# Allegro board FM85_AGILEX_PCIE_DK_CMC_ADI_REVC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_DDIMM_DQ50: length 84.9
  L16_SIG6 w0.081: v1(129.87,75.03) 129.47,74.34 129.47,74.33 arc(129.41,74.11) 129.47,73.88 129.47,73.87 arc(129.64,73.71) 129.87,73.65 129.87,73.65 arc(130.1,73.59) 130.27,73.42 arc(130.39,73.28) 130.56,73.2 130.74,73.2 131.13,73.59 131.55,73.59 131.99,74.02 132.49,74.02 132.86,73.65 134.03,73.65 134.44,73.85 134.44,73.86 arc(134.62,74.03) 134.87,74.1 arc(135.12,74.16) 135.3,74.34 135.3,74.35 arc(135.48,74.53) 135.73,74.6 135.73,74.6 arc(135.98,74.67) 136.17,74.85 136.17,74.85 arc(136.23,75.1) 136.17,75.35 arc(136.11,75.51) 136.11,75.69 136.67,76.85 136.64,77.1 arc(136.58,77.31) 136.62,77.52 arc(136.64,77.57) 136.64,77.61 arc(136.64,77.79) 136.64,77.97 arc(136.64,78.01) 136.62,78.06 arc(136.58,78.27) 136.64,78.48 arc(136.7,78.71) 136.64,78.94 136.64,78.94 arc(136.58,79.17) 136.64,79.4 arc(136.7,79.63) 136.64,79.86 arc(136.58,80.09) 136.64,80.31 136.64,80.32 arc(136.72,80.59) 136.67,80.86 arc(136.66,80.9) 136.63,80.93 136.58,80.97 136.58,88.52 135.33,89.77 134.2,89.77 129.76,94.21 126.66,94.21 125.73,95.14 125.73,97.41 122.55,100.59 122.54,100.59 122.32,100.81 122.32,100.83 120.61,102.53 115.86,102.53 115.37,103.02 114.7,103.02 114.38,103.34 114.38,103.45 114.17,103.67 113.87,103.67 112.97,104.57 112.97,104.91 112.71,105.17 111.83,105.17 110.46,106.54 99.64,106.54 99.33,106.85 95.94,106.85 95.66,106.57 93.63,106.57 93.08,107.11 84.6,107.11 v1(84.44,106.96)
DDR4_DDIMM_DQ51: length 83.1
  L16_SIG6 w0.081: v1(83.59,100.96) 83.61,100.98 83.61,105.71 83.69,105.79 84.03,105.79 84.11,105.71 84.11,105.55 84.19,105.46 85.16,105.46 85.25,105.38 85.25,105.21 85.17,105.13 84.19,105.13 84.11,105.05 84.11,104.87 84.19,104.79 85.12,104.79 85.21,104.71 85.21,104.55 85.11,104.46 84.19,104.46 84.11,104.38 84.11,104.2 84.19,104.12 84.95,104.12 85.03,104.04 85.03,103.87 84.95,103.79 84.19,103.79 84.11,103.71 84.11,101.32 84.84,100.59 93.99,100.59 94.38,100.21 101.18,100.21 101.96,99.43 101.96,98.98 103.34,97.6 105.28,97.6 106.28,96.6 106.28,95.59 107.41,94.46 107.79,94.46 108.74,93.5 108.74,93.23 109,92.97 111.94,92.97 112.03,93.05 112.03,93.4 112.11,93.48 112.28,93.48 112.36,93.4 112.36,93.05 112.44,92.97 112.61,92.97 112.7,93.05 112.7,93.4 112.78,93.48 112.95,93.48 113.03,93.4 113.03,93.05 113.11,92.97 113.29,92.97 113.37,93.05 113.37,93.4 113.45,93.48 113.62,93.48 113.7,93.4 113.7,93.05 113.78,92.97 115.45,92.97 115.54,93.05 115.54,93.41 115.62,93.49 115.79,93.49 115.87,93.41 115.87,93.08 115.95,93 116.3,93 116.51,93.2 116.81,93.2 117.01,93 117.09,93 117.17,93.08 117.17,93.41 117.25,93.49 117.42,93.49 117.51,93.41 117.51,93.05 117.59,92.97 117.76,92.97 117.89,93.1 118.13,93.1 118.26,92.97 118.51,92.97 118.55,92.93 118.56,92.93 118.79,92.69 118.79,92.68 120.13,91.35 121.82,91.35 123.39,89.78 125.44,89.78 129.92,85.29 129.92,84.66 129.59,84.33 129.59,84 130.06,83.53 130.06,82.62 129.9,82.47 129.9,81.11 129.39,80.6 arc(129.41,80.45) 129.47,80.32 129.48,80.31 arc(129.53,80.08) 129.47,79.86 arc(129.41,79.63) 129.47,79.41 129.47,79.4 arc(129.53,79.17) 129.47,78.94 arc(129.41,78.71) 129.47,78.48 arc(129.53,78.25) 129.47,78.02 arc(129.41,77.79) 129.47,77.56 129.47,77.56 arc(129.53,77.33) 129.47,77.1 v1(129.07,76.41)
DDR4_DDIMM_DQ52: length 83.9
  L16_SIG6 w0.081: v1(132.26,74.57) 133.76,74.57 134,74.6 arc(134.25,74.67) 134.43,74.85 134.44,74.85 arc(134.62,75.03) 134.86,75.1 134.87,75.1 arc(135.12,75.17) 135.3,75.35 arc(135.36,75.56) 135.32,75.78 135.32,76.31 135.47,76.46 135.84,77.1 arc(135.91,77.33) 135.85,77.56 135.84,77.56 arc(135.78,77.79) 135.84,78.02 arc(135.91,78.25) 135.84,78.48 135.84,78.48 arc(135.78,78.71) 135.84,78.94 arc(135.91,79.17) 135.85,79.4 135.84,79.4 arc(135.78,79.63) 135.84,79.86 arc(135.91,80.09) 135.85,80.31 135.83,80.34 arc(135.78,80.56) 135.84,80.78 arc(135.91,81) 135.85,81.23 135.84,81.24 135.54,81.54 135.54,88.81 134.92,89.44 133.99,89.44 129.98,93.44 126.94,93.44 124.83,95.55 124.83,97.76 122.27,100.31 122.16,100.31 121.83,99.99 121.72,99.99 121.59,100.11 121.59,100.23 121.92,100.55 121.92,100.67 121.8,100.79 121.68,100.79 121.36,100.46 121.24,100.46 121.12,100.58 121.12,100.7 121.45,101.03 121.45,101.14 121.15,101.44 116.24,101.44 116.16,101.35 116.16,100.88 116.08,100.8 115.91,100.8 115.83,100.88 115.83,101.35 115.74,101.44 115.57,101.44 115.49,101.35 115.49,100.88 115.41,100.8 115.24,100.8 115.15,100.88 115.15,101.35 115.07,101.44 114.67,101.44 114.41,101.7 114.3,101.7 113.77,101.17 113.65,101.17 113.53,101.29 113.53,101.4 114.06,101.93 114.06,102.05 113.94,102.17 113.82,102.17 113.29,101.64 113.18,101.64 113.06,101.76 113.06,101.88 113.59,102.41 113.59,102.52 113.46,102.64 113.35,102.64 112.82,102.12 112.7,102.12 112.58,102.24 112.58,102.35 113.11,102.88 113.11,103 112.64,103.47 112.07,103.47 111.51,102.9 111.39,102.9 111.27,103.02 111.27,103.14 111.84,103.71 111.84,103.82 111.71,103.94 111.6,103.94 111.03,103.38 110.92,103.38 110.79,103.5 110.79,103.61 111.36,104.18 111.36,104.3 111.24,104.42 111.13,104.42 110.56,103.85 110.44,103.85 110.32,103.97 110.32,104.09 110.89,104.66 110.89,104.77 109.9,105.76 98.71,105.76 98.49,105.99 97.02,105.99 96.78,105.74 92.62,105.74 v1(92.09,106.26)
DDR4_DDIMM_DQ53: length 82.8
  L16_SIG6 w0.081: v1(91.24,100.96) 91.16,101.05 85.62,101.05 84.92,101.74 84.92,103.14 85.59,103.81 85.59,105.07 86.96,106.44 89.36,106.44 89.96,105.83 89.96,104.29 90.27,103.99 94.62,103.99 95.5,103.11 96.8,103.11 97.41,103.73 103.2,103.73 103.76,104.3 104.96,104.3 105.23,104.03 106.63,104.03 108.59,102.06 109.37,102.06 110.31,101.12 110.31,100.81 110.53,100.59 110.9,100.59 112.12,99.37 112.12,99.19 112.79,98.52 113.51,98.52 113.74,98.29 113.74,97.88 114.22,97.4 115.58,97.4 115.66,97.48 115.66,97.98 115.74,98.06 115.92,98.06 116,97.98 116,97.48 116.08,97.4 120.51,97.4 121.97,95.94 121.97,95.56 125.3,92.22 129.03,92.22 133.93,87.32 133.93,84.42 133.48,83.97 133.48,80.42 arc(133.47,80.37) 133.45,80.32 133.45,80.31 arc(133.39,80.09) 133.45,79.86 arc(133.52,79.63) 133.46,79.4 133.45,79.4 arc(133.39,79.17) 133.45,78.94 arc(133.52,78.71) 133.46,78.48 133.45,78.48 arc(133.39,78.25) 133.45,78.02 arc(133.52,77.79) 133.45,77.56 133.45,77.56 arc(133.39,77.33) 133.45,77.1 133.51,77.04 133.51,76.71 133.05,76.26 v1(133.05,75.95)
DDR4_DDIMM_DQ54: length 84.3
  L16_SIG6 w0.081: v1(86.14,106.26) 86.14,106.26 86.65,106.77 91.26,106.77 91.68,106.36 91.68,105.9 92.2,105.37 93.63,105.37 93.8,105.2 99.88,105.2 100,105.32 108.35,105.32 112.34,101.34 112.79,101.34 113.71,100.42 114.49,100.42 114.57,100.34 114.57,99.81 114.65,99.73 114.83,99.73 114.91,99.81 114.91,100.34 114.99,100.42 115.16,100.42 115.24,100.34 115.24,99.81 115.33,99.73 115.5,99.73 115.58,99.81 115.58,100.34 115.66,100.42 115.83,100.42 115.91,100.34 115.91,99.81 116,99.73 116.17,99.73 116.25,99.81 116.25,100.34 116.33,100.42 116.5,100.42 116.59,100.34 116.59,99.85 116.67,99.77 116.83,99.77 116.92,99.86 116.92,100.34 117,100.42 117.17,100.42 117.26,100.34 117.26,99.85 117.34,99.77 117.5,99.77 117.59,99.86 117.59,100.34 117.67,100.42 117.84,100.42 117.93,100.34 117.93,99.81 118.01,99.73 118.18,99.73 118.26,99.81 118.26,100.34 118.34,100.42 118.52,100.42 118.6,100.34 118.6,99.81 118.68,99.73 118.85,99.73 118.93,99.81 118.93,100.34 119.01,100.42 119.19,100.42 119.27,100.34 119.27,99.81 119.35,99.73 119.52,99.73 119.6,99.81 119.6,100.34 119.68,100.42 120.12,100.42 123.97,96.57 123.97,94.52 124.59,93.9 124.7,93.9 125.03,94.23 125.15,94.23 125.27,94.11 125.27,94 124.94,93.67 124.94,93.55 125.06,93.43 125.17,93.43 125.51,93.76 125.62,93.76 125.74,93.64 125.74,93.52 125.41,93.19 125.41,93.08 125.59,92.89 130.05,92.89 135.21,87.74 135.21,81.59 134.97,81.36 134.97,80.87 arc(135.01,80.83) 135.05,80.78 135.06,80.77 arc(135.11,80.54) 135.05,80.32 135.04,80.31 arc(134.99,80.09) 135.05,79.86 arc(135.11,79.63) 135.05,79.4 135.04,79.4 arc(134.99,79.17) 135.05,78.94 arc(135.11,78.71) 135.05,78.48 135.05,78.48 arc(134.99,78.25) 135.05,78.02 arc(135.11,77.79) 135.05,77.56 135.05,77.56 arc(134.99,77.33) 135.05,77.1 135.06,76.91 135.06,76.81 arc(135,76.53) 134.84,76.29 134.17,75.62 arc(134.14,75.6) 134.1,75.58 133.81,75.52 133.33,75.03 v1(133.05,75.03)
DDR4_DDIMM_DQ55: length 82.7
  L16_SIG6 w0.081: v1(85.29,102.29) 85.29,103.04 85.42,103.17 85.54,103.17 86.46,102.25 86.57,102.25 86.7,102.37 86.7,102.49 85.78,103.41 85.78,103.52 86.02,103.77 86.14,103.77 87.05,102.86 87.17,102.86 87.29,102.98 87.29,103.1 86.21,104.18 86.21,104.29 86.21,104.29 86.21,104.41 85.93,104.69 85.93,104.8 86.05,104.92 86.17,104.92 86.44,104.65 86.56,104.65 86.68,104.77 86.68,104.88 86.4,105.16 86.4,105.27 86.53,105.4 86.64,105.4 86.92,105.12 87.03,105.12 87.39,105.47 87.39,105.85 87.64,106.1 88.9,106.1 89.15,105.86 89.15,105.22 89.06,105.14 88.98,105.14 88.9,105.06 88.9,104.88 88.98,104.8 89.06,104.8 89.15,104.72 89.15,104.55 89.06,104.47 88.98,104.47 88.9,104.39 88.9,104.21 88.98,104.13 89.06,104.13 89.15,104.05 89.15,103.92 89.42,103.66 94.42,103.66 94.45,103.63 94.46,103.63 95.31,102.78 96.94,102.78 97.56,103.39 106.55,103.39 110.06,99.89 110.92,99.89 111.31,99.5 111.31,99.21 112.79,97.73 113.41,97.73 114.12,97.03 120.34,97.03 121.43,95.94 121.43,95.43 123.44,93.42 123.44,93.3 123.22,93.08 123.22,92.97 123.34,92.84 123.45,92.84 123.68,93.07 123.79,93.07 123.91,92.94 123.91,92.83 123.69,92.61 123.69,92.49 123.81,92.37 123.93,92.37 124.15,92.59 124.26,92.59 124.39,92.47 124.39,92.36 124.16,92.13 124.16,92.02 124.29,91.9 124.4,91.9 124.62,92.12 124.74,92.12 124.97,91.89 128.78,91.89 133.35,87.32 133.35,84.31 133.14,84.11 133.14,81.17 arc(133.11,81.05) 133.03,80.96 132.87,80.87 arc(132.79,80.81) 132.73,80.73 arc(132.7,80.69) 132.67,80.65 132.6,80.57 arc(132.56,80.49) 132.6,80.4 132.77,80.23 arc(132.82,80.11) 132.77,80 132.56,79.79 arc(132.52,79.68) 132.56,79.58 132.79,79.35 arc(132.85,79.19) 132.79,79.02 132.67,78.91 arc(132.59,78.7) 132.67,78.49 132.73,78.43 arc(132.82,78.28) 132.81,78.1 arc(132.79,78.06) 132.77,78.03 arc(132.75,78) 132.73,77.97 arc(132.64,77.87) 132.56,77.76 arc(132.52,77.66) 132.56,77.55 arc(132.62,77.39) 132.61,77.22 arc(132.6,77.16) 132.6,77.11 132.6,76.79 arc(132.59,76.75) 132.56,76.72 v1(132.26,76.41)
DDR4_DDIMM_DQ56: length 76.3
  L16_SIG6 w0.081: v1(81.04,106.26) 81.04,105.46 80.17,104.58 79.45,104.58 79.37,104.5 79.37,104.32 79.29,104.24 79.11,104.24 79.03,104.32 79.03,104.5 78.95,104.58 78.78,104.58 78.7,104.5 78.7,104.05 78.61,103.96 78.44,103.96 78.36,104.05 78.36,104.5 78.28,104.58 78.11,104.58 78.03,104.5 78.03,104.05 77.94,103.96 77.77,103.96 77.69,104.05 77.69,104.5 77.61,104.58 77.18,104.58 76.51,103.91 76.51,101.94 77.79,100.67 79.42,100.67 79.61,100.85 80.51,100.85 80.67,100.69 80.67,99.19 80.72,99.15 80.72,98.24 82.61,96.34 85.41,96.34 86.41,95.34 95.36,95.34 96.98,93.72 97.35,93.72 97.7,93.37 97.7,92.49 103.61,86.58 104.77,86.58 105.77,85.58 110.13,85.58 110.42,85.29 110.42,84.63 110.97,84.08 114.36,84.08 114.95,84.68 114.95,84.72 122,84.72 124.59,82.13 124.59,81.23 124.66,81.16 124.66,80.88 124.69,80.78 arc(124.63,80.56) 124.67,80.35 124.69,80.31 arc(124.72,80.26) 124.74,80.21 arc(124.75,80.03) 124.69,79.86 arc(124.63,79.67) 124.66,79.47 arc(124.67,79.43) 124.69,79.4 124.69,79.4 arc(124.75,79.17) 124.69,78.94 arc(124.63,78.71) 124.69,78.48 124.69,78.48 arc(124.75,78.25) 124.69,78.02 arc(124.63,77.79) 124.69,77.56 124.69,77.56 arc(124.75,77.33) 124.69,77.1 124.68,77.08 arc(124.63,76.86) 124.69,76.64 v1(125.09,75.95)
DDR4_DDIMM_DQ57: length 77.5
  TOP w0.149: v1(79.93,100.11) 80.19,100.37 J2.275
  L16_SIG6 w0.076: 123.51,76.41 arc(123.65,76.38) 123.77,76.3 124.02,76.06 arc(124.05,76.03) 124.08,76.01 124.61,75.79 arc(124.65,75.78) 124.68,75.77 arc(124.79,75.72) 124.86,75.64 124.98,75.43 arc(125.06,75.24) v1(125.09,75.03)
  L16_SIG6 w0.081: 123.51,76.41 123.47,76.41 123.34,76.43 123.09,76.61 123.02,76.86 123.07,77.05 123.1,77.1 123.1,77.56 123.08,77.59 123.02,77.79 123.08,77.99 123.1,78.02 arc(123.16,78.25) 123.1,78.48 123.07,78.51 123.02,78.71 123.08,78.91 123.1,78.94 123.1,79.39 123.07,79.44 123.02,79.63 123.08,79.83 123.1,79.86 123.1,80.31 123.06,80.38 123.05,80.45 123.01,80.51 123.08,80.75 123.09,80.78 123.1,80.8 123.09,80.9 123.07,80.92 123.07,82.06 123.04,82.08 123.04,82.38 arc(123.04,82.42) 123.01,82.45 121.76,83.71 arc(121.48,83.89) 121.16,83.95 115.43,83.95 114.84,83.36 109.63,83.36 109.13,83.86 105.33,83.86 arc(105.29,83.86) 105.25,83.89 94.5,94.64 94.19,94.64 94.11,94.56 94.11,93.79 94.02,93.71 93.85,93.71 93.77,93.79 93.77,94.56 93.69,94.64 93.52,94.64 93.43,94.56 93.43,93.79 93.35,93.71 93.18,93.71 93.1,93.79 93.1,94.56 93.02,94.64 92.85,94.64 92.76,94.56 92.76,93.79 92.68,93.71 92.51,93.71 92.43,93.79 92.43,94.56 92.35,94.64 92.17,94.64 92.09,94.56 92.09,93.79 92.01,93.71 91.84,93.71 91.76,93.79 91.76,94.56 91.68,94.64 91.5,94.64 91.42,94.56 91.42,93.79 91.34,93.71 91.17,93.71 91.09,93.79 91.09,94.56 91.01,94.64 87.92,94.64 87.84,94.56 87.84,94.17 87.76,94.09 87.58,94.09 87.5,94.17 87.5,94.56 87.42,94.64 87.25,94.64 87.17,94.56 87.17,94.17 87.09,94.09 86.91,94.09 86.83,94.17 86.83,94.56 86.75,94.64 82.69,94.64 80.98,96.35 80.86,96.35 80.43,95.92 80.32,95.92 80.2,96.04 80.2,96.15 80.63,96.58 80.63,96.7 80.51,96.82 80.39,96.82 79.96,96.39 79.85,96.39 79.72,96.51 79.72,96.63 80.15,97.06 80.15,97.17 80.03,97.29 79.92,97.29 79.49,96.86 79.37,96.86 79.25,96.99 79.25,97.1 79.68,97.53 79.68,97.65 79.43,97.89 79.43,98.82 79.93,99.32 v1(79.93,100.11)
DDR4_DDIMM_DQ58: length 76.1
  L16_SIG6 w0.081: v1(75.09,105.57) 76,104.65 76,103.32 75.92,103.24 75.12,103.24 75.04,103.16 75.04,102.99 75.12,102.91 75.92,102.91 76,102.83 76,102.65 75.92,102.57 75.57,102.57 75.49,102.49 75.49,102.32 75.57,102.24 75.92,102.24 76,102.15 76,101.98 75.92,101.9 75.57,101.9 75.49,101.82 75.49,101.65 75.57,101.57 75.92,101.57 76,101.48 76,101.13 76.91,100.22 77.13,100.22 77.21,100.14 77.21,99.78 77.29,99.7 77.47,99.7 77.55,99.78 77.55,100.14 77.63,100.22 77.8,100.22 77.88,100.14 77.88,99.78 77.97,99.7 78.14,99.7 78.22,99.78 78.22,100.14 78.3,100.22 78.47,100.22 78.55,100.14 78.55,99.78 78.64,99.7 78.81,99.7 78.89,99.78 78.89,100.14 78.97,100.22 79.45,100.22 79.75,100.52 80.12,100.52 80.34,100.3 80.34,99.23 79.83,98.72 79.83,98.09 82.92,95 95.22,95 96.71,93.51 96.71,92.96 103.96,85.72 104.74,85.72 105.79,84.67 arc(105.82,84.65) 105.86,84.64 109.9,84.64 110.83,83.71 114.6,83.71 115.27,84.38 121.73,84.38 123.47,82.64 123.6,82.64 123.84,82.41 123.84,82.22 124.12,81.94 124.12,81.36 123.85,81.1 123.85,80.91 123.84,80.9 123.91,80.75 arc(123.95,80.54) 123.89,80.32 123.89,80.31 arc(123.83,80.09) 123.89,79.86 arc(123.95,79.63) 123.89,79.4 123.89,79.4 arc(123.83,79.17) 123.89,78.94 arc(123.95,78.71) 123.89,78.48 123.89,78.48 arc(123.83,78.25) 123.89,78.02 arc(123.95,77.79) 123.89,77.56 123.89,77.56 arc(123.83,77.33) 123.89,77.1 124.02,76.87 124.17,76.83 arc(124.26,76.78) 124.29,76.68 v1(124.29,76.41)
DDR4_DDIMM_DQ59: length 77.2
  L16_SIG6 w0.081: v1(124.29,74.57) 123.49,74.57 123.48,74.57 arc(123.26,74.63) 123.09,74.8 arc(122.93,74.97) 122.7,75.03 122.7,75.03 arc(122.47,75.09) 122.3,75.25 122.29,75.26 arc(122.13,75.43) 121.9,75.49 121.9,75.49 arc(121.67,75.55) 121.5,75.72 arc(121.44,75.95) 121.5,76.18 121.5,76.18 arc(121.56,76.41) 121.5,76.64 arc(121.44,76.86) 121.49,77.08 121.5,77.1 arc(121.56,77.33) 121.5,77.56 121.5,77.56 arc(121.44,77.79) 121.5,78.02 arc(121.56,78.25) 121.5,78.48 arc(121.44,78.71) 121.5,78.94 arc(121.56,79.17) 121.5,79.4 121.5,79.4 arc(121.44,79.63) 121.5,79.86 arc(121.56,80.09) 121.5,80.31 121.49,80.35 arc(121.44,80.57) 121.5,80.78 arc(121.55,80.89) 121.56,81.01 121.56,81.07 121.47,81.16 121.47,81.16 121.26,81.38 121.25,81.38 120.85,81.78 116.9,81.78 116.82,81.7 116.82,80.77 116.73,80.69 116.56,80.69 116.48,80.77 116.48,81.7 116.4,81.78 116.23,81.78 116.14,81.7 116.14,80.77 116.06,80.69 115.89,80.69 115.81,80.77 115.81,81.7 115.73,81.78 115.56,81.78 115.47,81.7 115.47,80.77 115.39,80.69 115.22,80.69 115.14,80.77 115.14,81.7 115.06,81.78 114.88,81.78 114.8,81.7 114.8,80.77 114.72,80.69 114.55,80.69 114.47,80.77 114.47,81.7 114.39,81.78 114.21,81.78 114.13,81.7 114.13,80.77 114.05,80.69 113.88,80.69 113.8,80.77 113.8,81.7 113.72,81.78 113.54,81.78 113.46,81.7 113.46,80.77 113.38,80.69 113.21,80.69 113.13,80.77 113.13,81.7 113.05,81.78 105.57,81.78 95.21,92.14 81.98,92.14 76.83,97.29 76.29,97.29 74.24,99.35 v1(74.24,100.96)
DDR4_DDIMM_DQ60: length 76.4
  L16_SIG6 w0.081: v1(128.27,75.03) 128.67,75.72 arc(128.73,75.95) 128.67,76.18 arc(128.61,76.4) 128.67,76.63 128.68,76.66 arc(128.73,76.88) 128.67,77.1 arc(128.61,77.33) 128.67,77.56 128.67,77.56 arc(128.73,77.79) 128.67,78.02 arc(128.61,78.25) 128.67,78.48 arc(128.73,78.71) 128.67,78.94 arc(128.61,79.17) 128.67,79.4 128.68,79.41 arc(128.73,79.63) 128.67,79.86 128.63,79.9 128.63,80.17 128.21,80.59 128.21,83.41 127.92,83.7 127.92,84.76 125,87.69 123.75,87.69 121.33,90.1 112.28,90.1 112.2,90.19 112.2,90.74 112.12,90.82 111.94,90.82 111.86,90.74 111.86,90.19 111.78,90.1 111.61,90.1 111.53,90.19 111.53,90.74 111.44,90.82 111.27,90.82 111.19,90.74 111.19,90.19 111.11,90.1 110.94,90.1 110.86,90.19 110.86,90.74 110.77,90.82 110.6,90.82 110.52,90.74 110.52,90.19 110.44,90.1 110.27,90.1 110.19,90.19 110.19,90.74 110.1,90.82 109.93,90.82 109.85,90.74 109.85,90.19 109.77,90.1 109.6,90.1 109.51,90.19 109.51,90.74 109.43,90.82 109.26,90.82 109.18,90.74 109.18,90.19 109.1,90.1 108.93,90.1 108.84,90.19 108.84,90.74 108.76,90.82 108.59,90.82 108.51,90.74 108.51,90.19 108.43,90.1 108.14,90.1 104.38,93.86 104.38,94.08 104.16,94.3 103.72,94.3 101.7,96.31 100.94,96.31 100.19,97.06 100.19,98.27 98.71,99.74 94.18,99.74 93.8,100.13 83.77,100.13 83.13,100.77 83.13,106.57 v1(82.74,106.96)
DDR4_DDIMM_DQ61: length 75.6
  TOP w0.149: J2.273 81.89,100.95 82.41,100.43 v1(82.41,100.41)
  L16_SIG6 w0.081: v1(127.48,76.41) 127.08,77.1 arc(127.02,77.33) 127.08,77.56 127.08,77.56 arc(127.14,77.79) 127.08,78.02 arc(127.02,78.25) 127.08,78.48 127.08,78.48 127.08,80.9 127.28,81.1 127.28,82.92 127.05,83.15 126.75,83.15 126.72,83.18 126.66,83.18 126.43,83.41 126.43,83.47 125.03,84.87 125.03,85.45 121.64,88.84 111.67,88.84 111.59,88.76 111.59,88.39 111.51,88.31 111.33,88.31 111.25,88.39 111.25,89.21 111.15,89.31 111,89.31 110.92,89.23 110.92,88.39 110.83,88.31 110.66,88.31 110.58,88.39 110.58,89.21 110.48,89.31 110.33,89.31 110.25,89.23 110.25,88.41 110.16,88.33 109.99,88.33 109.91,88.41 109.91,89.21 109.81,89.31 109.66,89.31 109.57,89.23 109.57,88.39 109.49,88.31 109.32,88.31 109.24,88.39 109.24,89.21 109.14,89.31 108.99,89.31 108.9,89.23 108.9,88.4 108.82,88.32 108.65,88.32 108.57,88.4 108.57,89.21 108.47,89.31 108.32,89.31 108.23,89.23 108.23,88.4 108.15,88.32 107.98,88.32 107.9,88.4 107.9,89.21 107.8,89.31 107.64,89.31 107.56,89.23 107.56,88.62 107.48,88.54 107.31,88.54 107.23,88.62 107.23,89.5 106.9,89.83 106.79,89.83 106.44,89.48 106.32,89.48 106.2,89.6 106.2,89.72 106.55,90.07 106.55,90.18 106.43,90.31 106.31,90.31 105.96,89.96 105.85,89.96 105.73,90.08 105.73,90.19 106.08,90.54 106.08,90.66 101.59,95.14 100.12,95.14 97.07,98.19 94.63,98.19 94.18,98.64 93.5,98.64 93.2,98.94 87.04,98.94 86.96,99.02 86.96,99.19 86.88,99.27 86.71,99.27 86.63,99.19 86.63,99.02 86.54,98.94 85.41,98.94 85.33,99.02 85.33,99.29 85.25,99.38 85.08,99.38 85,99.29 85,99.02 84.91,98.94 83.91,98.94 82.43,100.41 v1(82.41,100.41)
DDR4_DDIMM_DQ62: length 76.3
  L16_SIG6 w0.081: v1(128.27,75.95) 127.88,76.64 arc(127.81,76.86) 127.87,77.08 127.88,77.1 arc(127.94,77.33) 127.88,77.56 127.88,77.56 arc(127.81,77.79) 127.88,78.02 arc(127.94,78.25) 127.88,78.48 arc(127.81,78.71) 127.88,78.94 127.88,83.07 127.22,83.73 127.22,83.74 127.08,83.88 127.08,84.52 124.32,87.29 123.67,87.29 121.27,89.7 115.04,89.7 114.96,89.61 114.96,89.29 114.88,89.21 114.71,89.21 114.63,89.29 114.63,89.61 114.54,89.7 114.37,89.7 114.29,89.61 114.29,89.29 114.21,89.21 114.04,89.21 113.96,89.29 113.96,89.61 113.87,89.7 113.7,89.7 113.62,89.61 113.62,89.29 113.54,89.21 113.37,89.21 113.28,89.29 113.28,89.61 113.2,89.7 113.03,89.7 112.95,89.61 112.95,89.29 112.87,89.21 112.7,89.21 112.61,89.29 112.61,89.61 112.53,89.7 107.63,89.7 101.78,95.54 100.34,95.54 98.82,97.07 98.82,97.47 98.63,97.66 98.22,97.66 97.28,98.61 95.67,98.61 95.24,99.04 94.01,99.04 93.95,98.97 93.64,98.97 93.42,99.19 93.42,99.39 93.09,99.72 83.71,99.72 82.84,100.59 arc(82.5,101.1) 82.38,101.71 82.38,104.54 arc(82.32,105.17) 82.17,105.79 arc(82.15,105.92) 82.19,106.05 arc(82.22,106.24) 82.14,106.42 arc(82.14,106.42) 82.14,106.42 arc(82.12,106.44) 82.11,106.46 81.87,106.67 arc(81.82,106.7) 81.75,106.72 81.08,106.72 arc(80.77,106.58) 80.63,106.27 80.63,105.93 arc(80.4,105.38) 79.85,105.15 79.22,105.15 arc(79.09,105.14) 78.97,105.1 arc(78.84,105.07) 78.72,105.06 77.95,105.06 arc(77.86,105.06) 77.76,105.07 arc(77.65,105.1) 77.53,105.14 arc(77.51,105.14) 77.48,105.15 arc(77.41,105.17) 77.35,105.22 arc(77.33,105.23) 77.31,105.25 arc(77.2,105.32) 77.11,105.41 77,105.52 arc(76.9,105.55) v1(76.79,105.57)
DDR4_DDIMM_DQ63: length 76.6
  TOP w0.149: J2.280 75.94,102.37 76.61,103.04 v1(77.12,103.04)
  L16_SIG6 w0.081: v1(127.48,74.57) 127.11,74.94 127.11,75.79 127.18,75.87 127.18,76.02 127.02,76.19 126.99,76.3 126.8,76.41 126.71,76.5 126.53,76.5 126.27,76.76 126.27,81.28 126.43,81.44 arc(126.45,81.48) 126.46,81.52 126.46,82.52 126.39,82.59 126.39,82.88 124.7,84.57 124.7,85.31 122.57,87.44 119.73,87.44 119.25,87.92 arc(119.2,87.96) 119.13,87.97 107.48,87.97 arc(107.44,87.97) 107.4,87.97 106.94,88.05 arc(106.2,88.29) 105.57,88.75 104.57,89.75 104.57,89.86 105.18,90.48 105.18,90.59 105.06,90.72 104.95,90.72 104.33,90.1 104.22,90.1 104.09,90.22 104.09,90.34 104.71,90.95 104.71,91.07 104.59,91.19 104.47,91.19 103.86,90.58 103.74,90.58 103.62,90.7 103.62,90.81 104.23,91.43 104.23,91.54 104.11,91.67 104,91.67 103.38,91.05 103.27,91.05 101.11,93.21 101.11,93.6 96.86,97.86 94.49,97.86 94.04,98.3 93.36,98.3 93.21,98.46 89.95,98.46 89.68,98.19 83.52,98.19 83.15,98.56 83.15,98.9 81.98,100.07 81.98,101.97 80.86,103.09 77.18,103.09 v1(77.12,103.04)
DDR4_DDIMM_DQ64: length 46
  TOP w0.149: v1(149.44,103.75) 153.98,103.75 154.99,104.77 J2.49
  L03_SIG1 w0.081: v1(149.44,103.75) 149.44,102.55 149.36,102.47 149.03,102.47 148.95,102.39 148.95,102.22 149.03,102.14 149.36,102.14 149.44,102.05 149.44,98.68 145.96,95.2 145.19,95.2 144.43,94.44 144.43,93.72 142.51,91.8 135.65,91.8 134.64,90.78 134.13,90.78 131.73,88.39 131.73,87.2 131.1,86.57 131.1,85.96 130.68,85.54 130.51,85.54 129.16,84.2 129.16,83.73 128.98,83.54 128.98,82.43 128.68,82.13 128.68,81.03 arc(128.68,80.97) 128.69,80.91 arc(128.7,80.87) 128.72,80.82 arc(128.75,80.57) 128.68,80.33 arc(128.68,80.33) 128.67,80.32 128.27,79.92 v2(128.27,79.63)
DDR4_DDIMM_DQ65: length 44.1
  TOP w0.149: v1(148.68,100.32) 153.8,100.32 154.14,100.65 J2.194
  L03_SIG1 w0.081: v1(148.68,100.32) 148.59,100.22 148.59,98.5 147.74,97.65 147.13,97.65 146.91,97.43 146.91,96.83 145.62,95.53 145.05,95.53 144.21,94.7 143.78,94.7 143.55,94.46 143.55,93.77 142.75,92.97 141.67,92.97 141.58,92.89 141.58,92.25 141.5,92.17 141.33,92.17 141.25,92.25 141.25,92.89 141.17,92.97 141,92.97 140.91,92.89 140.91,92.25 140.83,92.17 140.66,92.17 140.58,92.25 140.58,92.89 140.5,92.97 140.32,92.97 140.24,92.89 140.24,92.25 140.16,92.17 139.99,92.17 139.91,92.25 139.91,92.89 139.83,92.97 137.87,92.97 137.03,92.14 135.52,92.14 134.5,91.12 133.99,91.12 131.4,88.53 131.4,87.48 130.24,86.31 130.24,85.89 128.83,84.48 128.83,83.87 128.64,83.68 128.64,82.62 128.31,82.29 128.31,80.63 v2(128.27,80.55)
DDR4_DDIMM_DQ66: length 43.4
  L03_SIG1 w0.081: v2(127.48,81.01) 127.48,83.81 127.08,84.2 127.08,85 128.69,86.61 128.81,86.61 129.07,86.35 129.18,86.35 129.31,86.47 129.31,86.58 129.05,86.84 129.05,86.96 129.17,87.08 129.28,87.08 129.54,86.82 129.66,86.82 129.78,86.94 129.78,87.06 129.52,87.32 129.52,87.43 129.64,87.55 129.76,87.55 130.02,87.3 130.13,87.3 130.25,87.42 130.25,87.53 129.99,87.79 129.99,88.1 134.79,92.9 134.79,93.44 135.31,93.95 136.5,93.95 136.6,94.05 138.29,94.05 138.38,93.95 138.99,93.95 139.14,94.1 140.46,94.1 141.19,94.84 141.71,94.84 143.56,96.69 143.68,96.69 144.12,96.25 144.23,96.25 144.35,96.37 144.35,96.49 143.92,96.93 143.92,97.04 144.71,97.83 145.49,97.83 146.8,99.15 146.92,99.15 147.04,99.03 147.15,99.03 147.27,99.15 147.27,99.27 147.15,99.39 147.15,99.5 147.75,100.1 147.75,101.05 148.51,101.8 148.51,106.43 v1(149.04,106.96)
DDR4_DDIMM_DQ67: length 45.7
  L03_SIG1 w0.081: v2(127.48,79.17) 127.88,79.86 arc(127.94,80.09) 127.88,80.31 127.86,80.34 arc(127.81,80.56) 127.88,80.78 127.95,80.95 127.95,82.2 arc(127.94,82.23) 127.93,82.26 arc(127.92,82.3) 127.91,82.34 127.91,84.54 128.19,84.81 128.19,84.93 127.91,85.21 127.91,85.33 128.03,85.45 128.14,85.45 128.47,85.13 128.58,85.13 128.7,85.25 128.7,85.37 128.38,85.69 128.38,85.8 128.5,85.92 128.62,85.92 128.9,85.64 129.02,85.64 131.06,87.69 131.06,88.67 133.85,91.46 134.04,91.46 135.12,92.54 135.12,93.18 135.56,93.62 136.24,93.62 136.32,93.54 136.32,93.34 136.24,93.26 135.86,93.26 135.78,93.18 135.78,93.02 135.88,92.92 136.24,92.92 136.32,92.84 136.32,92.58 136.4,92.49 136.57,92.49 136.65,92.58 136.65,93.63 136.74,93.72 138.15,93.72 138.55,93.31 139.23,93.31 139.64,93.72 140.7,93.72 140.96,93.45 141.78,93.45 142.01,93.68 142.13,93.68 142.49,93.32 142.6,93.32 142.72,93.45 142.72,93.56 142.36,93.92 142.36,94.04 142.61,94.29 142.61,94.74 143.78,95.91 145.25,95.91 145.35,96.02 145.35,96.13 144.74,96.74 144.74,96.86 144.87,96.98 144.98,96.98 145.59,96.37 145.71,96.37 145.83,96.49 145.83,96.6 145.22,97.22 145.22,97.33 145.34,97.45 145.45,97.45 146.07,96.84 146.18,96.84 146.58,97.24 146.58,97.57 146.99,97.99 147.35,97.99 147.86,98.49 147.86,99.48 148.19,99.81 v1(148.19,100.96)
DDR4_DDIMM_DQ68: length 45.9
  L03_SIG1 w0.081: v2(131.46,79.63) 132.42,79.63 132.89,80.1 133.13,80.1 133.67,80.64 134,80.64 134.22,80.86 134.22,81.93 134.02,82.13 134.02,83.01 135.51,84.51 135.51,87.41 137.23,89.13 141.55,89.13 141.55,89.13 143.62,89.13 143.62,89.14 144.35,89.14 147.29,92.07 148.83,92.07 149.44,92.68 149.44,93.79 152.3,96.65 153.54,96.65 154.6,97.71 154.6,97.78 154.6,97.78 154.6,98.58 155.78,99.77 155.78,101.32 156.24,101.78 156.24,103.03 156.16,103.11 155.96,103.11 155.88,103.19 155.88,103.37 155.96,103.45 156.16,103.45 156.24,103.53 156.24,103.7 156.16,103.78 155.87,103.78 155.79,103.86 155.79,104.04 155.87,104.12 156.16,104.12 156.24,104.2 156.24,106.51 v1(156.69,106.96)
DDR4_DDIMM_DQ69: length 45.3
  TOP w0.149: J2.192 155.84,100.59 155.62,100.36 v1(155.28,100.36)
  L03_SIG1 w0.081: v2(131.46,80.55) 132.44,80.55 133.68,81.8 133.68,83.15 134.1,83.56 134.1,87.41 134.43,87.74 135.25,87.74 136.98,89.47 137.09,89.47 137.09,89.47 141.69,89.47 141.69,89.47 143.48,89.47 143.48,89.47 144.21,89.47 147.3,92.56 148.44,92.56 148.62,92.73 148.62,93.42 149.11,93.91 149.11,93.93 149.71,94.53 149.71,94.65 149.51,94.85 149.51,94.96 149.63,95.08 149.75,95.08 149.95,94.88 150.06,94.88 150.18,95 150.18,95.12 149.98,95.32 149.98,95.44 150.11,95.56 150.22,95.56 150.42,95.36 150.54,95.36 150.66,95.48 150.66,95.59 150.46,95.79 150.46,95.91 150.58,96.03 150.69,96.03 150.89,95.83 151.01,95.83 151.13,95.95 151.13,96.07 150.93,96.27 150.93,96.38 151.05,96.51 151.17,96.51 151.37,96.31 151.48,96.31 151.61,96.43 151.61,96.54 151.41,96.74 151.41,96.86 151.53,96.98 151.64,96.98 151.84,96.78 151.96,96.78 152.16,96.98 152.18,96.98 152.19,96.99 153.08,96.99 153.7,97.61 153.7,98.2 153.92,98.42 153.92,98.54 153.67,98.79 153.67,98.91 153.79,99.03 153.91,99.03 154.16,98.78 154.27,98.78 154.4,98.9 154.4,99.01 154.14,99.27 154.14,99.38 154.27,99.5 154.38,99.5 154.63,99.25 154.75,99.25 154.87,99.37 154.87,99.49 154.14,100.22 154.14,100.34 154.25,100.46 154.37,100.46 155.11,99.72 155.22,99.72 155.28,99.78 v1(155.28,100.36)
DDR4_DDIMM_DQ70: length 45
  TOP w0.149: v1(153.68,104.42) 150.82,104.42 150.56,104.68 150.56,106.08 J2.54
  L03_SIG1 w0.081: v1(153.68,104.42) 154.22,103.88 154.22,103.53 154.13,103.45 153.75,103.45 153.67,103.37 153.67,103.19 153.75,103.11 154.13,103.11 154.22,103.03 154.22,102.86 154.13,102.78 153.75,102.78 153.67,102.7 153.67,102.52 153.75,102.44 154.13,102.44 154.22,102.36 154.22,101.44 153.44,100.66 153.44,99.78 151.81,98.16 151.62,98.16 146.98,93.51 146.98,93.18 143.94,90.14 143.2,90.14 143.2,90.14 141.97,90.14 141.97,90.14 136.82,90.14 136.81,90.14 136.67,90.14 135.63,89.09 134.79,89.09 133.43,87.73 133.43,83.84 133.01,83.43 133.01,83.22 131.04,81.26 130.91,81.26 130.68,81.03 v2(130.68,81.03)
DDR4_DDIMM_DQ71: length 46.5
  TOP w0.149: J2.199 149.89,102.79 150.3,103.2 v1(154.71,103.2)
  L03_SIG1 w0.081: v2(130.68,79.16) 130.68,79.18 131.09,79.59 131.09,80.7 133.35,82.96 133.35,83.29 133.76,83.7 133.76,87.55 134.29,88.08 135.09,88.08 136.82,89.8 136.95,89.8 136.96,89.8 141.83,89.8 141.83,89.8 143.34,89.8 143.34,89.81 144.07,89.81 147.28,93.02 147.51,93.02 147.71,93.21 147.71,93.72 151.54,97.55 152.61,97.55 152.84,97.78 152.84,98.59 153.77,99.52 153.77,100.49 154.71,101.43 154.71,101.81 154.79,101.89 155.21,101.89 155.29,101.98 155.29,102.15 155.21,102.23 154.79,102.23 154.71,102.31 v1(154.71,103.2)
DDR4_DDIMM_DQS_N0: length 101.8
  L03_SIG1 w0.076: v2(136.26,78.74) 136.27,78.69 136.5,78.56 136.53,78.46 136.47,78.36 136.42,78.31 136.42,77.99 136.71,77.7 137.38,77.7 137.8,78.12 137.97,78.12 138.38,77.72 138.39,77.72 138.41,77.7 138.76,77.7 138.77,77.7 138.79,77.7 139,77.48 139,77.48 139.23,77.25 139.48,77.25 139.6,77.25 139.69,77.18 139.84,76.88 139.86,76.82 139.88,76.8 139.89,76.79 139.92,76.76
  L03_SIG1 w0.081: 139.92,76.76 140.39,76.3 142.09,76.3 142.6,76.81 143.4,76.81 143.83,76.37 144.37,76.37 144.37,76.37 150.59,76.37 150.97,75.98 155.23,75.98 156.73,77.48 156.85,77.48 158.45,75.88 158.71,75.88 158.94,76.11 158.94,76.38 157.34,77.98 157.34,78.09 157.46,78.22 157.58,78.22 159.18,76.61 159.45,76.61 159.68,76.84 159.68,77.11 158.07,78.71 158.07,78.83 158.2,78.95 158.31,78.95 159.91,77.35 160.18,77.35 160.41,77.58 160.41,77.84 158.81,79.44 158.81,79.56 158.93,79.68 159.04,79.68 160.65,78.08 160.91,78.08 161.14,78.31 161.14,78.58 158.87,80.85 158.87,80.97 158.99,81.09 159.1,81.09 161.38,78.81 161.64,78.81 161.87,79.04 161.87,79.31 160.37,80.82 160.37,80.93 160.79,81.36 161.89,81.36 161.97,81.28 161.97,80.41 162.16,80.22 162.49,80.22 162.67,80.41 162.67,81.28 162.76,81.36 162.93,81.36 163.01,81.28 163.01,79.84 163.2,79.65 163.51,79.65 163.71,79.85 163.71,81.28 163.79,81.36 163.96,81.36 164.05,81.28 164.05,80.5 164.23,80.31 164.56,80.31 164.75,80.5 164.75,81.28 164.83,81.36 166.01,81.36 166.57,81.92 166.57,85.74 167.78,86.94 167.78,87.58 172.36,92.17 173.04,92.17 174.17,93.3 174.17,93.61 176.2,95.63 179.16,95.63 179.7,95.63 181.22,97.15 182.3,97.15 182.93,97.78 186.95,97.78 189.5,100.33 189.5,100.75 v1(189.84,101.09)
DDR4_DDIMM_DQS_N1: length 72.9
  L05_SIG2 w0.081: v1(133.85,81.01) 134.08,80.88 arc(134.1,80.87) 134.11,80.87 arc(134.13,80.87) 134.15,80.87 134.21,80.9 arc(134.22,80.91) 134.23,80.93 134.28,81 134.28,81 134.29,81.01 134.3,81.03 134.3,81.05 arc(134.31,81.08) 134.3,81.12 134.19,81.51 arc(134.16,81.56) 134.13,81.61 133.45,82.28 arc(133.37,82.4) 133.34,82.54 133.34,83.67 133.32,83.75 133.3,83.8 133.19,84.05 arc(133.17,84.12) 133.16,84.2 133.16,88.96 arc(133.19,89.07) 133.25,89.17 135.26,91.18 135.34,91.23 135.38,91.27 135.9,91.27 143.49,91.27 148.28,96.06 156.45,96.06 157.14,95.37 157.61,95.37 158.3,96.06 159.32,96.06 159.51,95.87 159.51,95.22 159.59,95.14 159.76,95.14 159.84,95.22 159.84,95.87 160.03,96.06 160.36,96.06 160.55,95.87 160.55,95.26 160.63,95.18 160.79,95.18 160.88,95.27 160.88,95.87 161.07,96.06 168.12,96.06 168.89,96.83 173.85,96.83 173.94,96.74 176.68,96.74 178.28,98.34 178.28,99.33 178.47,99.52 180.05,99.52 180.13,99.6 180.13,99.77 180.05,99.85 178.47,99.85 178.28,100.04 178.28,102.29 178.95,102.96 179.55,102.96 180.12,102.38 180.12,101.17 180.33,100.96 v1(180.49,100.96)
DDR4_DDIMM_DQS_N2: length 53
  L16_SIG6 w0.076: 141.48,80.43 141.48,80.42 141.48,80.41 141.48,80.17 140.81,79.5 140.81,79.16 140.7,78.93 140.66,78.89 arc(140.65,78.89) 140.65,78.88 arc(140.62,78.73) 140.66,78.59 140.71,78.52 arc(140.84,78.39) 141.02,78.34 141.03,78.34 arc(141.19,78.38) 141.31,78.48 141.29,78.55 v1(141.02,78.71)
  L16_SIG6 w0.081: 141.48,80.43 141.48,81.14 141.68,81.34 141.87,81.34 144.46,83.93 144.46,85.6 148.68,89.82 159.05,89.82 162.35,93.12 162.35,93.12 162.97,93.74 164.89,93.74 165.31,94.16 165.31,94.43 164.77,94.97 164.77,95.09 164.89,95.21 165.01,95.21 165.55,94.67 165.82,94.67 166.04,94.9 166.04,95.16 165.5,95.71 165.5,95.82 165.62,95.94 165.74,95.94 166.28,95.4 166.55,95.4 166.78,95.63 166.78,95.89 166.23,96.44 166.23,96.55 166.36,96.68 166.47,96.68 167.01,96.13 167.28,96.13 167.51,96.36 167.51,96.63 166.97,97.17 166.97,97.29 167.09,97.41 167.2,97.41 167.75,96.86 168.01,96.86 168.24,97.09 168.24,97.36 167.7,97.9 167.7,98.02 167.82,98.14 167.94,98.14 168.17,97.91 168.85,97.91 169.13,98.19 169.13,98.6 169.29,98.76 169.29,98.94 169.13,99.09 169.13,99.27 169.29,99.43 169.29,99.61 169.13,99.76 169.13,99.98 169.44,100.29 170.62,100.29 170.81,100.48 170.81,100.88 170.89,100.96 v1(171.14,100.96)
DDR4_DDIMM_DQS_N3: length 43.4
  L03_SIG1 w0.081: v1(161.79,102.36) 161.48,102.67 arc(161.47,102.7) 161.46,102.73 161.46,102.81 arc(161.33,103.12) 161.02,103.25 160.09,103.25 arc(159.72,103.09) 159.56,102.72 159.56,99.81 arc(159.62,99.49) 159.8,99.22 159.98,99.04 arc(160.12,98.83) 160.17,98.58 arc(160.25,98.09) 160.48,97.65 arc(160.57,97.47) 160.61,97.27 160.61,96.56 arc(160.51,96.08) 160.24,95.68 159.2,94.64 arc(158.85,94.11) 158.72,93.49 158.72,93.35 arc(158.7,93.17) 158.63,93.01 arc(158.58,92.93) 158.52,92.86 156.9,91.24 156.78,91.24 156.38,91.64 156.12,91.64 155.89,91.41 155.89,91.14 156.29,90.74 156.29,90.63 156.16,90.51 156.05,90.51 155.65,90.9 155.39,90.9 155.16,90.67 155.16,90.41 155.55,90.01 155.55,89.89 155.43,89.77 155.32,89.77 154.92,90.17 154.65,90.17 154.42,89.94 154.42,89.67 154.82,89.28 154.82,89.16 154.69,89.03 arc(154.02,88.58) 153.22,88.42 148.19,88.42 arc(147.86,88.36) 147.59,88.18 145.29,85.87 arc(145.09,85.57) 145.02,85.22 145.02,84.38 arc(144.97,84.13) 144.82,83.91 144.02,83.11 arc(144,83.09) 143.97,83.07 143.16,82.39 arc(143.13,82.37) 143.09,82.36 141.21,82.36 arc(141.15,82.35) 141.08,82.34 140.86,82.26 arc(140.35,81.98) 139.9,81.61 139.62,81.33 arc(139.53,81.27) 139.43,81.25 arc(139.3,81.22) 139.19,81.15 139.07,81.03 arc(139.05,81.01) 139.03,80.98 138.99,80.92 arc(138.94,80.88) 138.88,80.89 v2(138.63,81.03)
DDR4_DDIMM_DQS_N4: length 66.6
  L14_SIG5 w0.076: v1(131.46,78.71) 131.52,78.65 arc(131.71,78.61) 131.8,78.77 arc(131.77,78.92) 131.7,79.05 131.7,79.05 arc(131.63,79.2) 131.6,79.36 131.6,80.14 131.6,80.14 131.6,80.16
  L14_SIG5 w0.081: 131.6,80.16 131.6,80.65 arc(131.65,81.02) 131.81,81.36 arc(131.86,81.42) 131.91,81.48 arc(131.94,81.51) 131.97,81.55 132.07,81.65 arc(132.16,81.79) 132.19,81.95 132.19,84.33 131.64,84.89 131.64,90 128.18,93.45 128.18,97.73 125.91,100.01 124.09,100.01 123.83,100.26 123.83,101.42 123.75,101.5 123.56,101.5 123.5,101.44 123.5,100.19 123.31,100.01 122.49,100.01 122.13,100.36 122.13,101.28 122.43,101.58 122.43,102.67 122.2,102.9 119.01,102.9 118.59,102.49 116.56,102.49 116.31,102.73 113.08,102.73 112.86,102.94 112.86,103.19 112.65,103.41 112.65,103.98 112.54,104.09 112.18,104.09 112.1,104.01 112.1,102.62 111.91,102.43 111.58,102.43 111.4,102.62 111.4,104 111.3,104.09 111.14,104.09 111.06,104.01 111.06,102.62 110.87,102.43 110.55,102.43 110.36,102.62 110.36,104 110.27,104.09 110.11,104.09 110.02,104.01 110.02,102.62 109.84,102.43 109.51,102.43 109.32,102.62 109.32,104 109.23,104.09 109.07,104.09 108.99,104.01 108.99,102.62 108.8,102.43 108.48,102.43 108.29,102.62 108.29,104 108.2,104.09 107.75,104.09 107.59,103.93 107.42,103.93 107.26,104.09 107.08,104.09 106.92,103.93 106.75,103.93 106.59,104.09 106.46,104.09 106.23,103.86 106.23,103.51 106.35,103.39 106.35,103.18 106.23,103.05 106.23,102.84 106.35,102.72 106.35,102.51 106.23,102.38 106.23,102.17 106.35,102.05 106.35,101.84 106.23,101.71 106.23,101.5 v1(106.58,101.15)
DDR4_DDIMM_DQS_N5: length 67.4
  L14_SIG5 w0.076: 127.08,81.31 127.08,81.3 127.08,81.3 127.08,80.41 126.97,80.3 126.97,79.88 127.18,79.66 127.18,78.84 127.04,78.59 126.94,78.56 v1(126.68,78.71)
  L14_SIG5 w0.081: v1(97.19,100.96) 97.05,100.96 96.89,101.13 96.89,101.35 97.04,101.5 97.33,101.5 97.67,101.16 97.67,100.32 97.75,100.24 97.75,100.07 97.93,99.9 98.09,99.9 98.5,99.49 98.5,99.32 98.66,99.15 98.83,99.15 99.36,98.63 99.36,98.27 99.2,98.11 99.2,97.93 99.36,97.77 99.36,97.59 99.2,97.43 99.2,97.26 99.36,97.1 99.36,96.92 99.2,96.76 99.2,96.59 99.36,96.43 99.36,96.25 99.2,96.09 99.2,95.92 99.36,95.76 99.36,95.33 99.9,94.8 103.74,94.8 103.92,94.98 103.92,96.51 104.01,96.59 104.18,96.59 104.26,96.51 104.26,94.98 104.45,94.8 104.77,94.8 104.96,94.98 104.96,96.51 105.04,96.59 105.21,96.59 105.3,96.51 105.3,94.98 105.48,94.8 105.81,94.8 106,94.98 106,96.51 106.08,96.59 106.25,96.59 106.33,96.51 106.33,94.98 106.52,94.8 107.62,94.8 107.81,94.98 107.81,95.88 107.89,95.96 108.06,95.96 108.14,95.88 108.14,94.98 108.33,94.8 108.65,94.8 108.84,94.98 108.84,95.88 108.92,95.96 109.1,95.96 109.18,95.88 109.18,94.98 109.37,94.8 110.09,94.8 110.89,95.6 110.89,96.21 110.97,96.29 112.5,96.29 112.73,96.06 112.73,95.41 113.31,94.82 118.23,94.82 118.71,94.34 118.71,93.85 118.96,93.61 118.96,91.66 119.38,91.24 124.48,91.24 126.9,88.82 126.9,84.13 127.27,83.76 127.27,82.32 127.08,82.13 127.08,81.31
DDR4_DDIMM_DQS_N6: length 83.5
  L16_SIG6 w0.076: 130.97,79.16 130.87,79.05 arc(130.77,78.83) 130.84,78.59 arc(130.86,78.56) 130.89,78.54 arc(130.95,78.48) 131,78.41 arc(131.03,78.23) 130.97,78.05 arc(130.91,77.87) 130.95,77.68 131,77.58 arc(131.04,77.35) 130.98,77.13 arc(130.92,76.8) 131.07,76.49 arc(131.09,76.46) 131.09,76.42 arc(131.09,76.4) 131.08,76.38 arc(131.08,76.38) 131.07,76.37 131.07,76.37 arc(131.05,76.34) 131.04,76.31 131.02,76.29 arc(130.98,76.25) 130.92,76.26 v1(130.66,76.41)
  L16_SIG6 w0.081: v1(87.82,101.74) 87.79,101.71 87.47,101.71 87.35,101.83 87.35,102.08 87.6,102.33 93.92,102.33 95.1,101.15 95.71,101.15 95.89,101.34 97.7,101.34 97.83,101.21 98.26,101.21 98.38,101.34 102.45,101.34 102.66,101.12 102.66,100.35 103.54,99.47 103.96,99.47 105.2,100.7 105.31,100.7 105.43,100.58 105.43,100.46 104.28,99.31 104.28,99.05 104.5,98.82 104.78,98.82 106.45,100.49 106.59,100.49 106.7,100.38 106.7,100.27 105.69,99.26 105.69,98.99 105.83,98.85 105.83,98.85 106.03,98.66 106.03,98.65 106.44,98.23 107.09,97.59 107.36,97.59 107.8,98.04 107.92,98.04 108.04,97.91 108.04,97.8 107.59,97.35 107.59,97.08 107.82,96.86 108.09,96.86 109.33,98.1 109.46,98.1 109.57,97.98 109.57,97.87 107.7,95.99 107.7,95.72 107.92,95.49 108.19,95.49 109.37,96.67 109.51,96.67 109.62,96.56 109.62,96.45 108.76,95.59 108.76,95.18 109.12,94.82 111.86,94.82 112.05,95.01 112.05,95.67 112.12,95.74 112.31,95.74 112.39,95.66 112.39,95.01 112.58,94.82 113.81,94.82 114,95.01 114,95.64 114.08,95.72 114.25,95.72 114.33,95.64 114.33,95.01 114.52,94.82 119.46,94.82 119.5,94.78 119.52,94.78 123.69,90.6 124.63,90.6 128.06,90.6 129.81,88.84 129.81,87.59 131.43,85.97 arc(131.5,85.87) 131.52,85.75 131.52,82.19 131.12,81.55 131.14,81.43 131.05,81.28 131.04,81.13 131.04,79.32 arc(131.02,79.23) 130.97,79.16
DDR4_DDIMM_DQS_N7: length 75.4
  L16_SIG6 w0.076: v1(125.88,76.41) 126.14,76.26 arc(126.17,76.22) 126.17,76.16 arc(126.17,76.16) 126.17,76.16 126.14,76.12 arc(126.12,76.09) 126.09,76.06 arc(126.02,76.02) 125.93,76.01 125.85,76.01 arc(125.74,76.03) 125.63,76.08 arc(125.59,76.12) 125.56,76.16 arc(125.53,76.21) 125.5,76.26 arc(125.46,76.39) 125.51,76.52 arc(125.63,76.85) 125.53,77.18 arc(125.5,77.26) 125.49,77.35 arc(125.5,77.39) 125.52,77.43 arc(125.53,77.44) 125.53,77.45 arc(125.54,77.48) 125.56,77.5 arc(125.57,77.52) 125.59,77.55 arc(125.61,77.57) 125.62,77.59 arc(125.63,77.6) 125.64,77.61 arc(125.66,77.64) 125.68,77.68 arc(125.71,77.84) 125.63,77.98 arc(125.54,78.13) 125.52,78.31 arc(125.52,78.33) 125.53,78.35 arc(125.54,78.39) 125.55,78.43 arc(125.63,78.65) 125.6,78.88 arc(125.6,78.9) 125.59,78.92 arc(125.58,78.96) 125.56,78.99 125.56,78.99 arc(125.51,79.18) 125.56,79.36 arc(125.63,79.63) 125.56,79.91 arc(125.54,79.95) 125.53,80 125.53,80.18 arc(125.54,80.25) 125.58,80.3 arc(125.68,80.52) 125.61,80.76 arc(125.56,80.83) 125.52,80.91 125.4,81.19 arc(125.38,81.25) 125.38,81.32 125.38,82.45 arc(125.28,83) 124.99,83.47 arc(124.96,83.5) 124.93,83.53
  L16_SIG6 w0.081: 124.93,83.53 121.68,86.79 119.73,86.79 arc(119.69,86.79) 119.66,86.82 119.25,87.22 arc(118.94,87.43) 118.57,87.51 107.26,87.51 arc(107.22,87.51) 107.18,87.51 106.15,87.75 arc(106.11,87.76) 106.07,87.78 104.87,88.42 arc(104.83,88.44) 104.8,88.47 arc(104.63,88.59) 104.47,88.71 arc(104.44,88.74) 104.41,88.77 101.11,92.07 arc(100.74,92.48) 100.42,92.92 arc(100.13,93.39) 99.9,93.88 99.81,94.09 arc(99.78,94.15) 99.74,94.21 arc(99.11,94.89) 98.43,95.53 arc(98.25,95.68) 98.04,95.81 arc(97.95,95.87) 97.87,95.93 arc(97.82,95.97) 97.79,96.03 arc(97.42,96.59) 96.88,96.97 96.24,97.25 arc(96.17,97.27) 96.1,97.28 96.09,97.28 95.06,97.28 arc(95.02,97.28) 94.98,97.28 94.34,97.31 arc(94.3,97.32) 94.26,97.33 93.14,97.86 arc(93.06,97.89) 92.98,97.9 90.56,97.9 arc(90.41,97.87) 90.29,97.79 arc(90.02,97.61) 89.71,97.55 89.49,97.55 89.3,97.36 89.3,96.12 89.22,96.04 89.04,96.04 88.96,96.12 88.96,97.38 88.77,97.57 88.45,97.57 88.26,97.38 88.26,96.12 88.18,96.04 88.01,96.04 87.93,96.12 87.93,97.48 87.73,97.68 87.41,97.68 87.23,97.49 87.23,96.12 87.14,96.04 86.97,96.04 86.89,96.12 86.89,97.36 86.7,97.55 82.49,97.55 arc(82.33,97.58) 82.19,97.67 81.59,98.28 arc(81.56,98.31) 81.54,98.34 arc(81.46,98.67) 81.54,98.99 arc(81.56,99.03) 81.58,99.06 arc(81.71,99.44) 81.55,99.8 arc(81.5,99.87) 81.48,99.96 81.48,101.46 81.01,101.93 79.82,101.93 79.27,101.37 78.34,101.37 78.06,101.64 78.06,102.25 78.16,102.35 78.39,102.35 v1(78.51,102.24)
DDR4_DDIMM_DQS_N8: length 44.6
  L03_SIG1 w0.081: v1(152.44,100.96) 152.2,101.21 152.2,101.47 151.92,101.74 151.55,101.74 151.13,102.16 151.13,104.14 150.81,104.46 150.29,104.46 150.05,104.22 150.05,100.57 150.43,100.18 151.21,100.18 151.29,100.1 151.29,99.93 151.21,99.85 150.43,99.85 150.24,99.66 150.24,98.99 150.29,98.94 150.29,98.48 150.06,98.25 149.67,98.25 146.15,94.74 145.38,94.74 144.89,94.25 144.89,93.53 142.7,91.34 135.85,91.34 134.78,90.27 134.27,90.27 132.2,88.2 132.2,87.01 131.57,86.38 131.57,84.88 130.01,83.32 130.01,82.47 129.5,81.97 129.5,81.28 129.57,81.22 129.57,81.14 129.43,80.9 129.32,80.87 v2(129.05,81.02)
DDR4_DDIMM_DQS_P0: length 101.8
  L03_SIG1 w0.076: 140.05,76.89 140.04,76.91 140.04,76.91 140.02,76.92 140.01,76.93 140.01,76.94 139.91,77.12 139.83,77.28 139.67,77.43 139.3,77.43 139.18,77.55 139.18,77.56 138.86,77.88 138.83,77.88 138.82,77.88 138.48,77.88 138.46,77.9 138.45,77.9 138.05,78.3 137.73,78.3 137.3,77.87 136.78,77.87 136.6,78.06 136.6,78.24 136.61,78.26 136.68,78.37 136.78,78.4 137.01,78.27 v2(137.06,78.28)
  L03_SIG1 w0.081: v1(188.99,101.09) 189.11,101.09 189.32,100.88 189.32,100.41 189.24,100.32 189.05,100.32 188.89,100.16 188.89,99.98 188.76,99.85 188.55,99.85 188.42,99.72 188.42,99.5 188.29,99.37 188.07,99.37 187.94,99.24 187.94,99.03 187.81,98.9 187.6,98.9 187.47,98.77 187.47,98.55 187.34,98.42 187.13,98.42 186.99,98.29 186.99,98.08 186.87,97.96 186.33,97.96 186.18,98.12 186,98.12 185.84,97.96 182.85,97.96 182.22,97.33 181.14,97.33 179.62,95.81 179.24,95.81 176.12,95.81 173.99,93.68 173.99,93.38 172.96,92.35 172.28,92.35 167.59,87.66 167.59,87.02 166.39,85.81 166.39,81.99 165.93,81.54 164.75,81.54 164.56,81.35 164.56,80.58 164.48,80.5 164.31,80.5 164.23,80.58 164.23,81.35 164.04,81.54 163.72,81.54 163.53,81.35 163.53,79.92 163.44,79.83 163.27,79.83 163.19,79.91 163.19,81.35 163,81.54 162.68,81.54 162.49,81.35 162.49,80.49 162.41,80.41 162.24,80.41 162.16,80.49 162.16,81.35 161.97,81.54 160.72,81.54 160.18,81.01 160.18,80.74 161.69,79.23 161.69,79.12 161.57,79 161.45,79 159.18,81.27 158.91,81.27 158.68,81.04 158.68,80.77 160.96,78.5 160.96,78.39 160.84,78.26 160.72,78.26 159.12,79.86 158.85,79.86 158.62,79.63 158.62,79.37 160.23,77.77 160.23,77.65 160.1,77.53 159.99,77.53 158.39,79.13 158.12,79.13 157.89,78.9 157.89,78.64 159.49,77.03 159.49,76.92 159.37,76.8 159.26,76.8 157.65,78.4 157.39,78.4 157.16,78.17 157.16,77.9 158.76,76.3 158.76,76.19 158.64,76.06 158.52,76.06 156.92,77.67 156.66,77.67 155.16,76.17 151.05,76.17 150.66,76.55 144.29,76.55 144.29,76.55 143.91,76.55 143.47,76.99 142.53,76.99 142.02,76.48 140.47,76.48 140.05,76.89
DDR4_DDIMM_DQS_P1: length 72.8
  L05_SIG2 w0.081: v1(134.65,80.55) 134.4,80.69 arc(134.36,80.74) 134.37,80.8 arc(134.38,80.82) 134.39,80.83 134.42,80.88 134.42,80.88 134.43,80.9 134.46,80.93 134.47,80.96 134.48,81.01 arc(134.49,81.09) 134.48,81.17 134.36,81.56 arc(134.32,81.66) 134.26,81.74 133.58,82.41 arc(133.54,82.47) 133.52,82.54 133.52,83.7 133.49,83.82 133.46,83.88 133.36,84.12 arc(133.35,84.16) 133.35,84.2 133.35,88.96 arc(133.35,89) 133.38,89.04 134.38,90.04 135.38,91.04 135.45,91.08 135.82,91.08 143.56,91.08 148.35,95.88 156.38,95.88 157.06,95.19 157.69,95.19 158.37,95.88 159.24,95.88 159.33,95.79 159.33,95.14 159.51,94.95 159.83,94.95 160.03,95.15 160.03,95.79 160.11,95.88 160.28,95.88 160.36,95.79 160.36,95.18 160.55,95 160.86,95 161.06,95.2 161.06,95.79 161.14,95.88 168.2,95.88 168.97,96.64 173.77,96.64 173.86,96.55 176.75,96.55 177.15,96.95 177.38,96.95 177.5,97.08 177.5,97.3 177.63,97.43 177.85,97.43 177.98,97.55 177.98,97.78 178.46,98.26 178.46,99.25 178.55,99.33 180.12,99.33 180.31,99.52 180.31,99.85 180.12,100.03 178.55,100.03 178.46,100.12 178.46,101.54 178.6,101.68 178.6,101.87 178.46,102.01 178.46,102.21 179.02,102.77 179.47,102.77 179.94,102.3 179.94,102.12 179.8,101.97 179.8,101.78 179.94,101.64 179.94,101.17 179.73,100.96 v1(179.64,100.96)
DDR4_DDIMM_DQS_P2: length 53.2
  L16_SIG6 w0.076: v1(141.82,78.25) 141.59,78.38 141.47,78.38 141.46,78.38 arc(141.46,78.37) 141.45,78.37 arc(141.26,78.22) 141.03,78.16 141.02,78.16 arc(140.75,78.23) 140.55,78.42 140.51,78.5 arc(140.44,78.73) 140.49,78.96 arc(140.51,78.99) 140.53,79.02 140.55,79.04 140.63,79.2 140.63,79.57 141.3,80.24 141.3,80.37 141.3,80.38 141.3,80.43
  L16_SIG6 w0.081: 141.3,80.43 141.3,81.22 141.61,81.53 141.8,81.53 144.27,84 144.27,85.67 148.6,90 158.97,90 162.16,93.19 162.16,93.19 162.9,93.93 164.82,93.93 165.13,94.24 165.13,94.35 164.59,94.9 164.59,95.16 164.81,95.39 165.08,95.39 165.62,94.85 165.74,94.85 165.86,94.97 165.86,95.09 165.32,95.63 165.32,95.9 165.55,96.13 165.81,96.13 166.36,95.58 166.47,95.58 166.59,95.7 166.59,95.82 166.05,96.36 166.05,96.63 166.28,96.86 166.55,96.86 167.09,96.31 167.21,96.31 167.33,96.44 167.33,96.55 166.78,97.1 166.78,97.36 167.01,97.59 167.28,97.59 167.82,97.05 167.94,97.05 168.06,97.17 168.06,97.28 167.52,97.83 167.52,98.09 167.75,98.32 168.01,98.32 168.24,98.09 168.77,98.09 168.94,98.26 168.94,100.06 169.36,100.48 170.55,100.48 170.63,100.56 170.63,100.88 170.55,100.96 v1(170.29,100.96)
DDR4_DDIMM_DQS_P3: length 43.2
  L03_SIG1 w0.081: v1(160.94,102.36) 161.25,102.67 arc(161.27,102.7) 161.28,102.73 161.28,102.81 arc(161.2,102.99) 161.02,103.07 160.09,103.07 arc(159.84,102.96) 159.74,102.72 159.74,102.23 159.87,102.1 159.87,101.89 159.74,101.77 159.74,101.56 159.87,101.43 159.87,101.22 159.74,101.1 159.74,100.66 159.9,100.5 159.9,100.32 159.74,100.16 159.74,99.81 arc(159.79,99.56) 159.93,99.35 160.11,99.17 arc(160.29,98.9) 160.36,98.58 arc(160.43,98.15) 160.63,97.76 arc(160.75,97.53) 160.79,97.27 160.79,96.56 arc(160.68,96.01) 160.37,95.55 159.33,94.51 arc(159.02,94.04) 158.91,93.49 158.91,93.35 arc(158.88,93.13) 158.79,92.92 arc(158.73,92.82) 158.65,92.73 156.97,91.06 156.71,91.06 156.31,91.45 156.19,91.45 156.07,91.33 156.07,91.22 156.47,90.82 156.47,90.55 156.24,90.32 155.97,90.32 155.58,90.72 155.46,90.72 155.34,90.6 155.34,90.48 155.74,90.09 155.74,89.82 155.51,89.59 155.24,89.59 154.84,89.99 154.73,89.99 154.61,89.86 154.61,89.75 155,89.35 155,89.09 154.82,88.9 arc(154.09,88.41) 153.22,88.24 148.19,88.24 arc(147.93,88.19) 147.72,88.05 145.42,85.74 arc(145.25,85.5) 145.2,85.22 145.2,84.38 arc(145.13,84.06) 144.95,83.78 144.15,82.98 arc(144.12,82.95) 144.09,82.93 143.28,82.25 arc(143.19,82.19) 143.09,82.18 141.21,82.18 arc(141.17,82.17) 141.13,82.16 140.93,82.09 arc(140.45,81.83) 140.03,81.48 139.75,81.2 arc(139.6,81.1) 139.43,81.07 arc(139.37,81.05) 139.31,81.02 139.2,80.9 arc(139.19,80.89) 139.18,80.88 139.15,80.82 arc(139.14,80.76) 139.18,80.71 v2(139.43,80.57)
DDR4_DDIMM_DQS_P4: length 66.8
  L14_SIG5 w0.076: 131.78,80.16 131.78,80.14 131.78,80.14 131.78,79.36 arc(131.8,79.26) 131.85,79.16 131.85,79.15 arc(131.94,78.97) 131.98,78.78 131.98,78.71 131.99,78.71 arc(131.99,78.69) 131.99,78.67 arc(132.06,78.49) 132.18,78.33 v1(132.26,78.25)
  L14_SIG5 w0.081: v1(105.73,101.15) 106.05,101.47 106.05,103.93 106.39,104.27 108.27,104.27 108.47,104.07 108.47,102.7 108.55,102.62 108.72,102.62 108.81,102.7 108.81,104.09 108.98,104.27 109.31,104.27 109.51,104.07 109.51,102.7 109.59,102.62 109.76,102.62 109.84,102.7 109.84,104.09 110.02,104.27 110.34,104.27 110.54,104.07 110.54,102.7 110.62,102.62 110.8,102.62 110.88,102.7 110.88,104.09 111.06,104.27 111.38,104.27 111.58,104.07 111.58,102.7 111.66,102.62 111.83,102.62 111.91,102.7 111.91,104.08 112.1,104.27 112.61,104.27 112.83,104.05 112.83,103.48 113.05,103.27 113.05,103.02 113.15,102.91 116.39,102.91 116.63,102.67 118.52,102.67 118.93,103.08 122.28,103.08 122.62,102.75 122.62,101.5 122.32,101.2 122.32,100.44 122.56,100.19 123.23,100.19 123.31,100.27 123.31,101.52 123.48,101.69 123.83,101.69 124.02,101.5 124.02,100.34 124.17,100.19 125.98,100.19 128.36,97.81 128.36,93.53 131.82,90.07 131.82,84.97 132.38,84.41 132.38,81.95 arc(132.33,81.72) 132.2,81.52 132.1,81.42 arc(132.07,81.39) 132.04,81.36 arc(132,81.31) 131.97,81.26 arc(131.83,80.97) 131.78,80.65 131.78,80.16
DDR4_DDIMM_DQS_P5: length 67.4
  L14_SIG5 w0.076: 127.26,81.31 127.26,81.3 127.26,81.3 127.26,81.3 127.26,80.34 127.15,80.23 127.15,79.95 127.36,79.74 127.36,78.79 127.19,78.5 127.22,78.4 v1(127.48,78.25)
  L14_SIG5 w0.081: v1(96.34,100.96) 96.55,100.96 96.7,101.12 96.7,101.42 96.97,101.69 97.4,101.69 97.85,101.24 97.85,100.4 99.54,98.7 99.54,95.41 99.97,94.98 103.66,94.98 103.74,95.06 103.74,96.59 103.93,96.78 104.25,96.78 104.44,96.59 104.44,95.06 104.52,94.98 104.7,94.98 104.78,95.06 104.78,96.59 104.97,96.78 105.29,96.78 105.48,96.59 105.48,95.06 105.56,94.98 105.73,94.98 105.81,95.06 105.81,96.59 106,96.78 106.33,96.78 106.51,96.59 106.51,95.06 106.6,94.98 107.54,94.98 107.62,95.06 107.62,95.95 107.81,96.14 108.14,96.14 108.32,95.95 108.32,95.06 108.41,94.98 108.58,94.98 108.66,95.06 108.66,95.95 108.85,96.14 109.17,96.14 109.36,95.95 109.36,95.06 109.44,94.98 110.01,94.98 110.71,95.67 110.71,96.29 110.9,96.48 112.57,96.48 112.91,96.14 112.91,95.48 113.39,95.01 118.3,95.01 118.9,94.41 118.9,93.93 119.14,93.68 119.14,91.74 119.46,91.43 124.55,91.43 127.08,88.9 127.08,84.2 127.45,83.83 127.45,82.25 127.26,82.06 127.26,81.31
