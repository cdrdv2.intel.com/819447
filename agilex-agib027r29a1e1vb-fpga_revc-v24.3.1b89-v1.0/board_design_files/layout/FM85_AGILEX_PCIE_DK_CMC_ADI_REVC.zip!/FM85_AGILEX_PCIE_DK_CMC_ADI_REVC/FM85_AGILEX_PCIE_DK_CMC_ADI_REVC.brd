# Allegro board FM85_AGILEX_PCIE_DK_CMC_ADI_REVC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_COMP_CH0_CKE: length 85
  L12_SIG4 w0.089: v1(69.79,21.73) 69.79,21.73 70.21,21.31 72.78,21.31 73.62,22.15 79.57,22.15 v1(79.98,21.74) 80.39,22.15 81.48,22.15 81.7,21.93 83.42,21.93 83.67,22.17 84.59,22.17 85.68,22.17 86.2,21.65 88.54,21.65 88.84,21.35 89.75,21.35 v1(90.14,21.74) 90.37,21.74 90.79,22.15 91.82,22.15 91.91,22.06 91.91,21.75 92,21.66 92.17,21.66 92.25,21.75 92.25,22.06 92.34,22.15 92.51,22.15 92.6,22.06 92.6,21.75 92.69,21.66 92.85,21.66 92.94,21.75 92.94,22.06 93.03,22.15 99.89,22.15 v1(100.3,21.74) 100.71,22.15 107.44,22.15 107.53,22.06 107.53,21.9 107.62,21.81 107.78,21.81 107.87,21.9 107.87,22.06 107.96,22.15 110.05,22.15 v1(110.46,21.74)
  L16_SIG6 w0.081: v1(110.46,21.74) 110.83,21.37 110.83,20.67 110.7,20.54 110.18,20.54 110.03,20.68 110.03,22.87 110.12,22.95 110.72,22.95 110.87,23.11 110.87,23.58 110.74,23.72 110.12,23.72 110.03,23.8 110.03,24.48 110.12,24.56 111.27,24.56 111.39,24.68 111.39,25.24 111.31,25.32 109.04,25.32 108.78,25.59 108.78,29.84 108.86,29.92 111.04,29.92 111.13,30.02 111.13,30.14 111.02,30.26 108.86,30.26 108.78,30.34 108.78,30.51 108.86,30.59 110.33,30.59 110.49,30.76 110.49,30.99 109.98,31.51 109.87,31.51 109.31,30.95 109.2,30.95 109.08,31.07 109.08,31.19 109.63,31.74 109.63,31.86 105.65,35.84 105.65,36.68 arc(105.62,36.78) 105.57,36.87 105.04,37.4 105.01,37.4 104.79,37.61 104.79,37.64 104.73,37.7 arc(104.71,37.74) 104.7,37.78 arc(104.72,37.89) 104.77,38 arc(104.83,38.22) 104.77,38.45 104.77,38.46 arc(104.7,38.68) 104.76,38.91 104.77,38.92 v1(105.16,39.61)
  BOTTOM w0.149: R32.2 R34.1 67.69,22.28 68.29,22.28 68.44,22.13 69.4,22.13 v1(69.79,21.73)
DDR4_COMP_CH0_CLK_N: length 83.6
  L03_SIG1 w0.081: v1(102.77,38.23) 103.02,38.09 103.05,37.96 102.96,37.81 102.96,37.48 103.88,36.57 103.88,34.88 104.11,34.64 104.38,34.64 104.85,35.12 104.99,35.12 105.12,34.99 105.12,34.88 104.66,34.43 104.66,34.09 105.32,33.44 105.61,33.44 106.42,34.25 106.56,34.25 106.66,34.15 106.66,34.02 105.84,33.2 105.84,32.91 106.43,32.33 107.53,32.33 108.7,31.16 109.87,31.16 109.95,31.08 109.95,29.56 110.16,29.35 110.46,29.35 110.65,29.54 110.65,31.08 110.73,31.16 111.38,31.16 111.49,31.05 111.49,29.46 111.7,29.25 111.97,29.25 112.19,29.47 112.19,31.08 112.27,31.16 113.06,31.16 113.46,30.76 113.46,26.17 113.88,25.74 113.88,21.28 114.29,20.87 114.59,20.87 114.95,21.24 114.95,21.66 115.03,21.74 v1(115.26,21.74)
  L05_SIG2 w0.081: v1(115.26,21.74) 114.95,21.74 114.55,22.14 113.93,22.14 113.8,22.19 112.22,22.19 112.11,22.29 111.59,22.29 111.46,22.16 110.91,22.16 110.78,22.29 109.94,22.29 109.78,22.14 107.09,22.14 106.51,21.56 105.28,21.56 v1(105.1,21.74) 104.81,21.74 104.43,22.12 102.07,22.12 101.9,22.29 101.38,22.29 101.23,22.14 100.68,22.14 100.53,22.29 100.07,22.29 99.9,22.12 97.42,22.12 96.87,21.58 95.1,21.58 v1(94.94,21.74) 94.92,21.76 94.68,21.76 94.52,21.92 94.52,21.92 94.36,22.08 94.05,22.08 93.82,22.31 91.24,22.31 91.09,22.17 90.78,22.17 90.66,22.29 89.91,22.29 89.78,22.17 86.78,22.17 86.15,21.53 84.98,21.53 84.76,21.76 84.76,21.79 v1(84.74,21.8) 84.72,21.8 84.66,21.74 84.53,21.74 84.35,21.92 84.35,21.92 84.14,22.13 84.12,22.13 84.08,22.17 83.81,22.17 83.68,22.29 83.1,22.29 82.79,21.99 82.47,21.99 82.16,22.29 81.08,22.29 80.95,22.17 80.63,22.17 80.5,22.29 79.75,22.29 79.62,22.17 76.6,22.17 75.97,21.54 74.71,21.54 74.59,21.66 v1(74.59,21.73)
  BOTTOM w0.149: v1(74.59,21.73) 74.19,22.13 73.38,22.13 R36.2
DDR4_COMP_CH0_CLK_P: length 83.7
  L03_SIG1 w0.081: v1(114.46,21.74) 114.69,21.74 114.77,21.66 114.77,21.31 114.51,21.05 114.37,21.05 114.07,21.35 114.07,25.82 113.64,26.24 113.64,30.84 113.14,31.34 112.2,31.34 112.01,31.16 112.01,29.55 111.9,29.43 111.77,29.43 111.68,29.53 111.68,31.13 111.46,31.34 110.66,31.34 110.47,31.16 110.47,29.62 110.39,29.54 110.24,29.54 110.13,29.64 110.13,31.16 109.95,31.34 108.78,31.34 107.61,32.51 106.5,32.51 106.03,32.99 106.03,33.12 106.84,33.94 106.84,34.23 106.64,34.43 106.34,34.43 105.53,33.62 105.39,33.62 104.85,34.17 104.85,34.35 105.3,34.8 105.3,35.07 105.06,35.3 104.78,35.3 104.3,34.83 104.18,34.83 104.06,34.95 104.06,35.55 104.16,35.65 104.34,35.65 104.42,35.73 104.42,35.9 104.34,35.99 104.16,35.99 104.06,36.08 104.06,36.65 103.14,37.56 103.14,37.76 103.21,37.87 103.33,37.91 v1(103.57,37.77)
  L05_SIG2 w0.081: v1(73.79,21.73) 74.1,21.73 74.48,21.36 76.05,21.36 76.68,21.99 79.7,21.99 79.82,22.11 80.42,22.11 80.55,21.98 81.03,21.98 81.15,22.11 82.09,22.11 82.4,21.8 82.87,21.8 83.17,22.11 83.61,22.11 83.9,21.82 83.94,21.82 83.94,21.8 83.96,21.8 v1(83.98,21.78) 84.02,21.74 84.27,21.74 84.66,21.35 86.22,21.35 86.86,21.99 89.86,21.99 89.98,22.11 90.58,22.11 90.71,21.99 91.17,21.99 91.31,22.13 93.75,22.13 v1(94.14,21.74) 94.44,21.74 94.79,21.39 96.95,21.39 97.49,21.94 99.97,21.94 100.14,22.11 100.45,22.11 100.6,21.96 101.3,21.96 101.45,22.11 101.83,22.11 102,21.94 104.1,21.94 v1(104.3,21.74) 104.55,21.74 104.92,21.37 106.58,21.37 107.17,21.96 109.86,21.96 110.01,22.11 110.7,22.11 110.84,21.98 111.53,21.98 111.66,22.11 112.04,22.11 112.14,22.01 113.77,22.01 113.89,21.95 114.33,21.95 114.46,21.82 v1(114.46,21.74)
  BOTTOM w0.149: R35.2 72.22,21.97 72.46,21.73 v1(73.79,21.73)
DDR4_COMP_CH0_CS_N: length 83.6
  TOP w0.149: U3.L7 v1(83.48,20.93) ; U2.L7 v1(113.7,20.94)
  L05_SIG2 w0.081: v1(113.7,20.94) 113.27,20.51 108.49,20.51 108.41,20.6 108.41,21.08 108.33,21.17 108.16,21.17 108.08,21.08 108.08,20.6 107.99,20.51 107.82,20.51 107.74,20.6 107.74,21.08 107.66,21.17 107.49,21.17 107.41,21.08 107.41,20.6 107.32,20.51 104.72,20.51 v1(104.3,20.94) 103.9,20.54 98.28,20.54 98.2,20.62 98.2,20.83 98.12,20.91 97.95,20.91 97.87,20.83 97.87,20.62 97.78,20.54 94.54,20.54 v1(94.14,20.94) 93.74,20.54 92.16,20.54 92.08,20.46 92.08,20.26 92,20.18 91.82,20.18 91.74,20.26 91.74,20.46 91.66,20.54 85.42,20.54 85.38,20.51 84.41,20.51 83.99,20.93 v1(83.48,20.93) 83.11,20.56 arc(83.08,20.55) 83.05,20.54 78.93,20.54 78.79,20.4 78.59,20.4 78.45,20.54 78.26,20.54 78.12,20.4 77.92,20.4 77.78,20.54 77.59,20.54 77.45,20.4 77.25,20.4 77.11,20.54 76.92,20.54 76.78,20.4 76.58,20.4 76.43,20.55 76.25,20.55 76.1,20.4 75.91,20.4 75.8,20.51 74.22,20.51 v1(73.79,20.93)
  L16_SIG6 w0.081: v1(113.7,20.94) 113.7,20.7 113.79,20.6 114.52,20.6 114.6,20.68 114.6,21.36 114.83,21.59 114.83,29.92 114.75,30 114.43,30 114.35,30.08 114.35,30.25 114.43,30.33 114.75,30.33 114.83,30.41 114.83,30.59 114.75,30.67 114.43,30.67 114.35,30.75 114.35,30.92 114.43,31 115.02,31 115.11,31.08 115.11,31.28 114.88,31.51 114.24,31.51 113.81,31.95 113.81,32.5 113.37,32.94 113.37,33.05 113.57,33.25 113.57,33.37 113.45,33.49 113.34,33.49 113.14,33.29 113.02,33.29 112.79,33.53 112.79,34.54 112.65,34.68 112.53,34.68 112.45,34.6 112.45,33.45 112.37,33.37 112.04,33.37 111.94,33.47 111.94,34.92 111.86,35 111.73,35 111.61,34.88 111.61,33.48 111.52,33.38 111.36,33.38 111.27,33.47 111.27,34.18 111.19,34.27 110.93,34.27 110.85,34.35 110.85,34.52 110.93,34.6 111.19,34.6 111.27,34.68 111.27,35 111,35.27 110.64,35.27 110.42,35.04 110.42,33.94 110.34,33.86 110.17,33.86 110.09,33.95 110.09,34.68 109.97,34.79 109.12,34.79 107.86,36.06 107.86,37.13 107.22,37.77 arc(107.2,37.89) 107.16,38 107.09,38.1 arc(107.06,38.23) 107.09,38.35 107.21,38.56 arc(107.25,38.68) 107.22,38.81 107.16,38.92 v1(106.76,39.61)
DDR4_COMP_CH0_DBI_N0: length 40.9
  L12_SIG4 w0.089: v1(109.95,41.45) 109.95,41.19 110.53,40.61 110.83,40.61 111.14,40.3 arc(111.2,40.07) 111.14,39.84 111.14,39.83 arc(111.08,39.6) 111.14,39.38 arc(111.2,39.15) 111.14,38.92 111.14,38.91 arc(111.08,38.68) 111.14,38.46 111.14,38.45 arc(111.2,38.25) 111.16,38.04 arc(110.99,37.55) 110.88,37.04 arc(110.85,36.77) 110.84,36.51 110.11,35.78 110.11,35.31 109.16,34.36 106.6,34.36 105.89,33.66 105.1,33.66 101.53,30.09 101.53,26.33 101.36,26.16 100.78,26.16 100.69,26.25 100.69,27.54 100.52,27.71 100.04,27.71 99.87,27.55 99.87,27.5 99.87,27.49 99.87,27.18 99.87,27.18 99.87,26.7 99.87,26.69 99.87,26.38 99.87,26.38 99.87,26.25 99.78,26.16 98.88,26.16 98.79,26.25 98.79,27.42 98.7,27.51 98.53,27.51 98.44,27.42 98.44,26.07 98.35,25.98 98.17,25.98 98.08,26.07 98.08,27.42 97.99,27.51 97.82,27.51 97.73,27.42 97.73,25.9 97.62,25.79 97.48,25.79 97.37,25.9 97.37,27.42 97.28,27.51 97.11,27.51 97.01,27.42 97.01,26.28 96.89,26.16 94.23,26.16 94.14,26.08 v1(94.14,25.74)
DDR4_COMP_CH0_DBI_N1: length 42
  L07_SIG3 w0.089: v1(90.14,25.74) 90.14,25.48 90.26,25.35 92.03,25.35 92.16,25.22 92.16,23.82 92.29,23.7 92.79,23.7 92.91,23.82 92.91,25.19 93.08,25.35 95.86,25.35 96.11,25.09 96.11,24.48 96.25,24.34 97.75,24.34 97.86,24.45 97.86,25.76 98.33,26.23 98.33,30.04 98.68,30.39 98.68,31.71 98.88,31.92 103.67,31.92 107.7,35.94 108.2,35.94 108.81,36.56 108.81,37.77 arc(108.8,37.89) 108.74,38.01 arc(108.69,38.23) 108.75,38.46 arc(108.81,38.68) 108.75,38.91 108.75,38.92 arc(108.69,39.15) 108.75,39.38 arc(108.81,39.6) 108.75,39.83 108.75,39.84 arc(108.69,40.07) 108.75,40.3 arc(108.81,40.52) 108.75,40.75 108.75,40.76 arc(108.69,40.99) 108.75,41.22 arc(108.81,41.44) 108.75,41.67 108.75,41.68 arc(108.69,41.9) 108.74,42.12 108.76,42.15 arc(108.81,42.37) 108.75,42.6 108.75,42.6 arc(108.69,42.83) 108.75,43.06 arc(108.81,43.29) 108.75,43.51 108.75,43.52 arc(108.69,43.75) 108.75,43.98 arc(108.81,44.2) 108.75,44.43 108.75,44.44 arc(108.59,44.6) 108.36,44.67 108.35,44.67 arc(108.12,44.6) 107.95,44.44 arc(107.79,44.27) 107.56,44.21 v1(106.76,44.21)
DDR4_COMP_CH0_DBI_N2: length 31.4
  L14_SIG5 w0.081: v1(116.32,46.05) 116.72,45.35 arc(116.78,45.12) 116.72,44.9 arc(116.56,44.73) 116.33,44.67 116.32,44.67 arc(116.09,44.6) 115.92,44.44 115.92,44.43 arc(115.86,44.2) 115.92,43.98 arc(115.98,43.75) 115.93,43.52 115.92,43.51 arc(115.86,43.29) 115.92,43.06 arc(115.98,42.83) 115.93,42.6 115.91,42.58 arc(115.86,42.36) 115.92,42.14 arc(115.98,41.91) 115.93,41.69 115.92,41.67 arc(115.86,41.44) 115.92,41.22 arc(115.98,40.99) 115.93,40.76 115.92,40.75 arc(115.86,40.52) 115.92,40.3 arc(115.98,40.07) 115.92,39.84 115.92,39.83 arc(115.86,39.6) 115.92,39.38 arc(115.98,39.15) 115.92,38.92 115.92,38.91 arc(115.86,38.68) 115.92,38.46 115.92,38.45 arc(115.98,38.22) 115.92,38 115.82,37.82 115.82,31.38 115.74,31.3 113.89,31.3 113.81,31.22 113.81,31.04 113.89,30.96 115.74,30.96 115.82,30.88 115.82,30.71 115.74,30.63 113.89,30.63 113.81,30.55 113.81,30.37 113.89,30.29 115.73,30.29 115.81,30.21 115.81,29.87 115.65,29.71 113.9,29.71 113.66,29.47 113.66,26.14 114.06,25.74 v1(114.46,25.74)
DDR4_COMP_CH0_DBI_N3: length 41.7
  L12_SIG4 w0.089: v1(110.46,25.74) 110.49,25.77 110.76,25.77 111.11,26.13 111.46,26.13 111.71,26.37 111.9,26.37 112.06,26.54 112.06,27.47 112.17,27.59 112.36,27.59 112.45,27.5 112.45,27.01 112.54,26.92 112.72,26.92 112.81,27.01 112.81,27.5 112.9,27.59 113.07,27.59 113.16,27.5 113.16,27.01 113.25,26.92 113.43,26.92 113.52,27.01 113.52,27.7 113.62,27.8 113.82,27.8 113.91,27.71 113.91,27.04 114,26.95 115.43,26.95 115.85,27.37 116.33,27.37 117.15,28.19 117.15,29.33 117.33,29.52 117.76,29.52 117.86,29.62 117.86,29.77 117.77,29.86 117.57,29.86 117.48,29.95 117.48,30.11 117.57,30.2 117.76,30.2 117.86,30.3 117.86,30.46 117.77,30.55 117.57,30.55 117.48,30.63 117.48,30.8 117.57,30.89 117.76,30.89 117.86,30.99 117.86,31.14 117.77,31.23 117.57,31.23 117.48,31.32 117.48,31.49 117.57,31.57 117.76,31.57 117.86,31.68 117.86,32.02 117.94,32.1 118.28,32.1 118.38,32.2 118.38,32.86 118.29,32.95 118.04,32.95 117.95,33.04 117.95,33.22 118.04,33.31 118.27,33.31 118.38,33.42 118.38,34.11 118.29,34.2 117.92,34.2 117.83,34.29 117.83,34.47 117.92,34.56 118.29,34.56 118.38,34.64 118.38,34.88 118.29,34.97 116.9,34.97 116.8,35.07 116.8,35.34 117.04,35.58 117.04,36.86 117.55,37.37 118.1,37.37 118.32,37.6 118.32,43.41 118.07,43.66 117.93,43.66 117.64,43.95 117.47,43.95 117.13,44.29 116.77,44.29 116.48,44.58 116.24,44.58 115.6,45.21 115.37,45.21 114.91,45.67 114.37,45.67 114.09,45.96 113.78,45.96 113.56,45.74 113.56,45.73 113.5,45.67 113.49,45.68 arc(113.39,45.61) 113.27,45.59 113.13,45.59 arc(112.9,45.65) 112.74,45.82 arc(112.57,45.98) 112.34,46.05 v1(111.54,46.05)
DDR4_COMP_CH0_DBI_N4: length 68.7
  L14_SIG5 w0.081: v1(83.98,25.74) 83.98,26.08 84.06,26.16 86.53,26.16 86.64,26.27 86.64,30.93 90.43,34.72 91.64,34.72 91.83,34.9 91.83,35.66 91.91,35.75 92.08,35.75 92.16,35.66 92.16,34.9 92.24,34.82 92.41,34.82 92.5,34.9 92.5,35.66 92.58,35.75 92.75,35.75 92.83,35.66 92.83,34.9 92.91,34.82 93.09,34.82 93.17,34.9 93.17,35.66 93.25,35.75 93.42,35.75 93.5,35.66 93.5,34.9 93.58,34.82 93.76,34.82 93.84,34.9 93.84,35.66 93.92,35.75 94.09,35.75 94.17,35.66 94.17,34.9 94.25,34.82 94.43,34.82 94.51,34.9 94.51,35.66 94.59,35.75 94.76,35.75 94.84,35.66 94.84,34.9 94.92,34.82 95.1,34.82 95.18,34.9 95.18,35.66 95.26,35.75 95.43,35.75 95.51,35.66 95.51,34.9 95.59,34.82 95.77,34.82 95.85,34.9 95.85,35.66 95.93,35.75 96.1,35.75 96.18,35.66 96.18,34.9 96.27,34.82 96.44,34.82 96.52,34.9 96.52,35.66 96.6,35.75 96.77,35.75 96.85,35.66 96.85,34.9 96.94,34.82 97.11,34.82 97.19,34.9 97.19,35.66 97.27,35.75 97.44,35.75 97.53,35.66 97.53,34.9 97.61,34.82 97.78,34.82 97.86,34.9 97.86,35.66 97.94,35.75 98.11,35.75 98.2,35.66 98.2,34.9 98.28,34.82 101.71,34.82 101.81,34.73 101.81,34.39 101.8,34.38 101.87,34.32 103.11,34.32 103.19,34.4 103.19,34.75 103.11,34.83 102.45,34.83 102.37,34.91 102.37,35.09 102.45,35.17 103.11,35.17 103.19,35.25 103.19,35.42 103.11,35.5 102.45,35.5 102.37,35.59 102.37,35.76 102.45,35.84 103.11,35.84 103.19,35.92 103.19,36.09 103.11,36.17 102.45,36.17 102.37,36.26 102.37,36.43 102.45,36.51 103.11,36.51 103.19,36.59 103.19,36.76 103.11,36.85 102.45,36.85 102.37,36.93 102.37,37.1 102.45,37.18 103.11,37.18 103.19,37.26 103.19,37.43 103.11,37.52 102.45,37.52 102.37,37.6 102.37,37.77 102.45,37.85 103.11,37.85 103.19,37.93 103.19,43.43 103.5,43.74 103.77,43.74 103.97,43.94 103.97,44.44 arc(103.91,44.67) 103.97,44.9 arc(104.03,45.13) 103.97,45.36 103.97,45.36 arc(103.91,45.59) 103.97,45.82 arc(104.03,46.04) 103.97,46.27 103.97,46.28 arc(103.91,46.51) 103.97,46.74 103.97,46.74 arc(104.03,46.97) 103.97,47.2 103.97,47.2 arc(103.91,47.43) 103.97,47.66 arc(104.03,47.88) 103.97,48.11 103.97,48.12 arc(103.91,48.35) 103.97,48.58 arc(104.14,48.74) 104.36,48.81 104.37,48.81 arc(104.6,48.75) 104.77,48.58 arc(104.93,48.41) 105.16,48.35 105.17,48.35 arc(105.4,48.28) 105.56,48.12 105.57,48.11 arc(105.74,47.95) 105.96,47.89 arc(106.19,47.95) 106.36,48.11 v1(106.76,48.81)
DDR4_COMP_CH0_DBI_N5: length 49.6
  L14_SIG5 w0.081: v1(79.98,25.74) 80.35,26.11 81.09,26.11 81.95,26.97 84.13,26.97 84.35,27.19 84.35,27.43 84.64,27.72 84.9,27.72 85.21,28.03 85.21,31.23 87.2,33.22 87.2,34.2 87.28,34.29 87.77,34.29 87.85,34.37 87.85,34.54 87.77,34.62 87.28,34.62 87.2,34.7 87.2,34.87 87.28,34.96 87.77,34.96 87.85,35.04 87.85,35.21 87.77,35.29 87.28,35.29 87.2,35.37 87.2,35.55 87.28,35.63 87.77,35.63 87.85,35.71 87.85,35.88 87.77,35.96 87.28,35.96 87.2,36.04 87.2,36.22 87.28,36.3 87.77,36.3 87.85,36.38 87.85,36.55 87.77,36.63 87.28,36.63 87.2,36.71 87.2,36.89 87.28,36.97 87.77,36.97 87.85,37.05 87.85,37.22 87.77,37.3 87.28,37.3 87.2,37.38 87.2,37.56 87.28,37.64 87.77,37.64 87.85,37.72 87.85,37.89 87.77,37.97 87.28,37.97 87.2,38.05 87.2,38.39 87.31,38.51 88.98,38.51 89.57,39.1 89.85,39.1 90.34,39.59 90.84,39.59 91.38,39.05 93.65,39.05 93.94,38.77 94.27,38.77 94.35,38.68 94.35,38.1 94.44,38.02 94.61,38.02 94.69,38.1 94.69,38.68 94.77,38.77 94.94,38.77 95.02,38.68 95.02,38.1 95.11,38.02 95.28,38.02 95.36,38.1 95.36,38.68 95.44,38.77 95.98,38.77 96.24,39.02 97.14,39.02 97.4,38.77 97.71,38.77 98.08,39.13 98.67,39.13 98.88,39.34 98.88,40.25 99.13,40.51 99.3,40.51 99.78,40.99 99.78,42.14 arc(99.81,42.26) 99.88,42.37 arc(99.91,42.42) 99.92,42.48 99.92,43.29 arc(99.94,43.41) 99.99,43.52 arc(100.05,43.75) 99.99,43.98 arc(99.92,44.2) 99.98,44.43 99.99,44.44 arc(100.15,44.6) 100.38,44.67 100.39,44.67 arc(100.62,44.73) 100.78,44.9 arc(100.95,45.06) 101.18,45.13 101.18,45.13 arc(101.41,45.19) 101.58,45.35 101.58,45.36 arc(101.75,45.53) 101.98,45.59 arc(102.21,45.65) 102.38,45.82 arc(102.44,46.04) 102.38,46.27 102.38,46.28 v1(101.98,46.97)
DDR4_COMP_CH0_DBI_N6: length 34.3
  L07_SIG3 w0.089: v1(111.54,44.21) 111.54,43.89 112.09,43.34 112.43,43.34 112.96,42.8 113.27,42.8 113.72,42.34 114.03,42.34 114.41,41.96 114.41,41.66 114.31,41.56 114.31,37.95 113.94,37.57 113.94,37.23 114.02,37.14 114.76,37.14 114.84,37.05 114.84,36.89 114.76,36.8 114.02,36.8 113.94,36.71 113.94,36.37 114.02,36.28 114.6,36.28 114.7,36.18 114.7,36.02 114.61,35.93 114.02,35.93 113.94,35.84 113.94,35.22 111.57,32.85 111.57,31.74 111.19,31.36 111.06,31.36 110.82,31.61 110.69,31.61 110.57,31.49 110.57,31.37 110.82,31.13 110.82,30.99 110.71,30.88 110.58,30.88 109.78,31.68 109.65,31.68 109.54,31.56 109.54,31.43 110.3,30.67 110.3,30.55 110.09,30.35 109.61,30.35 109.05,30.91 108.89,30.91 108.46,30.48 108.37,30.39 108.37,30.26 108.61,30.03 108.61,29.9 108.49,29.79 108.36,29.79 108.13,30.02 108,30.02 107.88,29.91 107.88,29.78 108.12,29.54 108.12,29.42 108.01,29.3 107.88,29.3 107.64,29.54 107.52,29.54 106.58,28.6 106.58,27.92 106.42,27.76 105.74,27.76 105.74,27.77 105.47,27.5 105.47,27.18 105.25,26.96 104.94,26.96 104.94,26.97 104.67,26.7 104.67,26.38 104.3,26.01 v1(104.3,25.74)
DDR4_COMP_CH0_DBI_N7: length 42
  L05_SIG2 w0.081: v1(100.3,25.74) 100.63,25.74 100.71,25.66 100.71,25.45 100.61,25.35 98.9,25.35 98.76,25.5 98.76,31.21 99.4,31.86 103.38,31.86 103.96,32.44 107.12,32.44 107.39,32.71 107.39,33.73 107.31,33.81 107.02,33.81 106.94,33.89 106.94,34.05 107.02,34.13 107.31,34.13 107.39,34.21 107.39,34.64 107.31,34.73 106.83,34.73 106.74,34.81 106.74,34.98 106.83,35.06 107.31,35.06 107.39,35.14 107.39,35.31 107.31,35.4 106.85,35.4 106.77,35.48 106.77,35.65 106.85,35.73 107.31,35.73 107.39,35.81 107.39,37.13 107.56,37.3 110.2,37.3 110.36,37.47 110.36,44.04 110.51,44.19 110.85,44.19 111.18,44.52 arc(111.35,44.65) 111.56,44.7 arc(111.73,44.74) 111.88,44.84 112.1,45.06 arc(112.23,45.14) 112.37,45.17 112.49,45.17 arc(112.6,45.19) 112.69,45.26 112.89,45.46 arc(113.16,45.57) 113.42,45.46 113.54,45.34 arc(113.97,45.16) 114.4,45.34 114.46,45.4 arc(114.65,45.52) 114.88,45.55 arc(115.02,45.52) 115.14,45.44 115.48,45.11 115.78,44.98 116.28,44.31 arc(116.31,44.26) v1(116.32,44.21)
DDR4_COMP_CH0_DBI_N8: length 68.7
  L12_SIG4 w0.089: v1(73.79,25.73) 72.6,24.54 72.47,24.54 71.84,25.17 71.71,25.17 71.6,25.06 71.6,24.93 72.57,23.95 72.57,23.57 72.37,23.37 71.13,23.37 70.75,23.75 70.3,23.75 70.21,23.66 70.21,23.09 70.03,22.91 68.59,22.91 68.48,22.81 68.48,22.39 68.37,22.27 68.19,22.27 68.1,22.36 68.1,31.22 69.07,32.18 69.47,32.18 70.02,31.63 75.02,31.63 75.95,30.7 76.67,30.7 78.18,32.21 83.65,32.21 88.17,36.73 88.17,38.1 88.46,38.39 arc(88.64,38.57) 88.88,38.64 88.89,38.64 arc(89.14,38.7) 89.33,38.88 89.33,38.89 arc(89.51,39.07) 89.76,39.14 arc(90.01,39.2) 90.19,39.39 90.2,39.39 arc(90.26,39.64) 90.19,39.89 90.19,40.39 arc(90.38,40.57) 90.63,40.64 90.63,40.64 arc(90.88,40.7) 91.06,40.89 arc(91.24,41.07) 91.48,41.14 91.5,41.14 arc(91.75,41.21) 91.93,41.39 91.93,41.39 arc(92.11,41.57) 92.36,41.64 arc(92.6,41.7) 92.79,41.88 92.79,41.89 arc(92.98,42.07) 93.23,42.14 93.23,42.14 arc(93.48,42.2) 93.66,42.39 arc(93.84,42.57) 94.09,42.64 94.09,42.64 arc(94.34,42.7) 94.52,42.88 94.53,42.89 arc(94.71,43.07) 94.96,43.14 94.96,43.14 arc(95.21,43.2) 95.39,43.39 arc(95.57,43.57) 95.81,43.64 95.82,43.64 arc(96.07,43.7) 96.26,43.88 96.26,43.89 arc(96.44,44.07) 96.69,44.14 96.69,44.14 arc(96.94,44.07) 97.12,43.89 arc(97.3,43.71) 97.55,43.64 97.56,43.64 arc(97.8,43.7) 97.99,43.88 97.99,43.89 arc(98.18,44.07) 98.42,44.14 arc(98.67,44.2) 98.85,44.38 98.85,44.39 99.19,44.9 arc(99.35,45.06) 99.57,45.13 99.59,45.13 arc(99.82,45.19) 99.98,45.35 99.99,45.36 arc(100.16,45.53) 100.38,45.59 100.39,45.59 arc(100.62,45.65) 100.78,45.82 arc(100.95,45.98) 101.17,46.05 101.18,46.05 arc(101.41,46.11) 101.58,46.27 101.58,46.28 arc(101.75,46.44) 101.97,46.51 101.99,46.51 arc(102.21,46.57) 102.38,46.74 arc(102.54,46.9) 102.77,46.97 102.78,46.97 arc(103.01,47.03) 103.17,47.2 103.18,47.2 arc(103.34,47.37) 103.57,47.43 arc(103.8,47.37) 103.97,47.2 103.97,47.2 arc(104.14,47.03) 104.36,46.97 104.37,46.97 arc(104.6,46.91) 104.76,46.74 104.77,46.74 arc(104.93,46.57) 105.16,46.51 105.17,46.51 arc(105.4,46.57) 105.56,46.74 arc(105.73,46.9) 105.96,46.97 105.96,46.97 arc(106.19,46.91) 106.36,46.74 v1(106.76,46.05)
DDR4_COMP_CH0_DQ0: length 40.4
  L12_SIG4 w0.089: v1(108.35,40.53) 108.14,40.16 107.95,39.83 arc(107.89,39.6) 107.95,39.38 arc(108.02,39.15) 107.96,38.92 107.95,38.91 arc(107.89,38.68) 107.95,38.46 107.96,38.45 arc(108.02,38.22) 107.95,38 107.3,37.35 106.43,37.35 105.29,36.21 103.81,36.21 100.66,33.06 99.11,33.06 99.02,32.97 99.02,31.62 98.92,31.52 98.75,31.52 98.66,31.61 98.66,32.97 98.57,33.06 98.39,33.06 98.31,32.97 98.31,31.62 98.21,31.52 98.04,31.52 97.95,31.61 97.95,32.97 97.86,33.06 97.68,33.06 97.59,32.97 97.59,31.62 97.5,31.52 97.33,31.52 97.24,31.61 97.24,32.97 97.15,33.06 96.28,33.06 95.23,32.01 92.27,32.01 92.02,31.77 92.02,31.64 92.6,31.06 92.6,30.93 92.49,30.81 92.36,30.81 91.78,31.4 91.65,31.4 89.72,29.47 89.72,24.56 v1(90.14,24.14)
DDR4_COMP_CH0_DQ1: length 40.1
  L12_SIG4 w0.089: v1(110.74,40.07) 110.32,39.33 arc(110.27,39.15) 110.32,38.96 110.39,38.84 arc(110.43,38.7) 110.39,38.55 110.31,38.42 arc(110.25,38.2) 110.31,37.97 110.35,37.89 arc(110.39,37.78) 110.41,37.67 110.41,36.56 109.77,35.93 109.77,35.45 109.02,34.7 106.46,34.7 105.75,34 104.87,34 103.59,32.72 103.02,32.72 102.79,32.49 102.79,31.92 100.21,29.34 98.66,29.34 98.57,29.25 98.57,28 98.48,27.91 98.3,27.91 98.21,28 98.21,29.25 98.12,29.34 97.94,29.34 97.85,29.25 97.85,28.02 97.74,27.91 97.59,27.91 97.5,28 97.5,29.25 97.41,29.34 97.23,29.34 97.14,29.25 97.14,28.02 97.04,27.92 96.91,27.92 96.79,28.04 96.79,29.25 96.67,29.37 96.26,29.37 96.11,29.23 96.11,27.02 96.01,26.91 95.48,26.91 95.31,27.08 95.31,28.36 95.16,28.51 94.25,28.51 93.64,27.9 93.64,24.63 93.74,24.53 94.05,24.53 94.14,24.62 v1(94.14,24.94)
DDR4_COMP_CH0_DQ2: length 41.1
  L12_SIG4 w0.089: v1(90.94,23.34) 90.93,23.34 90.56,23.71 90.56,29.74 91.17,30.35 93.27,30.35 93.43,30.5 93.43,31.47 93.59,31.63 96.39,31.63 96.49,31.52 96.49,30.42 96.58,30.33 97.33,30.33 97.5,30.5 97.5,30.92 97.59,31.01 99.1,31.01 103.76,35.67 103.76,35.67 103.94,35.84 106.04,35.84 106.13,35.93 106.13,36.38 106.22,36.47 106.38,36.47 106.47,36.38 106.47,35.93 106.56,35.84 107.52,35.84 107.95,36.27 107.95,36.83 108.19,37.07 108.64,37.07 108.81,37.24 108.81,37.77 arc(108.8,37.89) 108.75,38 108.74,38.01 arc(108.69,38.23) 108.75,38.46 arc(108.81,38.68) 108.75,38.91 108.75,38.92 arc(108.69,39.15) 108.75,39.38 arc(108.81,39.6) 108.75,39.83 108.75,39.84 arc(108.69,40.07) 108.75,40.3 arc(108.81,40.52) 108.75,40.75 108.75,40.76 arc(108.69,40.99) 108.75,41.22 108.75,42.99 arc(108.77,43.09) 108.83,43.18 108.91,43.26 arc(108.98,43.31) 109.07,43.33 109.3,43.33 arc(109.48,43.25) 109.55,43.07 109.55,42.24 arc(109.58,42.12) 109.65,42.01 arc(109.76,41.93) 109.89,41.91 110.1,41.91 v1(110.74,41.91)
DDR4_COMP_CH0_DQ3: length 40.3
  L12_SIG4 w0.089: v1(111.54,40.53) 111.94,39.83 arc(112,39.6) 111.94,39.38 arc(111.88,39.15) 111.94,38.92 111.94,38.91 arc(112,38.68) 111.94,38.46 arc(111.88,38.23) 111.93,38.01 111.91,37.99 111.91,37.55 arc(111.91,37.5) 111.88,37.47 111.51,37.1 arc(111.48,37.07) 111.45,37.04 arc(111.36,36.9) 111.28,36.74 111.2,36.53 arc(111.19,36.49) 111.18,36.44 arc(111.14,36.35) 111.08,36.27 110.46,35.64 110.46,35.17 109.27,33.98 106.7,33.98 106.04,33.31 105.32,33.31 101.88,29.88 101.88,24.64 101.79,24.55 98.95,24.55 98.86,24.64 98.86,25.6 98.77,25.7 98.6,25.7 98.51,25.61 98.51,24.18 98.42,24.09 98.24,24.09 98.15,24.18 98.15,25.42 98.06,25.5 97.89,25.5 97.8,25.42 97.8,24.18 97.71,24.09 97.53,24.09 97.44,24.18 97.44,25.32 97.35,25.41 97.17,25.41 97.09,25.32 97.09,24.18 97,24.09 96.82,24.09 96.73,24.18 96.73,25.32 96.64,25.41 96.46,25.41 96.37,25.32 96.37,24.64 96.29,24.55 94.79,24.55 94.51,24.27 94.51,23.98 94.14,23.61 v1(94.14,23.34)
DDR4_COMP_CH0_DQ4: length 40.3
  L12_SIG4 w0.089: v1(90.14,23.34) 89.73,23.75 88.99,23.75 88.88,23.86 88.88,29.12 89.39,29.63 89.39,29.76 89.07,30.08 89.07,30.21 89.18,30.32 89.31,30.32 89.63,30 89.76,30 89.88,30.12 89.88,30.24 89.55,30.57 89.55,30.69 89.67,30.81 89.79,30.81 90.12,30.49 90.24,30.49 90.36,30.6 90.36,30.73 90.04,31.05 90.04,31.18 90.15,31.29 90.28,31.29 90.6,30.97 90.73,30.97 91.32,31.56 91.32,31.75 91.03,32.04 91.03,32.17 91.15,32.29 91.28,32.29 91.53,32.04 91.66,32.04 91.78,32.17 91.78,32.29 91.53,32.55 91.53,32.67 91.94,33.09 92.29,33.09 92.38,33 92.38,32.45 92.47,32.36 92.64,32.36 92.73,32.45 92.73,33 92.82,33.09 93,33.09 93.09,33 93.09,32.45 93.18,32.36 93.35,32.36 93.44,32.45 93.44,33 93.53,33.09 93.71,33.09 93.8,33 93.8,32.45 93.89,32.36 94.07,32.36 94.15,32.45 94.15,33 94.24,33.09 94.59,33.09 94.67,33 94.67,32.51 94.76,32.43 94.92,32.43 95.02,32.52 95.02,33 95.11,33.09 95.59,33.09 95.96,33.46 100.57,33.46 103.67,36.55 103.69,36.55 103.72,36.58 104.47,36.58 105.25,37.36 arc(105.28,37.39) 105.33,37.39 105.43,37.39 arc(105.93,37.53) 106.3,37.9 106.36,38 arc(106.52,38.16) 106.75,38.23 106.77,38.23 arc(106.99,38.29) 107.16,38.46 arc(107.22,38.68) 107.16,38.91 107.15,38.92 arc(107.1,39.15) 107.16,39.38 v1(107.56,40.07)
DDR4_COMP_CH0_DQ5: length 40.7
  L12_SIG4 w0.089: v1(94.94,23.34) 94.94,23.64 95.03,23.73 96.38,23.73 96.46,23.64 96.46,22.77 96.55,22.68 96.73,22.68 96.82,22.77 96.82,23.64 96.91,23.73 97.09,23.73 97.18,23.64 97.18,22.77 97.27,22.68 97.44,22.68 97.53,22.77 97.53,23.64 97.62,23.73 97.8,23.73 97.89,23.64 97.89,22.62 97.98,22.53 98.14,22.53 98.24,22.63 98.24,23.64 98.33,23.73 99.83,23.73 99.92,23.64 99.92,23.02 100.01,22.93 100.58,22.93 100.67,23.02 100.67,23.64 100.77,23.73 102.12,23.73 102.26,23.87 102.26,29.77 105.46,32.97 106.18,32.97 106.85,33.64 109.41,33.64 110.96,35.19 111.68,35.19 112.67,36.18 112.67,36.9 112.76,36.99 113.03,36.99 113.12,37.08 113.12,37.25 113.03,37.33 112.76,37.33 112.67,37.42 112.67,37.77 arc(112.69,37.89) 112.73,38 arc(112.8,38.22) 112.74,38.45 112.73,38.46 arc(112.67,38.68) 112.73,38.91 112.74,38.92 arc(112.8,39.15) 112.73,39.38 arc(112.67,39.6) 112.73,39.83 112.74,39.84 arc(112.74,40.3) 112.34,40.53 112.33,40.53 arc(112.1,40.59) 111.94,40.76 v1(111.54,41.45)
DDR4_COMP_CH0_DQ6: length 42.2
  L12_SIG4 w0.089: v1(90.94,22.54) 90.72,22.54 90.29,22.12 88.8,22.12 88.19,22.73 88.19,30.3 91.83,33.94 95.33,33.94 95.6,34.21 98.52,34.21 98.61,34.3 98.61,35.01 98.7,35.1 98.88,35.1 98.96,35.01 98.96,34.3 99.05,34.21 99.23,34.21 99.32,34.3 99.32,35.63 99.44,35.74 99.55,35.74 99.68,35.62 99.68,34.3 99.76,34.21 100.33,34.21 100.56,34.44 100.56,34.91 100.65,35 100.87,35 100.96,35.09 100.96,35.26 100.87,35.34 100.57,35.34 100.44,35.48 100.44,35.92 101.26,36.74 102.59,36.74 103.17,37.33 103.76,37.33 103.97,37.54 arc(104.03,37.76) 103.98,37.99 103.96,38.01 arc(103.91,38.23) 103.97,38.46 arc(104.13,38.62) 104.36,38.69 104.37,38.69 arc(104.59,38.75) 104.76,38.91 104.77,38.92 arc(104.94,39.09) 105.16,39.15 105.17,39.15 arc(105.4,39.21) 105.56,39.38 arc(105.62,39.6) 105.57,39.83 105.56,39.84 arc(105.5,40.07) 105.56,40.3 arc(105.73,40.46) 105.95,40.53 105.96,40.53 arc(106.19,40.59) 106.36,40.76 106.36,40.76 arc(106.53,40.93) 106.76,40.99 106.77,40.99 arc(106.99,41.05) 107.16,41.22 v1(107.56,41.91)
DDR4_COMP_CH0_DQ7: length 42.6
  L12_SIG4 w0.089: v1(94.14,22.54) 93.85,22.54 93.76,22.63 93.76,23.91 93.59,24.08 92.67,24.08 92.58,23.99 92.58,23.77 92.49,23.68 92.33,23.68 92.24,23.77 92.24,23.99 92.15,24.08 91.72,24.08 91.52,23.88 91.52,23.17 91.27,22.91 88.77,22.91 88.54,23.14 88.54,30.17 91.81,33.44 92.18,33.44 92.34,33.6 92.52,33.6 92.68,33.44 92.87,33.44 93.02,33.6 93.21,33.6 93.37,33.44 93.55,33.44 93.71,33.6 93.9,33.6 94.05,33.44 94.24,33.44 94.4,33.6 94.58,33.6 94.74,33.44 95.42,33.44 95.78,33.8 100.41,33.8 101.65,35.05 101.65,35.17 101.34,35.49 101.34,35.61 101.45,35.73 101.58,35.73 101.89,35.41 102.02,35.41 103.59,36.98 104.35,36.98 104.7,37.34 104.7,37.77 arc(104.72,37.89) 104.77,38 arc(104.93,38.16) 105.16,38.23 105.17,38.23 arc(105.4,38.29) 105.56,38.46 arc(105.73,38.62) 105.95,38.69 105.96,38.69 arc(106.19,38.75) 106.36,38.91 106.36,38.92 arc(106.42,39.15) 106.36,39.38 arc(106.36,39.84) 106.76,40.07 106.76,40.07 arc(106.99,40.13) 107.16,40.3 arc(107.32,40.46) 107.55,40.53 107.56,40.53 arc(107.79,40.59) 107.95,40.76 v1(108.35,41.45)
DDR4_COMP_CH0_DQ8: length 42.2
  L07_SIG3 w0.089: v1(90.94,28.94) 91.74,28.13 91.74,26.37 91.49,26.12 91.49,26.11 87.35,26.11 86.84,26.62 86.84,36.03 88.06,37.24 99.07,37.24 99.93,38.1 100.31,38.1 100.87,38.66 101.28,38.66 101.52,38.9 101.52,43.29 arc(101.53,43.41) 101.58,43.52 101.58,43.52 arc(101.75,43.69) 101.98,43.75 arc(102.21,43.81) 102.38,43.98 arc(102.54,44.14) 102.77,44.21 102.78,44.21 arc(103.01,44.27) 103.17,44.44 arc(103.34,44.6) 103.57,44.67 103.58,44.67 arc(103.8,44.6) 103.97,44.44 arc(104.14,44.27) 104.36,44.21 v1(105.17,44.21)
DDR4_COMP_CH0_DQ9: length 45.1
  L07_SIG3 w0.089: v1(108.35,44.21) 108.15,44 108.15,43.61 107.98,43.44 107.98,42.72 107.71,42.45 107.7,42.45 107.53,42.28 107.4,42.28 107.18,42.06 107.18,36.51 106.94,36.27 106.32,36.27 103.38,33.33 99.23,33.33 99.08,33.48 98.9,33.48 98.79,33.37 98.79,32.75 98.73,32.69 98.44,32.69 98.35,32.78 98.35,33.59 98.25,33.69 98.01,33.69 97.92,33.6 97.92,32.72 97.83,32.63 97.66,32.63 97.57,32.72 97.57,33.6 97.48,33.69 97.3,33.69 97.21,33.6 97.21,32.72 97.12,32.63 96.95,32.63 96.86,32.72 96.86,33.6 96.77,33.69 95.41,33.69 95.32,33.6 95.32,33.29 95.43,33.17 95.95,33.17 96.04,33.08 96.04,32.92 95.95,32.83 95.49,32.83 95.35,32.68 95.35,32.34 95.43,32.25 96.01,32.25 96.1,32.16 96.1,32 96.01,31.91 95.43,31.91 95.35,31.82 95.35,31.45 95.5,31.3 96.13,31.3 97.58,29.85 97.58,29.45 97.45,29.32 96.94,29.32 96.85,29.23 96.85,29.06 96.94,28.97 97.57,28.97 97.64,28.89 97.64,28.72 97.54,28.61 96.94,28.61 96.85,28.52 96.85,28.34 96.94,28.26 97.53,28.26 97.64,28.14 97.64,27.47 97.46,27.29 96.62,27.29 96.49,27.41 96.49,28.81 96.4,28.9 96.23,28.9 96.14,28.8 96.14,27.85 96.05,27.76 95.03,27.76 94.94,27.85 v1(94.94,28.14)
DDR4_COMP_CH0_DQ10: length 42.7
  L07_SIG3 w0.089: v1(90.94,27.34) 90.7,27.34 90.27,27.76 89.04,27.76 88.55,28.25 88.55,28.51 88.47,28.6 87.87,28.6 87.78,28.69 87.78,28.86 87.87,28.95 88.47,28.95 88.55,29.04 88.55,29.2 88.47,29.29 87.87,29.29 87.78,29.38 87.78,29.54 87.87,29.63 88.47,29.63 88.55,29.72 88.55,29.89 88.47,29.97 87.87,29.97 87.78,30.06 87.78,30.23 87.87,30.32 88.47,30.32 88.55,30.41 88.55,30.57 88.47,30.66 87.87,30.66 87.78,30.75 87.78,30.91 87.87,31 88.47,31 88.55,31.09 88.55,31.26 88.47,31.35 87.87,31.35 87.78,31.44 87.78,31.6 87.87,31.69 88.47,31.69 88.55,31.78 88.55,31.94 88.47,32.03 87.87,32.03 87.78,32.12 87.78,32.29 87.87,32.38 88.47,32.38 88.55,32.46 88.55,32.63 88.47,32.72 87.87,32.72 87.78,32.81 87.78,32.97 87.87,33.06 88.47,33.06 88.55,33.15 88.55,33.31 88.47,33.4 87.87,33.4 87.78,33.49 87.78,33.66 87.87,33.75 88.47,33.75 88.55,33.84 88.55,35.49 88.94,35.88 98.11,35.88 98.79,36.55 99.35,36.55 99.65,36.86 102.57,36.86 103.17,37.45 103.17,38.43 103.17,38.46 arc(103.11,38.68) 103.17,38.91 103.17,38.92 arc(103.23,39.15) 103.17,39.38 arc(103.11,39.6) 103.17,39.83 103.17,39.84 arc(103.23,40.07) 103.17,40.3 arc(103.11,40.52) 103.17,40.75 103.18,40.76 arc(103.23,40.99) 103.17,41.22 arc(103.11,41.44) 103.17,41.67 103.18,41.69 arc(103.23,41.91) 103.17,42.14 arc(103.11,42.36) 103.16,42.58 103.18,42.6 arc(103.34,42.77) 103.57,42.83 v1(104.37,42.83)
DDR4_COMP_CH0_DQ11: length 43.5
  L07_SIG3 w0.089: v1(107.56,42.83) 106.76,42.83 arc(106.53,42.89) 106.36,43.06 arc(106.19,43.22) 105.96,43.29 105.96,43.29 arc(105.73,43.22) 105.56,43.06 arc(105.5,42.83) 105.56,42.6 105.56,42.6 arc(105.63,42.37) 105.57,42.15 105.56,42.12 arc(105.5,41.9) 105.56,41.68 105.57,41.67 arc(105.62,41.44) 105.56,41.22 arc(105.5,40.99) 105.56,40.76 105.57,40.75 arc(105.62,40.52) 105.56,40.3 arc(105.5,40.07) 105.56,39.84 105.57,39.83 arc(105.62,39.6) 105.56,39.38 arc(105.5,39.15) 105.56,38.92 105.56,38.91 arc(105.62,38.68) 105.56,38.46 arc(105.5,38.23) 105.56,38.01 arc(105.61,37.89) 105.62,37.77 105.62,37.64 105.26,37.28 105.14,37.28 104.98,37.43 104.86,37.43 104.74,37.32 104.74,37.19 104.89,37.04 104.89,36.91 104.65,36.67 104.65,36.54 104.76,36.43 104.76,36.31 104.63,36.18 104.51,36.18 104.14,36.55 104.01,36.55 103.89,36.43 103.89,36.3 104.26,35.93 104.26,35.77 104.17,35.68 104.01,35.68 103.6,36.08 103.5,36.08 103.37,35.95 103.37,35.81 103.75,35.43 103.75,35.3 103.63,35.18 103.5,35.18 103.11,35.57 102.99,35.57 102.88,35.45 102.88,35.3 103.21,34.96 103.21,34.8 103.12,34.71 102.96,34.71 102.7,34.97 102.4,34.97 101.93,34.51 99.73,34.51 99.41,34.82 91.64,34.82 91.27,34.45 91.27,29.7 91.41,29.55 93.21,29.55 93.3,29.46 93.3,29.29 93.21,29.2 92.08,29.2 91.99,29.11 91.99,28.96 92.11,28.84 93.21,28.84 93.3,28.75 93.3,28.58 93.21,28.49 92.57,28.49 92.48,28.4 92.48,27.48 92.62,27.34 92.97,27.34 93.06,27.43 93.06,27.92 93.15,28.01 93.32,28.01 93.41,27.92 93.41,27.43 93.5,27.34 v1(94.14,27.34)
DDR4_COMP_CH0_DQ12: length 41.8
  L07_SIG3 w0.089: v1(90.14,27.34) 90.14,27.04 90.05,26.95 87.66,26.95 87.36,27.26 87.36,35.44 88.14,36.22 91.7,36.22 91.79,36.31 91.79,36.81 91.88,36.9 92.05,36.9 92.14,36.81 92.14,36.31 92.23,36.22 92.41,36.22 92.5,36.31 92.5,36.81 92.59,36.9 92.77,36.9 92.85,36.81 92.85,36.31 92.94,36.22 93.12,36.22 93.21,36.31 93.21,36.81 93.3,36.9 93.48,36.9 93.57,36.81 93.57,36.31 93.65,36.22 93.83,36.22 93.92,36.31 93.92,36.81 94.01,36.9 94.19,36.9 94.28,36.81 94.28,36.31 94.37,36.22 95.13,36.22 95.21,36.31 95.21,36.81 95.3,36.9 95.48,36.9 95.57,36.81 95.57,36.31 95.66,36.22 95.84,36.22 95.93,36.31 95.93,36.81 96.02,36.9 96.19,36.9 96.28,36.81 96.28,36.31 96.37,36.22 97.95,36.22 98.63,36.9 99.21,36.9 99.52,37.21 101.08,37.21 101.42,37.55 101.42,38.01 101.55,38.14 101.96,38.14 102.35,38.53 102.35,39.11 102.31,39.14 arc(102.33,39.26) 102.38,39.38 arc(102.44,39.6) 102.38,39.83 102.37,39.84 arc(102.31,40.07) 102.38,40.3 arc(102.44,40.52) 102.38,40.75 102.37,40.76 arc(102.31,40.99) 102.38,41.22 arc(102.44,41.44) 102.38,41.67 102.38,41.68 arc(102.31,41.9) 102.37,42.12 102.38,42.15 arc(102.44,42.37) 102.38,42.6 arc(102.31,42.83) 102.38,43.06 arc(102.54,43.22) 102.77,43.29 102.77,43.29 arc(103,43.35) 103.17,43.51 103.17,43.52 arc(103.34,43.69) 103.57,43.75 v1(104.37,43.75)
DDR4_COMP_CH0_DQ13: length 43.3
  L07_SIG3 w0.089: v1(108.35,42.37) 107.95,41.67 arc(107.89,41.44) 107.95,41.22 arc(108.02,40.99) 107.96,40.76 107.95,40.75 arc(107.89,40.52) 107.95,40.3 arc(108.02,40.07) 107.96,39.84 107.95,39.83 arc(107.89,39.6) 107.95,39.38 arc(108.02,39.15) 107.96,38.92 107.95,38.91 arc(107.89,38.68) 107.95,38.46 107.96,38.45 arc(108.02,38.22) 107.95,38 arc(107.75,37.58) 107.61,37.13 arc(107.6,37.08) 107.58,37.04 107.58,36.34 107.15,35.91 106.45,35.91 106.04,35.5 106.04,35.38 106.28,35.13 106.28,35.01 106.16,34.88 106.03,34.88 105.79,35.12 105.66,35.12 104.99,34.45 104.99,34.32 105.23,34.08 105.23,33.96 105.1,33.83 104.98,33.83 104.73,34.07 104.61,34.07 104.48,33.95 104.48,33.82 104.73,33.58 104.73,33.45 104.6,33.33 104.48,33.33 104.23,33.57 104.11,33.57 103.98,33.44 103.98,33.32 104.22,33.08 104.22,32.95 103.75,32.48 103.63,32.48 103.19,32.92 102.91,32.92 102.79,32.79 102.79,32.34 102.7,32.26 102.22,32.26 102.13,32.35 102.13,32.9 102.04,32.98 101.86,32.98 101.77,32.9 101.77,32.35 101.68,32.26 101.51,32.26 101.42,32.35 101.42,32.9 101.33,32.98 101.15,32.98 101.06,32.9 101.06,32.35 100.97,32.26 100.63,32.26 100.54,32.35 100.54,32.9 100.45,32.98 100.27,32.98 100.18,32.9 100.18,32.35 100.1,32.26 99.92,32.26 99.83,32.35 99.83,32.9 99.74,32.98 99.56,32.98 99.47,32.9 99.47,32.35 99.38,32.26 98.25,32.26 98.16,32.17 98.16,32.02 98.07,31.93 97.89,31.93 97.81,32.02 97.81,32.17 97.72,32.26 97.36,32.26 97.27,32.17 97.27,31.6 97.36,31.51 98.25,31.51 98.33,31.42 98.33,31.24 98.25,31.15 97.43,31.15 97.37,31.09 97.37,30.73 97.41,30.7 97.68,30.7 97.82,30.56 97.82,30.36 97.98,30.19 97.98,27.07 97.86,26.95 97.61,26.95 97.52,26.86 97.52,25.85 97.4,25.72 97.27,25.72 97.18,25.81 97.18,26.86 97.09,26.95 96.75,26.95 96.66,26.86 96.66,25.58 96.57,25.49 96.43,25.49 96.3,25.61 96.3,26.86 96.22,26.95 95.04,26.95 94.94,27.05 v1(94.94,27.34)
DDR4_COMP_CH0_DQ14: length 45.3
  L07_SIG3 w0.089: v1(90.94,26.54) 91.31,26.54 91.4,26.63 91.4,27.56 91.24,27.71 90.81,27.71 90.51,28.01 90.51,28.29 90.29,28.51 89.12,28.51 88.9,28.74 88.9,29.32 88.99,29.41 90.05,29.41 90.14,29.5 90.14,29.67 90.05,29.76 88.99,29.76 88.9,29.85 88.9,30.46 88.99,30.55 89.38,30.55 89.47,30.64 89.47,30.81 89.38,30.9 88.99,30.9 88.9,30.99 88.9,31.15 88.99,31.24 89.38,31.24 89.47,31.33 89.47,31.49 89.38,31.58 88.99,31.58 88.9,31.67 88.9,31.84 88.99,31.93 89.38,31.93 89.47,32.01 89.47,32.18 89.38,32.27 88.99,32.27 88.9,32.36 88.9,32.52 88.99,32.61 89.38,32.61 89.47,32.7 89.47,32.86 89.38,32.95 88.99,32.95 88.9,33.04 88.9,33.21 88.99,33.3 89.38,33.3 89.47,33.39 89.47,33.55 89.38,33.64 88.99,33.64 88.9,33.73 88.9,33.89 88.99,33.98 89.38,33.98 89.47,34.07 89.47,35.27 89.71,35.51 99.32,35.51 99.45,35.65 99.45,36.17 99.8,36.52 100.22,36.52 100.31,36.43 100.31,35.97 100.4,35.88 100.58,35.88 100.66,35.97 100.66,36.43 100.75,36.52 102.97,36.52 103.96,37.51 103.96,38.01 arc(103.91,38.23) 103.97,38.46 arc(104.03,38.68) 103.97,38.91 103.97,38.92 arc(103.91,39.15) 103.97,39.38 arc(104.03,39.6) 103.97,39.83 103.97,39.84 arc(103.91,40.07) 103.97,40.3 arc(104.03,40.52) 103.97,40.75 103.97,40.76 arc(103.91,40.99) 103.97,41.22 arc(104.03,41.44) 103.97,41.67 103.97,41.68 arc(103.91,41.9) 103.96,42.12 103.98,42.15 arc(104.14,42.31) 104.37,42.37 arc(104.6,42.43) 104.76,42.59 104.77,42.6 arc(104.83,42.83) 104.77,43.06 arc(104.71,43.29) 104.77,43.52 104.77,43.52 arc(104.94,43.69) 105.17,43.75 105.17,43.75 arc(105.4,43.81) 105.56,43.98 arc(105.73,44.14) 105.95,44.21 105.96,44.21 106.36,43.98 106.36,43.97 arc(106.53,43.81) 106.76,43.75 v1(107.56,43.75)
DDR4_COMP_CH0_DQ15: length 41.9
  L07_SIG3 w0.089: v1(105.17,42.37) 104.76,41.67 arc(104.7,41.44) 104.77,41.22 arc(104.83,40.99) 104.77,40.76 104.76,40.75 arc(104.7,40.52) 104.77,40.3 arc(104.83,40.07) 104.77,39.84 104.76,39.83 arc(104.7,39.6) 104.77,39.38 arc(104.83,39.15) 104.77,38.92 104.76,38.91 arc(104.7,38.68) 104.77,38.46 104.77,38.45 arc(104.83,38.22) 104.77,38 arc(104.72,37.89) 104.7,37.77 101.79,34.85 99.87,34.85 99.55,35.17 90.47,35.17 90.33,35.03 90.33,34.69 90.25,34.6 89.9,34.6 89.81,34.51 89.81,34.35 89.9,34.26 90.49,34.26 90.59,34.16 90.59,34.01 90.5,33.92 89.9,33.92 89.81,33.83 89.81,33.66 89.9,33.57 90.49,33.57 90.59,33.47 90.59,33.32 90.5,33.23 89.9,33.23 89.81,33.14 89.81,32.98 89.9,32.89 90.49,32.89 90.59,32.79 90.59,32.63 90.5,32.55 89.9,32.55 89.81,32.46 89.81,32.29 89.9,32.2 90.49,32.2 90.59,32.1 90.59,31.95 90.5,31.86 89.9,31.86 89.81,31.77 89.81,31.61 89.9,31.52 90.49,31.52 90.59,31.42 90.59,31.26 90.5,31.17 89.9,31.17 89.81,31.08 89.81,30.92 89.9,30.83 90.25,30.83 90.33,30.74 90.33,30.07 91.31,29.09 91.31,29.05 92.09,28.28 92.09,26.17 92.18,26.08 92.62,26.08 92.73,26.19 92.73,26.91 92.82,27 93,27 93.09,26.91 93.09,26.2 93.18,26.11 94.08,26.11 94.14,26.17 v1(94.14,26.54)
DDR4_COMP_CH0_DQ16: length 32.1
  L14_SIG5 w0.081: v1(114.73,45.13) 113.93,45.13 arc(113.53,44.9) 113.53,44.44 113.54,44.43 arc(113.59,44.2) 113.53,43.98 arc(113.47,43.75) 113.53,43.52 113.53,43.51 arc(113.59,43.29) 113.53,43.06 arc(113.47,42.83) 113.53,42.6 113.53,42.6 arc(113.59,42.37) 113.54,42.15 113.54,33.97 112.87,33.3 112.47,33.3 112.37,33.39 112.37,33.79 112.29,33.87 112.12,33.87 112.04,33.79 112.04,33.39 111.95,33.3 111.8,33.3 111.7,33.39 111.7,33.79 111.62,33.87 111.45,33.87 111.37,33.79 111.37,33.39 111.28,33.3 109.53,33.3 109.29,33.06 109.29,32.71 109.37,32.62 109.65,32.62 109.73,32.54 109.73,32.37 109.65,32.29 109.37,32.29 109.29,32.21 109.29,32.03 109.37,31.95 109.65,31.95 109.73,31.87 109.73,31.7 109.65,31.62 109.37,31.62 109.29,31.54 109.29,31.36 109.37,31.28 109.65,31.28 109.73,31.2 109.73,31.03 109.65,30.95 109.37,30.95 109.29,30.87 109.29,30.69 109.37,30.61 109.65,30.61 109.73,30.53 109.73,30.36 109.65,30.28 109.37,30.28 109.29,30.2 109.29,30.02 109.37,29.94 109.65,29.94 109.74,29.85 109.74,29.7 109.65,29.61 109.37,29.61 109.29,29.52 109.29,24.69 109.46,24.51 109.83,24.51 110.2,24.14 v1(110.46,24.14)
DDR4_COMP_CH0_DQ17: length 29.8
  L14_SIG5 w0.081: v1(117.12,44.67) 116.72,43.98 arc(116.66,43.75) 116.72,43.52 116.72,43.52 116.72,36.44 116.8,36.36 117.08,36.36 117.16,36.28 117.16,36.11 117.08,36.02 116.8,36.02 116.72,35.94 116.72,35.77 116.8,35.69 117.08,35.69 117.16,35.61 117.16,35.44 117.08,35.35 116.8,35.35 116.72,35.27 116.72,35.1 116.8,35.02 117.08,35.02 117.16,34.94 117.16,34.76 117.08,34.68 116.8,34.68 116.72,34.6 116.72,34.43 116.8,34.35 117.08,34.35 117.16,34.27 117.16,34.09 117.08,34.01 116.8,34.01 116.72,33.93 116.72,33.76 116.8,33.68 117.08,33.68 117.16,33.6 117.16,33.42 117.08,33.34 116.8,33.34 116.72,33.26 116.72,33.09 116.8,33.01 117.08,33.01 117.16,32.93 117.16,32.75 117.08,32.67 116.8,32.67 116.72,32.59 116.72,32.42 116.8,32.34 117.08,32.34 117.16,32.26 117.16,32.08 117.08,32 116.8,32 116.72,31.92 116.72,31.75 116.8,31.67 117.08,31.67 117.16,31.58 117.16,31.41 117.08,31.33 116.8,31.33 116.72,31.25 116.72,31.08 116.8,31 117.08,31 117.16,30.91 117.16,30.74 117.08,30.66 116.8,30.66 116.72,30.58 116.72,30.41 116.8,30.33 117.08,30.33 117.16,30.24 117.16,30.07 117.08,29.99 116.8,29.99 116.72,29.91 116.72,29.74 116.8,29.65 117.08,29.65 117.16,29.57 117.16,29.4 117.08,29.32 116.8,29.32 116.72,29.24 116.72,29.07 116.8,28.98 117.08,28.98 117.16,28.9 117.16,28.73 117.08,28.65 116.8,28.65 116.72,28.57 116.72,25.8 116.28,25.36 114.88,25.36 v1(114.46,24.94)
DDR4_COMP_CH0_DQ18: length 31
  L14_SIG5 w0.081: v1(111.26,23.34) 110.96,23.34 110.83,23.47 110.83,24.35 110.67,24.51 110.3,24.51 110.08,24.74 110.08,30.07 110.16,30.15 110.87,30.15 110.95,30.23 110.95,30.4 110.87,30.48 110.16,30.48 110.08,30.56 110.08,30.74 110.16,30.82 110.99,30.82 111.08,30.9 111.08,31.07 110.99,31.15 110.16,31.15 110.08,31.23 110.08,31.41 110.16,31.49 110.99,31.49 111.08,31.57 111.08,31.74 110.99,31.82 110.16,31.82 110.08,31.9 110.08,32.82 110.21,32.96 113.01,32.96 114.33,34.28 114.33,42.14 arc(114.27,42.36) 114.32,42.58 114.33,42.6 arc(114.39,42.83) 114.33,43.06 arc(114.27,43.29) 114.33,43.51 114.33,43.52 arc(114.39,43.75) 114.33,43.98 v1(113.93,44.67)
DDR4_COMP_CH0_DQ19: length 28.1
  L14_SIG5 w0.081: v1(114.46,23.34) 113.6,23.34 113.46,23.48 113.46,24.38 113.65,24.57 117.29,24.57 117.49,24.77 117.49,43.95 117.52,43.98 arc(117.45,44.2) 117.51,44.43 117.52,44.44 arc(117.58,44.67) 117.52,44.9 arc(117.45,45.12) 117.51,45.35 117.52,45.36 arc(117.58,45.59) 117.52,45.82 v1(117.12,46.51)
DDR4_COMP_CH0_DQ20: length 31.1
  L14_SIG5 w0.081: v1(110.46,23.34) 110.06,23.74 109.5,23.74 108.93,24.31 108.93,33.17 109.97,34.22 112.41,34.22 112.76,34.56 112.76,35.49 112.68,35.57 112.3,35.57 112.21,35.65 112.21,35.82 112.3,35.9 112.68,35.9 112.76,35.98 112.76,36.16 112.68,36.24 112.3,36.24 112.21,36.32 112.21,36.49 112.3,36.57 112.68,36.57 112.76,36.65 112.76,36.83 112.68,36.91 112.3,36.91 112.21,36.99 112.21,37.16 112.3,37.24 112.68,37.24 112.76,37.32 112.76,42.11 112.73,42.14 arc(112.67,42.36) 112.73,42.58 112.74,42.6 arc(112.8,42.83) 112.74,43.06 arc(112.67,43.29) 112.73,43.51 112.74,43.52 arc(112.8,43.75) 112.74,43.98 arc(112.67,44.2) 112.73,44.43 112.74,44.44 arc(112.8,44.67) 112.74,44.9 arc(112.67,45.12) 112.73,45.35 112.74,45.36 arc(112.91,45.53) 113.13,45.59 113.14,45.59 arc(113.37,45.65) 113.53,45.82 arc(113.7,45.98) 113.92,46.05 v1(114.73,46.05)
DDR4_COMP_CH0_DQ21: length 28.9
  L14_SIG5 w0.081: v1(117.91,45.13) 118.31,44.44 118.31,36.46 117.89,36.04 117.89,34.79 118.49,34.19 118.49,26.46 118.41,26.38 117.91,26.38 117.83,26.3 117.83,26.13 117.91,26.04 118.41,26.04 118.49,25.96 118.49,25.79 118.41,25.71 117.91,25.71 117.83,25.63 117.83,25.46 117.91,25.37 118.41,25.37 118.49,25.29 118.49,25.12 118.41,25.04 117.91,25.04 117.83,24.96 117.83,24.78 117.91,24.7 118.41,24.7 118.49,24.62 118.49,23.96 117.47,22.94 115.66,22.94 v1(115.26,23.34)
DDR4_COMP_CH0_DQ22: length 31.2
  L14_SIG5 w0.081: v1(113.93,46.51) 113.13,46.51 arc(112.9,46.44) 112.74,46.28 112.73,46.27 arc(112.56,46.11) 112.34,46.05 112.33,46.05 arc(112.1,45.98) 111.94,45.82 arc(111.88,45.59) 111.94,45.36 111.94,45.35 arc(112,45.12) 111.94,44.9 arc(111.88,44.67) 111.93,44.44 111.94,44.43 arc(112,44.2) 111.94,43.98 arc(111.88,43.75) 111.94,43.52 111.94,43.51 arc(112,43.29) 111.94,43.06 arc(111.88,42.83) 111.94,42.6 111.94,42.6 arc(112,42.37) 111.95,42.15 111.93,42.12 arc(111.88,41.9) 111.94,41.68 111.94,41.67 arc(112,41.44) 111.94,41.22 111.94,37.51 111.72,37.3 111.25,37.3 111.08,37.12 111.08,34.79 110.91,34.63 109.91,34.63 108.59,33.31 108.59,22.39 108.81,22.16 111.14,22.16 111.26,22.29 v1(111.26,22.54)
DDR4_COMP_CH0_DQ23: length 28.6
  L14_SIG5 w0.081: v1(117.91,46.05) 117.91,45.75 118.63,45.04 118.87,45.04 119.11,44.79 119.11,34.31 119,34.2 119,28.67 119.41,28.25 119.41,24.28 117.27,22.13 114.87,22.13 v1(114.46,22.54)
DDR4_COMP_CH0_DQ24: length 45.5
  L12_SIG4 w0.089: v1(109.95,45.13) 110.21,44.68 110.21,44.65 arc(110.35,44.31) 110.68,44.17 110.85,44.17 111.12,43.9 111.12,43.18 111.56,42.74 111.7,42.74 112.02,42.42 112.55,42.42 113.13,41.84 113.47,41.84 113.77,41.53 114.14,41.53 114.32,41.35 114.32,36.42 110.97,33.07 110.14,33.07 109.83,32.76 107.75,32.76 107.15,32.16 105.81,32.16 103.5,29.85 103.5,26.48 103.85,26.14 104.43,26.14 104.7,26.4 104.7,29.23 104.87,29.4 105.34,29.4 105.5,29.24 105.5,25.58 105.73,25.36 107.74,25.36 108.59,26.21 108.59,27.72 109.43,28.56 110.88,28.56 v1(111.26,28.94)
DDR4_COMP_CH0_DQ25: length 44.4
  L12_SIG4 w0.089: v1(109.15,44.67) 109.55,45.36 arc(109.72,45.53) 109.95,45.59 arc(110.18,45.53) 110.34,45.36 arc(110.51,45.19) 110.74,45.13 110.74,45.13 arc(110.97,45.19) 111.14,45.36 111.14,45.36 arc(111.31,45.53) 111.54,45.59 arc(111.77,45.53) 111.94,45.36 arc(112.1,45.19) 112.33,45.13 112.34,45.13 arc(112.56,45.07) 112.73,44.9 112.88,44.75 113.14,44.75 113.6,44.29 114.05,44.29 114.51,43.83 114.91,43.83 115.37,43.37 115.58,43.37 116.21,42.74 116.48,42.74 116.71,42.51 116.71,37.59 116.29,37.16 116.29,36.3 113.19,33.21 113.19,31.42 112.88,31.11 109.73,31.11 109.64,31.02 109.64,30.59 109.55,30.5 109.39,30.5 109.3,30.59 109.3,31.02 109.21,31.11 109.04,31.11 108.95,31.02 108.95,30.59 108.86,30.5 108.7,30.5 108.61,30.59 108.61,31.02 108.52,31.11 108.18,31.11 107.86,30.79 107.86,29.97 108.15,29.68 108.46,29.68 108.94,30.16 110.26,30.16 110.35,30.25 110.35,30.59 110.44,30.68 110.62,30.68 110.71,30.59 110.71,30.25 110.79,30.16 112.62,30.16 113.9,31.44 115.47,31.44 116,30.92 116,29.53 116.43,29.09 116.43,28.65 116.34,28.56 115.94,28.56 115.52,28.14 v1(115.26,28.14)
DDR4_COMP_CH0_DQ26: length 43.8
  L12_SIG4 w0.089: v1(112.34,46.51) 112.54,46.51 arc(112.58,46.52) 112.62,46.54 112.69,46.61 arc(112.71,46.64) 112.72,46.69 112.72,47.03 arc(112.73,47.08) 112.76,47.12 112.98,47.34 113.32,47.34 113.78,47.8 114.09,47.8 114.48,47.41 114.99,47.41 115.51,46.88 115.88,46.88 115.95,46.81 115.95,46.81 116.17,46.59 116.33,46.59 116.96,45.96 117.27,45.96 117.73,45.5 118.07,45.5 118.36,45.21 118.8,45.21 119.43,44.58 119.66,44.58 119.9,44.35 119.9,38 120.28,37.62 120.28,35.86 arc(120.28,35.8) 120.27,35.73 arc(120.25,35.55) 120.22,35.38 120.15,35.06 arc(120.03,34.76) 119.84,34.51 119.26,33.93 arc(119.12,33.72) 119.07,33.47 119.07,31.95 arc(119.11,31.74) 119.23,31.56 119.3,31.49 arc(119.41,31.33) 119.44,31.15 119.44,30.69 119.41,30.57 119.33,30.35 118.99,29.61 118.84,29.32 118.51,28.96 arc(118.46,28.93) 118.4,28.92 118.13,28.92 118.05,28.83 118.04,28.83 117.9,28.68 117.9,27.96 117.16,27.03 116.3,26.16 114.11,26.16 114.01,26.26 114.01,26.43 113.92,26.53 113.77,26.53 113.65,26.41 113.65,25.52 113.55,25.42 113.4,25.42 113.28,25.53 113.28,26.37 113.19,26.45 112.58,26.45 112.49,26.37 112.49,25.36 112.4,25.27 112.22,25.27 112.14,25.36 112.14,25.94 112.05,26.03 111.85,26.03 111.63,25.81 111.63,25.13 111.5,25 110.93,25 110.61,25.31 110.31,25.31 110.05,25.58 110.05,25.91 110.3,26.16 110.66,26.16 110.88,26.38 110.88,27.25 110.97,27.34 v1(111.26,27.34)
DDR4_COMP_CH0_DQ27: length 44.9
  L12_SIG4 w0.089: v1(112.34,44.67) 112.36,44.67 112.76,44.27 112.76,43.97 112.9,43.83 113.32,43.83 113.95,43.2 114.28,43.2 114.57,42.91 114.74,42.91 115.37,42.28 115.68,42.28 115.9,42.06 115.9,41.76 115.9,41.75 115.9,37.51 115.82,37.42 115.74,37.42 115.65,37.33 115.65,37.17 115.74,37.08 115.86,37.08 115.95,36.99 115.95,36.45 112.76,33.26 112.76,32.36 112.11,31.7 111.48,31.7 111.22,31.45 108.04,31.45 107.52,30.93 106.24,30.93 105.99,30.69 105.99,30.16 106.76,29.39 106.76,27.98 106.92,27.83 107.22,27.83 107.83,28.43 107.83,28.56 107.53,28.85 107.53,28.98 107.66,29.11 107.78,29.11 108.08,28.81 108.21,28.81 109.19,29.8 112.09,29.8 112.23,29.66 112.23,29.21 112.23,28.63 112.37,28.49 112.84,28.49 112.93,28.58 112.93,29.95 114.08,31.1 115.31,31.1 115.65,30.76 115.65,28.81 115.63,28.79 115.63,28.78 115.41,28.56 115.41,28.56 115.4,28.55 114.79,28.55 114.46,28.22 v1(114.46,27.34)
DDR4_COMP_CH0_DQ28: length 43.2
  L12_SIG4 w0.089: v1(110.46,27.34) 110.46,27.33 110.16,26.82 arc(110.14,26.78) 110.12,26.73 110.06,26.53 arc(110.05,26.5) 110.05,26.48 arc(110,26.38) 109.93,26.28 109.91,26.26 arc(109.89,26.24) 109.86,26.22 arc(109.74,26.09) 109.68,25.92 109.64,25.67 arc(109.64,25.63) 109.65,25.59 arc(109.71,25.44) 109.81,25.32 109.96,25.17 arc(110.01,25.09) 110.03,25 arc(110.05,24.91) 110.08,24.82 110.16,24.68 110.21,24.63 arc(110.26,24.59) 110.32,24.57 110.75,24.49 arc(110.79,24.48) 110.84,24.48 112.04,24.48 arc(112.6,24.54) 113.13,24.73 114.07,25.2 arc(114.33,25.3) 114.62,25.33 115.92,25.33 arc(116.23,25.39) 116.5,25.57 116.61,25.69 arc(116.76,25.87) 116.88,26.06 arc(116.96,26.21) 117.06,26.34 118.65,28.36 arc(118.83,28.61) 118.99,28.86 arc(119.16,29.16) 119.31,29.47 119.64,30.21 arc(119.69,30.33) 119.74,30.46 arc(119.8,30.66) 119.84,30.86 119.95,31.57 arc(119.96,31.61) 119.97,31.65 120.06,32.58 arc(120.16,33.31) 120.3,34.02 120.51,35.04 120.56,35.3 arc(120.65,36.06) 120.69,36.83 120.69,39.43 120.69,39.43 120.69,42.68 120.69,42.69 120.69,43 120.69,43 120.69,44.71 arc(120.65,44.85) 120.56,44.95 119.88,45.42 arc(119.85,45.44) 119.81,45.46 119.58,45.57 arc(119.58,45.57) 119.57,45.57 arc(119.47,45.62) 119.37,45.66 arc(119.26,45.72) 119.15,45.79 118.97,45.92 arc(118.93,45.95) 118.89,45.97 118.71,46.06 arc(118.49,46.19) 118.27,46.32 118.09,46.43 arc(117.97,46.5) 117.84,46.55 arc(117.58,46.69) 117.35,46.86 arc(117.26,46.93) 117.16,46.99 arc(117.15,46.99) 117.14,47 116.69,47.2 116.6,47.27 arc(116.45,47.37) 116.29,47.45 arc(116.18,47.5) 116.08,47.57 115.98,47.65 arc(115.95,47.68) 115.91,47.7 115.4,47.97 arc(115.32,48.02) 115.24,48.07 arc(115.19,48.1) 115.14,48.13 arc(115.13,48.14) 115.11,48.15 114.61,48.39 arc(114.57,48.41) 114.52,48.44 114.33,48.57 arc(114.29,48.59) 114.24,48.62 114.06,48.7 arc(114.02,48.72) 113.98,48.72 113.79,48.72 arc(113.72,48.72) 113.65,48.69 arc(113.49,48.61) 113.35,48.5 113.32,48.47 arc(113.29,48.44) 113.24,48.43 112.92,48.3 arc(112.77,48.22) 112.63,48.11 112.49,47.97 arc(112.4,47.9) 112.3,47.85 112.21,47.81 arc(112.17,47.79) 112.14,47.76 112.06,47.68 arc(112,47.6) 111.97,47.51 111.93,47.3 arc(111.93,47.25) 111.93,47.21 111.93,46.94 arc(111.9,46.82) 111.84,46.72 111.72,46.6 arc(111.6,46.52) 111.45,46.47 111.37,46.46 arc(111.19,46.4) 111.05,46.27 arc(111.02,46.24) 110.98,46.21 arc(110.93,46.18) 110.88,46.15 arc(110.84,46.13) 110.8,46.11 110.57,46.06 arc(110.53,46.05) 110.48,46.05 v1(109.95,46.05)
