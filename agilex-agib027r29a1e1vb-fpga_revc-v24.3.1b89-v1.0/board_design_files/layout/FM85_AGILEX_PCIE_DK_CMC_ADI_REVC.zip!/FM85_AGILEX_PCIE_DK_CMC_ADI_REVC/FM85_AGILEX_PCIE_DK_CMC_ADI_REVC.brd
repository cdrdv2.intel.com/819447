# Allegro board FM85_AGILEX_PCIE_DK_CMC_ADI_REVC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_DDIMM2_DBI_N3: length 56.4
  L12_SIG4 w0.076: 125.82,81.51 125.59,81.51 125.51,81.44 125.51,80.94 arc(125.52,80.9) 125.53,80.87 125.6,80.75 arc(125.64,80.67) 125.65,80.58 125.64,80.36 125.55,80.21 arc(125.41,80.06) 125.22,80 125.09,80 125.08,80 arc(124.95,79.97) 124.83,79.9 124.8,79.87 arc(124.8,79.86) 124.79,79.86 124.77,79.82 arc(124.72,79.71) 124.72,79.59 arc(124.73,79.54) 124.74,79.49 124.82,79.47 v1(125.09,79.63)
  L12_SIG4 w0.089: 125.82,81.51 126.04,81.73 127.11,81.73 127.83,82.45 128.35,82.45 128.91,83.01 128.91,83.48 129.05,83.62 129.06,83.62 129.21,83.78 129.54,83.78 129.78,83.54 131.3,83.54 131.7,83.93 136.64,83.93 136.75,84.04 136.82,84.04 139.95,84.04 140.3,84.39 141.46,84.39 141.46,84.4 142.84,84.4 147.31,88.87 155.24,88.87 155.89,89.51 157.59,89.51 158.28,90.2 158.41,90.2 158.56,90.05 158.84,90.05 159.07,90.28 159.07,90.56 158.92,90.71 158.92,90.84 159.04,90.95 159.16,90.95 159.31,90.8 159.59,90.8 159.82,91.03 159.82,91.32 159.67,91.47 159.67,91.59 159.79,91.71 159.92,91.71 160.07,91.56 160.35,91.56 160.58,91.79 160.58,92.07 160.43,92.22 160.43,92.35 160.86,92.78 161.07,92.78 162.33,94.04 162.33,95.72 162.04,96.01 160.82,96.01 160.74,96.1 160.74,96.26 160.82,96.35 162.12,96.35 162.33,96.56 162.33,96.75 162.42,96.84 163.3,96.84 163.52,97.06 163.52,97.35 163.3,97.57 162.39,97.57 162.31,97.66 162.31,97.86 162.39,97.95 v1(162.64,97.95)
DDR4_DDIMM2_DBI_N4: length 52.2
  L03_SIG1 w0.076: v2(115.53,79.63) 115.47,79.47 arc(115.39,79.39) 115.28,79.42 115.24,79.46 115.11,79.64 arc(114.97,79.76) 114.8,79.8 114.59,79.8 arc(114.56,79.81) 114.53,79.83 114.46,79.89 arc(114.42,79.96) 114.4,80.04 114.4,80.15 arc(114.41,80.22) 114.45,80.28 114.47,80.29 arc(114.51,80.35) 114.52,80.42 114.52,80.48 arc(114.52,80.49) 114.52,80.49 114.52,80.59 arc(114.5,80.69) 114.44,80.78 114.37,80.85 arc(114.37,80.85) 114.37,80.85 arc(114.34,80.89) 114.33,80.94 114.33,81.16 114.34,81.16 arc(114.39,81.24) 114.41,81.34 114.41,81.88 arc(114.38,82.06) 114.3,82.22 arc(114.21,82.39) 114.18,82.58
  L03_SIG1 w0.081: 114.18,82.58 114.18,85.51 114.29,85.61 114.29,85.84 114.18,85.95 114.18,86.4 arc(114.16,86.51) 114.1,86.6 113.21,87.49 112.65,87.49 109.86,90.29 109.86,90.5 109.73,90.63 109.52,90.63 109.4,90.74 107.62,90.74 107.39,90.98 107.39,91.2 107.26,91.32 107.04,91.32 106.49,91.88 106.49,92.11 106.36,92.23 106.14,92.23 106.01,92.36 106.01,92.56 105.86,92.71 105.66,92.71 105.12,93.25 105.12,93.5 105.43,93.82 105.43,94.96 105.24,95.15 104.39,95.15 104.31,95.23 104.31,95.4 104.4,95.49 105.24,95.49 105.43,95.68 105.43,96 105.24,96.19 104.38,96.19 104.3,96.27 104.3,96.44 104.38,96.52 105.24,96.52 105.43,96.71 105.43,97.17 105.51,97.25 105.9,97.25 106.09,97.44 106.09,97.76 105.9,97.95 105.51,97.95 105.43,98.03 105.43,98.22 105.14,98.51 105.14,98.97 105.39,99.22 105.57,99.22 105.72,99.37 105.72,99.55 105.96,99.79 105.96,99.88 106.13,100.05 106.13,100.22 105.96,100.38 105.96,100.49 106.07,100.6 106.81,100.6 107.23,101.02 107.23,101.37 106.89,101.7 106.24,101.7 106.16,101.79 106.16,102.03 106.3,102.17 106.3,102.36 106.16,102.51 106.16,102.76 106.27,102.88 106.47,102.88 106.62,102.73 106.81,102.73 106.96,102.88 107.14,102.88 107.29,102.73 107.48,102.73 107.63,102.88 107.88,102.88 107.96,102.8 107.96,102.37 108.15,102.18 108.48,102.18 108.66,102.37 108.66,102.55 108.75,102.63 109.31,102.63 109.67,102.27 109.67,101.78 109.38,101.49 109.38,101.26 109.38,100.61 109.25,100.48 109.13,100.48 108.85,100.76 108.57,100.76 108.35,100.55 108.35,100.27 108.71,99.91 108.71,99.8 108.58,99.67 108.41,99.67 107.59,100.5 107.32,100.5 107.09,100.27 107.09,100 107.94,99.15 107.94,99 107.69,98.75 107.69,98.61 107.56,98.49 107.14,98.49 107.01,98.62 107.01,98.9 107.11,99 v1(107.38,99)
DDR4_DDIMM2_DBI_N5: length 54.2
  L03_SIG1 w0.081: v1(98.04,99.34) 97.97,99.42 97.75,99.42 97.67,99.34 97.67,98.41 97.87,98.22 98.67,98.22 98.74,98.15 99.02,98.15 99.28,97.89 99.28,96.53 99.06,96.32 98.7,96.32 97.55,97.47 96.98,97.47 96.79,97.65 96.79,98.53 96.71,98.61 96.54,98.61 96.45,98.53 96.45,97.95 96.26,97.75 95.94,97.75 95.75,97.94 95.75,98.53 95.67,98.61 95.5,98.61 95.42,98.53 95.42,98.06 95.23,97.87 94.43,97.87 94.01,98.29 93.05,98.29 92.6,98.74 89.69,98.74 89.53,98.58 89.53,98.41 89.65,98.29 90.1,98.29 90.25,98.14 91.7,98.14 91.95,97.89 91.95,97.47 92.04,97.38 92.19,97.38 92.28,97.47 92.28,97.66 92.47,97.84 93.18,97.84 93.49,97.54 94.19,97.54 94.38,97.35 94.38,96.93 94.46,96.85 94.63,96.85 94.71,96.93 94.71,97.35 94.9,97.54 95.29,97.54 95.48,97.35 95.48,96.9 95.74,96.65 95.74,95.38 95.55,95.19 93.58,95.19 93.47,95.08 93.47,94.95 93.56,94.85 93.87,94.85 94.11,94.62 94.32,94.62 94.54,94.84 94.81,94.84 94.97,94.69 95.19,94.69 95.35,94.84 95.88,94.84 96.06,94.66 96.06,93.96 95.78,93.67 95.78,91.92 104.86,82.83 104.86,81.26 104.79,81.19 104.79,79.99 104.98,79.8 105.36,79.8 105.65,79.51 105.85,79.51 v2(105.96,79.63)
DDR4_DDIMM2_DBI_N6: length 54.3
  L05_SIG2 w0.076: 110.71,79.61 110.48,79.47 110.4,79.49 arc(110.38,79.66) 110.42,79.82 110.44,79.84 arc(110.57,79.96) 110.74,80 110.77,80 arc(111.03,80.08) 111.22,80.28 arc(111.29,80.53) 111.24,80.79 111.22,80.82 arc(111.18,80.88) 111.13,80.94 110.79,81.28 110.79,81.29 110.77,81.3
  L05_SIG2 w0.081: v1(88.69,99.34) 88.54,99.34 88.21,99.01 88.21,93.95 89.92,92.24 91.13,92.24 94.5,88.88 95.99,88.88 96.18,88.69 96.18,87.68 96.26,87.59 96.43,87.59 96.51,87.68 96.51,88.69 96.7,88.88 97.02,88.88 97.21,88.69 97.21,87.68 97.29,87.59 97.47,87.59 97.55,87.68 97.55,88.69 97.74,88.88 98.06,88.88 98.25,88.69 98.25,87.68 98.33,87.59 98.5,87.59 98.58,87.68 98.58,88.69 98.77,88.88 99.1,88.88 99.28,88.69 99.28,87.68 99.37,87.59 99.54,87.59 99.62,87.68 99.62,88.69 99.81,88.88 100.13,88.88 100.32,88.69 100.32,87.68 100.4,87.59 100.58,87.59 100.66,87.68 100.66,88.69 100.84,88.88 101.17,88.88 101.36,88.69 101.36,87.68 101.44,87.59 101.61,87.59 101.69,87.68 101.69,88.69 101.88,88.88 102.21,88.88 102.39,88.69 102.39,87.68 102.48,87.59 102.65,87.59 102.73,87.68 102.73,88.69 102.92,88.88 106.28,88.88 107.3,87.86 107.3,84.34 109.86,81.78 110.29,81.78 110.77,81.3 ; 110.71,79.61 v1(110.74,79.63)
DDR4_DDIMM2_DBI_N7: length 67.9
  L14_SIG5 w0.076: v1(112.34,75.03) 112.07,74.87 111.99,74.89 arc(111.97,75.06) 112.02,75.21 112.03,75.23 arc(112.15,75.36) 112.32,75.4 112.36,75.4 arc(112.62,75.48) 112.81,75.67 112.82,75.68 arc(112.89,75.95) 112.81,76.22 arc(112.76,76.4) 112.8,76.58 112.83,76.62 arc(112.89,76.87) 112.83,77.11 arc(112.82,77.13) 112.81,77.14 arc(112.79,77.19) 112.78,77.24 arc(112.77,77.38) 112.81,77.51 112.81,77.52 arc(112.89,77.79) 112.82,78.06 112.81,78.06 arc(112.79,78.11) 112.78,78.16 arc(112.77,78.3) 112.81,78.44 112.84,78.48 arc(112.91,78.75) 112.84,79.03 112.81,79.08 112.79,79.13 112.78,79.19 112.78,79.2 112.83,79.38 arc(112.89,79.64) 112.81,79.9 arc(112.76,80.09) 112.81,80.27 112.81,80.28 arc(112.89,80.55) 112.82,80.82 112.81,80.83 arc(112.76,81.01) 112.81,81.2 arc(112.84,81.25) 112.86,81.31 arc(112.87,81.33) 112.88,81.36 arc(112.89,81.41) 112.89,81.47 112.89,81.69 112.89,81.69 112.89,81.71
  L14_SIG5 w0.081: 112.89,81.71 112.89,83.77 112.7,83.96 112.14,83.96 111.68,84.42 111.68,85.39 110.04,87.04 94.41,87.04 91.65,89.79 88.64,89.79 86.39,92.04 85.15,92.04 84.96,91.85 84.96,91.05 84.88,90.97 84.71,90.97 84.62,91.05 84.62,91.85 84.44,92.04 84.11,92.04 83.92,91.85 83.92,91.05 83.84,90.97 83.67,90.97 83.59,91.05 83.59,91.85 83.4,92.04 83.08,92.04 82.89,91.85 82.89,91.05 82.81,90.97 82.63,90.97 82.55,91.05 82.55,91.85 82.36,92.04 82.04,92.04 81.85,91.85 81.85,91.05 81.77,90.97 81.6,90.97 81.52,91.05 81.52,91.85 81.33,92.04 79.56,92.04 79.18,92.42 79.18,93.12 79.18,93.68 78.8,94.06 78.8,95.48 78.62,95.67 77.92,95.67 77.84,95.75 77.84,95.92 77.92,96 78.92,96 79.1,96.19 79.1,96.51 78.92,96.7 77.92,96.7 77.84,96.78 77.84,96.96 77.92,97.04 78.82,97.04 79.01,97.23 79.01,97.55 78.82,97.74 78.21,97.74 78.13,97.82 78.13,97.99 78.21,98.07 78.82,98.07 79.01,98.26 79.01,99.01 v1(79.34,99.34)
DDR4_DDIMM2_DBI_N8: length 55.6
  L12_SIG4 w0.076: 119.07,81.27 119.07,81.14 arc(119.07,81.1) 119.08,81.05 119.21,80.77 arc(119.27,80.53) 119.22,80.3 119.17,80.21 arc(119.16,80.17) 119.15,80.14 arc(119.23,79.88) 119.44,79.73 arc(119.48,79.72) 119.52,79.72 arc(119.7,79.68) 119.87,79.59 arc(120.02,79.52) 120.18,79.56 v1(120.31,79.63)
  L12_SIG4 w0.089: 119.07,81.27 119.07,83.68 arc(119.11,83.87) 119.22,84.03 119.35,84.17 arc(119.53,84.44) 119.6,84.76 119.6,86.4 120.37,87.17 121.83,87.17 124.59,89.93 125.5,89.93 125.59,89.84 125.59,89.25 125.79,89.05 126.11,89.05 126.31,89.25 126.31,89.84 126.4,89.93 127.28,89.93 128.17,90.82 129.34,90.82 129.67,91.15 129.67,91.52 129.8,91.66 130.17,91.66 130.42,91.91 130.42,92.28 130.56,92.41 130.93,92.41 131.23,92.71 131.82,92.71 132.06,92.94 133.95,92.94 135.78,94.78 136.71,94.78 136.8,94.69 136.8,94.46 137,94.26 137.32,94.26 137.52,94.46 137.52,94.66 137.61,94.75 139.15,94.75 139.35,94.95 139.62,94.95 139.79,94.77 139.79,94.43 139.99,94.23 140.32,94.23 140.52,94.43 140.52,94.75 140.61,94.84 142.71,94.84 142.95,95.09 143.36,95.09 143.75,94.7 144.11,94.7 144.49,94.32 144.77,94.32 144.97,94.52 144.97,95.12 145.06,95.21 145.23,95.21 145.32,95.12 145.32,94.68 145.52,94.48 145.84,94.48 146.04,94.68 146.04,95.12 146.13,95.21 146.29,95.21 146.38,95.12 146.38,94.68 146.58,94.48 146.91,94.48 147.11,94.68 147.11,95.12 147.2,95.21 147.36,95.21 147.45,95.12 147.45,94.68 147.65,94.48 147.97,94.48 148.17,94.68 148.17,95.15 148.26,95.24 148.42,95.24 148.52,95.13 148.52,94.68 148.72,94.48 149.23,94.48 151.7,96.95 152.65,96.95 152.88,97.18 152.88,97.82 153.08,98.01 153.23,98.01 v1(153.29,97.95)
DDR4_DDIMM2_DQ0: length 120.5
  L12_SIG4 w0.089: v1(109.15,76.87) 109.95,76.87 arc(110.17,76.92) 110.33,77.07 110.36,77.12 arc(110.53,77.27) 110.74,77.33 110.77,77.33 arc(110.99,77.4) 111.14,77.56 arc(111.3,77.72) 111.51,77.79 111.54,77.79 arc(111.76,77.84) 111.93,77.99 111.94,78.02 arc(112,78.25) 111.94,78.48 111.94,78.48 arc(111.88,78.71) 111.94,78.94 arc(112,79.17) 111.94,79.4 111.94,79.4 arc(111.88,79.63) 111.94,79.86 arc(112,80.09) 111.94,80.31 111.92,80.35 arc(111.88,80.57) 111.94,80.78 111.94,81.22 111.54,81.62 111.54,85.92 110.85,86.62 110.85,87.95 113.97,91.07 114.34,91.07 114.81,91.54 115.67,91.54 115.91,91.77 115.91,92.11 115.73,92.28 115.73,93.7 116.29,94.26 116.29,95.03 119.13,97.86 119.46,97.86 119.69,98.1 119.69,98.35 119.84,98.5 120.49,98.5 120.73,98.73 121.04,98.73 121.13,98.82 121.13,98.97 121.22,99.06 121.38,99.06 121.47,98.97 121.47,98.82 121.56,98.73 121.73,98.73 121.82,98.82 121.82,98.97 121.9,99.06 122.07,99.06 122.16,98.97 122.16,98.82 122.25,98.73 123.08,98.73 123.17,98.82 123.17,98.97 123.26,99.06 123.42,99.06 123.51,98.97 123.51,98.82 123.6,98.73 124.07,98.73 124.67,98.13 125.89,98.13 126.57,98.81 128.79,98.81 130.05,100.07 134.48,100.07 134.9,99.65 135.99,99.65 136.09,99.75 141.69,99.75 141.69,99.75 142.8,99.75 142.8,99.75 145.71,99.75 146.08,100.12 146.96,100.12 147.21,99.87 149.79,99.87 149.83,99.9 177.84,99.9 178.04,100.1 184.57,100.1 185.14,99.52 185.14,98.02 185.12,98 185.12,93.53 185.14,93.51 185.14,92.88 184.96,92.7 184.96,91.15 185.25,90.86 188.32,90.86 189.75,92.3 191.96,92.3 192.28,92.62 192.28,95.16 192.14,95.3 192.14,95.61 192.39,95.87 v1(192.39,98.64)
DDR4_DDIMM2_DQ1: length 119.7
  TOP w0.149: J1.150 v1(191.54,93.34)
  L12_SIG4 w0.089: v1(109.15,78.71) 109.55,79.4 arc(109.61,79.63) 109.55,79.86 arc(109.49,80.09) 109.55,80.31 109.55,80.32 arc(109.61,80.5) 109.59,80.7 arc(109.57,80.74) 109.54,80.77 109.5,80.81 arc(109.45,80.89) 109.43,80.99 109.43,81.46 109.03,81.86 109.03,82.13 108.89,82.27 108.7,82.27 108.61,82.36 108.61,82.53 108.7,82.61 108.93,82.61 109.02,82.7 109.02,82.87 108.93,82.96 108.7,82.96 108.61,83.05 108.61,83.21 108.7,83.3 108.82,83.3 108.9,83.39 108.9,83.55 108.82,83.64 108.7,83.64 108.61,83.73 108.61,83.9 108.7,83.99 108.85,83.99 108.93,84.07 108.93,84.24 108.85,84.33 108.7,84.33 108.61,84.42 108.61,84.58 108.7,84.67 108.95,84.67 109.04,84.76 109.04,86.67 108.95,86.76 108.78,86.76 108.69,86.85 108.69,87.01 108.78,87.1 108.94,87.1 109.03,87.19 109.03,87.35 108.94,87.44 108.78,87.44 108.69,87.53 108.69,87.7 108.78,87.79 108.94,87.79 109.03,87.87 109.03,88.12 113.31,92.4 113.31,92.97 113.22,93.06 112.94,93.06 112.85,93.15 112.85,93.31 112.94,93.4 113.22,93.4 113.31,93.49 113.31,93.77 113.78,94.23 113.78,95.46 114.96,96.64 115.26,96.64 116.13,97.51 116.65,97.51 117.23,98.09 117.23,98.99 118.02,99.78 118.51,99.78 119.06,99.78 119.77,100.49 120.76,100.49 120.85,100.58 120.85,100.73 120.94,100.82 121.11,100.82 121.2,100.73 121.2,100.58 121.28,100.49 121.45,100.49 121.54,100.58 121.54,100.73 121.63,100.82 121.79,100.82 121.88,100.73 121.88,100.58 121.97,100.49 124.37,100.49 124.8,100.06 125.66,100.06 125.82,100.22 128.21,100.22 129.9,101.91 131.55,101.91 131.72,102.07 133.89,102.07 134.41,101.56 136.13,101.56 136.14,101.54 136.45,101.54 136.77,101.87 138.49,101.87 138.69,101.67 139,101.67 139.26,101.94 140.97,101.94 141.24,101.67 141.55,101.67 141.76,101.88 143.4,101.88 143.62,101.67 145.92,101.67 146.83,102.58 155.08,102.58 155.17,102.67 155.17,103.18 155.26,103.27 155.43,103.27 155.52,103.18 155.52,102.65 155.58,102.58 155.79,102.58 155.86,102.65 155.86,103.18 155.95,103.27 156.11,103.27 156.2,103.18 156.2,102.65 156.27,102.58 156.48,102.58 156.54,102.65 156.54,103.25 156.64,103.35 156.8,103.35 156.89,103.26 156.89,102.67 156.98,102.58 159.75,102.58 159.93,102.76 171.01,102.76 171.86,101.91 173.98,101.91 174.38,102.31 181.61,102.31 182.04,101.89 185.6,101.89 187.25,100.24 187.25,99.93 186.88,99.56 186.88,94.23 188.3,92.8 191.41,92.8 191.54,92.94 v1(191.54,93.34)
DDR4_DDIMM2_DQ2: length 119.2
  L12_SIG4 w0.089: v1(186.38,99.34) 186.41,99.38 186.41,99.91 186.06,100.25 186.06,100.38 186.16,100.48 186.16,100.61 186.05,100.72 185.92,100.72 185.82,100.62 185.7,100.62 185.58,100.74 185.58,100.87 185.68,100.97 185.68,101.09 185.56,101.21 185.44,101.21 185.34,101.11 185.21,101.11 184.95,101.37 182.88,101.37 182.59,101.08 182.47,101.08 182.38,101.17 182.38,101.27 182.29,101.36 182.12,101.36 182.03,101.27 182.03,101.17 181.95,101.08 181.78,101.08 181.69,101.17 181.69,101.27 181.6,101.36 181.44,101.36 181.35,101.27 181.35,101.17 181.26,101.08 181.02,101.08 180.7,101.4 180.51,101.4 180.42,101.49 180.42,101.7 180.33,101.79 180.17,101.79 180.08,101.7 180.08,101.49 179.99,101.4 179.83,101.4 179.74,101.49 179.74,101.7 179.65,101.79 179.48,101.79 179.39,101.7 179.39,101.49 179.3,101.4 179.14,101.4 179.05,101.49 179.05,101.7 178.96,101.79 178.8,101.79 178.71,101.7 178.71,101.49 178.62,101.4 178.45,101.4 178.36,101.49 178.36,101.7 178.28,101.79 178.11,101.79 178.02,101.7 178.02,101.49 177.93,101.4 176.45,101.4 176.36,101.49 176.36,101.72 176.27,101.81 176.11,101.81 176.02,101.72 176.02,101.49 175.93,101.4 175.76,101.4 175.68,101.49 175.68,101.72 175.59,101.81 175.42,101.81 175.33,101.72 175.33,101.49 175.24,101.4 175.08,101.4 174.99,101.49 174.99,101.72 174.9,101.81 174.74,101.81 174.65,101.72 174.65,101.49 174.56,101.4 173.26,101.4 172.98,101.12 171.67,101.12 171.23,101.57 171.1,101.57 170.86,101.33 170.73,101.33 170.61,101.44 170.61,101.57 170.86,101.81 170.86,101.94 170.61,102.19 170.24,102.19 170.15,102.1 170.15,101.64 170.05,101.55 169.89,101.55 169.81,101.64 169.81,102.1 169.72,102.19 169.14,102.19 169.05,102.1 169.05,101.66 168.98,101.58 168.78,101.58 168.71,101.65 168.71,102.1 168.62,102.19 168.46,102.19 168.37,102.1 168.37,101.85 168.28,101.76 168.11,101.76 168.03,101.85 168.03,102.1 167.94,102.19 167.01,102.19 166.92,102.1 166.92,101.8 166.83,101.71 166.67,101.71 166.58,101.8 166.58,102.1 166.49,102.19 166.32,102.19 166.23,102.1 166.23,101.8 166.15,101.71 165.98,101.71 165.89,101.8 165.89,102.1 165.8,102.19 165.64,102.19 165.55,102.1 165.55,101.45 165.46,101.36 165.29,101.36 165.21,101.45 165.21,102.1 165.12,102.19 164.81,102.19 164.57,101.95 164.47,101.95 164.38,101.86 164.38,101.53 164.29,101.44 164.13,101.44 164.04,101.53 164.04,101.86 163.95,101.95 162.76,101.95 162.68,101.86 162.68,101.36 162.59,101.28 162.42,101.28 162.33,101.36 162.33,101.86 162.24,101.95 159.31,101.95 159.15,102.11 152.6,102.11 152.51,102.02 152.51,101.46 152.42,101.37 152.25,101.37 152.16,101.46 152.16,102.02 152.07,102.11 151.91,102.11 151.82,102.02 151.82,101.46 151.73,101.37 151.57,101.37 151.48,101.46 151.48,102.02 151.39,102.11 150.04,102.11 149.96,102.02 149.96,101.49 149.87,101.4 149.7,101.4 149.61,101.49 149.61,102.02 149.52,102.11 148.66,102.11 148.57,102.02 148.57,101.45 148.48,101.36 148.31,101.36 148.23,101.45 148.23,102.02 148.14,102.11 147.02,102.11 146.11,101.2 143.81,101.2 143.42,101.2 143.24,101.38 141.93,101.38 141.74,101.2 141.04,101.2 140.86,101.38 139.38,101.38 139.19,101.2 138.49,101.2 138.31,101.38 136.95,101.38 136.64,101.07 136.08,101.07 135.6,100.59 135.29,100.59 134.79,101.09 134.21,101.09 133.72,101.58 132.65,101.58 132.35,101.29 130.89,101.29 130.74,101.44 130.09,101.44 128.4,99.75 126.18,99.75 125.5,99.07 125.06,99.07 124.13,100 119.95,100 119.25,99.31 118.94,99.31 118.35,98.72 118.23,98.72 118.03,98.91 117.91,98.91 117.79,98.8 117.79,98.67 117.98,98.48 117.98,98.09 116.93,97.04 116.32,97.04 115.46,96.17 115.44,96.17 115.44,95.72 115.22,95.5 114.49,95.5 114.25,95.26 114.25,94.04 113.78,93.57 113.78,92.21 109.51,87.94 109.51,84.57 109.42,84.47 109.42,83.13 109.5,83.05 109.5,82.14 110.37,81.26 110.37,81.03 arc(110.36,80.87) 110.31,80.72 arc(110.28,80.53) 110.33,80.35 110.35,80.31 arc(110.41,80.09) 110.35,79.86 arc(110.29,79.63) 110.34,79.4 110.35,79.4 arc(110.41,79.17) 110.35,78.94 110.04,78.41 v1(109.95,78.25)
DDR4_DDIMM2_DQ3: length 121.2
  L12_SIG4 w0.089: v1(109.95,77.33) 110.35,78.02 110.36,78.04 arc(110.53,78.19) 110.74,78.25 110.77,78.25 arc(110.99,78.32) 111.14,78.48 111.15,78.48 arc(111.21,78.71) 111.14,78.94 arc(111.08,79.17) 111.14,79.4 111.15,79.4 arc(111.21,79.63) 111.14,79.86 arc(111.08,80.09) 111.14,80.31 111.14,80.32 arc(111.21,80.53) 111.16,80.75 111.14,80.78 arc(111.11,80.86) 111.08,80.95 arc(111.04,81.09) 110.95,81.21 110.84,81.32 110.84,81.53 110.37,82 110.37,88.14 113.78,91.54 114.14,91.54 114.76,92.16 115.03,92.16 115.26,92.39 115.26,94.66 118.45,97.85 118.45,97.99 119.3,98.84 119.45,98.84 119.58,98.97 120.3,98.97 120.86,99.53 123.93,99.53 124.87,98.6 125.69,98.6 126.37,99.28 128.6,99.28 129.86,100.54 134.68,100.54 135.09,100.12 135.79,100.12 135.89,100.22 137.25,100.22 137.34,100.31 137.34,100.61 137.42,100.7 137.59,100.7 137.68,100.61 137.68,100.31 137.77,100.22 138.14,100.22 138.23,100.31 138.23,100.62 138.31,100.71 138.48,100.71 138.57,100.62 138.57,100.31 138.66,100.22 138.82,100.22 138.91,100.31 138.91,100.62 139,100.71 139.17,100.71 139.25,100.62 139.25,100.31 139.34,100.22 139.87,100.22 139.96,100.31 139.96,100.67 140.05,100.76 140.21,100.76 140.3,100.67 140.3,100.31 140.39,100.22 140.83,100.22 140.92,100.31 140.92,100.6 141.01,100.69 141.18,100.69 141.27,100.6 141.27,100.31 141.36,100.22 141.49,100.22 141.49,100.22 141.77,100.22 141.86,100.31 141.86,100.5 141.95,100.59 142.11,100.59 142.2,100.5 142.2,100.31 142.29,100.22 142.45,100.22 142.54,100.31 142.54,100.5 142.63,100.59 142.8,100.59 142.89,100.5 142.89,100.31 142.97,100.22 143.17,100.22 143.17,100.22 143.49,100.22 143.58,100.31 143.58,100.6 143.67,100.69 143.83,100.69 143.92,100.6 143.92,100.31 144.01,100.22 144.18,100.22 144.27,100.31 144.27,100.6 144.36,100.69 144.52,100.69 144.61,100.6 144.61,100.31 144.7,100.22 145.02,100.22 145.44,100.64 145.81,100.64 145.86,100.59 146.88,100.59 146.97,100.68 146.97,101.12 147.19,101.34 147.5,101.34 147.72,101.12 147.72,100.65 147.84,100.52 148.36,100.52 148.53,100.69 148.84,100.69 149,100.52 150.46,100.52 150.55,100.61 150.55,101.07 150.64,101.16 150.8,101.16 150.89,101.07 150.89,100.57 150.98,100.49 152.96,100.49 153.95,101.48 157.68,101.48 158.65,100.51 159.01,100.51 159.1,100.6 159.1,101.27 159.19,101.36 159.35,101.36 159.44,101.27 159.44,100.6 159.53,100.51 160.6,100.51 160.69,100.6 160.69,101.3 160.78,101.39 160.94,101.39 161.03,101.3 161.03,100.6 161.12,100.51 161.28,100.51 161.37,100.6 161.37,101.3 161.46,101.39 161.63,101.39 161.72,101.3 161.72,100.6 161.8,100.51 162.11,100.51 162.34,100.74 162.81,100.74 162.99,100.56 163.33,100.56 163.42,100.65 163.42,101.3 163.51,101.39 163.67,101.39 163.76,101.3 163.76,100.65 163.85,100.56 167.23,100.56 167.32,100.65 167.32,101.02 167.4,101.11 167.57,101.11 167.66,101.02 167.66,100.65 167.75,100.56 167.91,100.56 168,100.65 168,101.02 168.09,101.11 168.26,101.11 168.34,101.02 168.34,100.65 168.43,100.56 168.6,100.56 168.69,100.65 168.69,101.02 168.78,101.11 168.94,101.11 169.03,101.02 169.03,100.65 169.12,100.56 169.28,100.56 169.37,100.65 169.37,101.02 169.46,101.11 169.63,101.11 169.72,101.02 169.72,100.65 169.8,100.56 172.06,100.56 172.15,100.65 172.46,100.65 172.54,100.56 184.9,100.56 185.91,99.55 185.91,93.65 v1(185.66,93.4)
DDR4_DDIMM2_DQ4: length 119.7
  L12_SIG4 w0.089: v1(105.96,76.87) 105.57,77.56 arc(105.5,77.79) 105.57,78.02 arc(105.63,78.25) 105.57,78.48 105.56,78.48 arc(105.5,78.71) 105.57,78.94 arc(105.63,79.17) 105.57,79.39 105.56,79.41 arc(105.5,79.63) 105.57,79.86 105.57,80.53 104.13,81.97 104.13,89.9 107.88,93.64 107.88,98.35 107.87,98.36 107.87,98.67 107.88,98.68 107.88,99.59 112.67,104.38 112.76,104.38 113.01,104.64 113.01,105 113.47,105.46 121.72,105.46 122.67,106.41 125.74,106.41 126.02,106.69 127.76,106.69 128.23,106.22 131.38,106.22 131.75,105.84 134.08,105.84 134.55,106.31 145.6,106.31 146.63,107.34 166.94,107.34 167.43,106.85 184.93,106.85 185.84,105.94 189.26,105.94 189.47,105.73 189.47,105.09 192.74,101.82 192.75,101.82 193.25,101.33 193.25,100.26 v1(194.09,99.42)
DDR4_DDIMM2_DQ5: length 119
  TOP w0.149: J1.148 v1(193.24,96.37)
  L12_SIG4 w0.089: v1(193.24,96.37) 193.72,96.84 193.72,99.02 192.78,99.96 192.78,101.13 192.56,101.35 191.84,101.35 188.12,105.07 185.43,105.07 184.55,105.94 176.4,105.94 176.4,105.95 176.09,105.95 176.08,105.94 170.49,105.94 170.44,105.99 168.85,105.99 168.75,105.89 168.44,105.89 168.39,105.94 166.87,105.94 166.25,106.56 146.52,106.56 145.4,105.44 144.38,105.44 144.04,105.78 143.73,105.78 143.4,105.44 140.38,105.44 140.24,105.3 131.45,105.3 131.36,105.22 128.57,105.22 127.57,106.22 126.22,106.22 125.21,105.22 122.14,105.22 121.91,104.99 118.77,104.99 117.7,103.92 116.14,103.92 115.2,102.98 114.98,102.98 112.87,100.86 112.87,100.47 112.02,99.62 112.02,99.19 111.8,98.97 111.59,98.97 108.7,96.08 108.7,92.82 105.35,89.47 105.35,81.19 105.96,80.58 v1(105.96,78.71)
DDR4_DDIMM2_DQ6: length 119
  TOP w0.149: v1(191.19,99.92) 191.15,99.87 188.32,99.87 188.14,99.69 J1.10
  L12_SIG4 w0.089: v1(191.19,99.92) 191.19,100.44 187.51,104.13 179.26,104.13 179.26,104.13 178.56,104.13 178.55,104.13 172.6,104.13 172.41,104.32 164.61,104.32 162.31,104.32 161.51,105.12 157.79,105.12 157.71,105.21 157.71,105.4 157.62,105.48 157.45,105.48 157.36,105.4 157.36,105.21 157.27,105.12 157.11,105.12 157.02,105.21 157.02,105.4 156.93,105.48 156.77,105.48 156.68,105.4 156.68,105.21 156.59,105.12 156.42,105.12 156.33,105.21 156.33,105.4 156.24,105.48 156.08,105.48 155.99,105.4 155.99,105.21 155.9,105.12 153.57,105.12 152.78,104.33 150.95,104.33 150.09,105.19 147.41,105.19 146.55,104.33 145.62,104.33 145.43,104.15 140.41,104.15 140.3,104.04 132.58,104.04 132.25,104.37 131.84,104.37 131.75,104.28 129.88,104.28 129.19,103.59 128.9,103.59 127.45,102.14 126.21,102.14 124.45,103.91 119.55,103.91 118.59,102.95 117.33,102.95 116.05,101.67 115.48,101.67 114.35,100.54 114.08,100.54 113.81,100.27 113.81,100.08 113.36,99.63 113.36,98.73 112.39,97.76 112.39,97.16 111.25,96.02 111.25,95.58 110.12,94.45 110.12,93.7 110.32,93.5 110.32,93.11 106.93,89.72 106.93,87.12 106.84,87.03 106.62,87.03 106.53,86.94 106.53,86.78 106.62,86.69 106.84,86.69 106.93,86.6 106.93,85.93 106.84,85.84 106.58,85.84 106.49,85.75 106.49,85.58 106.58,85.5 106.84,85.5 106.93,85.41 106.93,84.63 106.84,84.54 106.42,84.54 106.33,84.45 106.33,84.29 106.42,84.2 106.84,84.2 106.93,84.11 106.93,83.95 106.84,83.86 106.42,83.86 106.33,83.77 106.33,83.6 106.42,83.51 106.84,83.51 106.93,83.43 106.93,82.84 106.45,82.36 106.45,81.39 107.14,80.71 107.14,79.8 106.76,79.43 v1(106.76,78.25)
DDR4_DDIMM2_DQ7: length 120.5
  TOP w0.149: J1.155 187.29,94.78 188.61,96.1 189.97,96.1 v1(191.19,97.32)
  L12_SIG4 w0.089: v1(191.19,97.32) 191.19,97.55 191.11,97.63 191.11,98.44 191.73,99.06 191.73,100.79 187.93,104.6 179.07,104.6 179.06,104.59 178.75,104.59 178.75,104.6 174.15,104.6 173.78,104.97 162.69,104.97 162.17,105.49 162.17,105.72 161.8,106.09 147.48,106.09 146.76,105.37 145.99,105.37 145.24,104.62 140.21,104.62 140.11,104.51 132.77,104.51 132.45,104.83 131.64,104.83 131.55,104.75 128.38,104.75 127.37,105.75 126.41,105.75 125.41,104.75 122.34,104.75 122.11,104.52 118.96,104.52 117.89,103.45 116.34,103.45 115.4,102.51 115.18,102.51 113.34,100.67 113.34,100.27 112.89,99.82 112.89,98.92 110.78,96.81 110.78,95.77 109.52,94.51 109.52,92.97 105.82,89.28 105.82,81.2 106.2,80.82 106.2,79 106.35,78.85 106.35,77.53 106.55,77.33 v1(106.76,77.33)
DDR4_DDIMM2_DQ8: length 97.9
  L12_SIG4 w0.089: v1(124.29,78.25) 125.11,78.25 arc(125.33,78.18) 125.49,78.02 arc(125.65,77.86) 125.86,77.79 125.88,77.79 arc(126.11,77.85) 126.27,78 126.29,78.04 arc(126.46,78.19) 126.68,78.25 126.7,78.25 arc(126.92,78.32) 127.08,78.48 arc(127.24,78.64) 127.46,78.71 127.48,78.71 arc(127.7,78.77) 127.87,78.92 127.89,78.96 arc(128.05,79.11) 128.27,79.17 128.29,79.17 arc(128.51,79.24) 128.67,79.4 arc(128.67,79.4) 128.68,79.4 arc(128.84,79.57) 129.05,79.63 132.26,79.63 arc(132.48,79.69) 132.65,79.85 132.67,79.87 arc(132.83,80.03) 133.05,80.09 133.07,80.09 arc(133.21,80.12) 133.33,80.18 133.41,80.26 arc(133.5,80.32) 133.6,80.34 arc(133.64,80.35) 133.67,80.37 arc(133.86,80.43) 134.05,80.36 arc(134.11,80.33) 134.17,80.3 arc(134.33,80.24) 134.46,80.14 arc(134.57,80.07) 134.69,80.05 134.89,80.05 arc(135.05,80.01) 135.17,79.9 arc(135.45,79.75) 135.72,79.9 arc(135.84,80.01) 136,80.05 arc(136.34,79.99) 136.65,79.85 136.76,79.77 arc(137.69,79.5) 138.62,79.72 arc(138.67,79.75) 138.72,79.76 arc(138.86,79.84) 138.95,79.97 arc(139.34,80.48) 139.96,80.67 140.9,80.67 141.57,81.35 143.78,81.35 148.48,86.05 154.47,86.05 155.33,85.19 155.33,84.97 155.24,84.88 154.68,84.88 154.59,84.79 154.59,84.61 154.68,84.52 155.24,84.52 155.33,84.43 155.33,84.26 155.24,84.17 154.68,84.17 154.59,84.08 154.59,83.9 154.68,83.81 155.24,83.81 155.33,83.72 155.33,83.54 155.24,83.46 154.68,83.46 154.59,83.37 154.59,83.19 154.68,83.1 155.24,83.1 155.33,83.01 155.33,82.6 156.07,81.85 160.11,81.85 160.73,82.47 160.73,82.6 160.5,82.84 160.5,82.96 160.61,83.08 160.74,83.08 160.98,82.84 161.1,82.84 161.22,82.96 161.22,83.08 160.98,83.32 160.98,83.45 161.1,83.56 161.22,83.56 161.46,83.33 161.59,83.33 161.7,83.44 161.7,83.57 161.47,83.81 161.47,83.93 161.58,84.05 161.71,84.05 161.95,83.81 162.07,83.81 162.19,83.93 162.19,84.05 161.95,84.29 161.95,84.42 162.07,84.53 162.19,84.53 162.43,84.3 162.56,84.3 162.8,84.54 162.8,85.21 162.98,85.38 162.98,85.55 162.8,85.73 162.8,85.89 162.98,86.07 162.98,86.23 162.8,86.41 162.8,86.58 162.98,86.76 162.98,86.92 162.8,87.1 162.8,87.26 162.98,87.44 162.98,87.61 162.8,87.78 162.8,88.53 163.91,89.64 164.62,89.64 168.22,93.24 168.22,93.55 168.47,93.81 168.47,93.93 167.82,94.58 167.82,94.71 167.94,94.82 168.07,94.82 168.72,94.17 168.84,94.17 168.96,94.29 168.96,94.42 168.31,95.07 168.31,95.19 168.43,95.31 168.55,95.31 169.2,94.66 169.33,94.66 169.44,94.78 169.44,94.9 168.79,95.55 168.79,95.68 168.91,95.79 169.04,95.79 169.69,95.14 169.81,95.14 170.15,95.48 171.19,95.48 171.68,95.97 171.68,96.1 171.05,96.73 171.05,96.85 171.17,96.97 171.29,96.97 171.92,96.34 172.05,96.34 172.36,96.66 172.57,96.66 172.66,96.75 172.66,97.28 172.75,97.37 172.91,97.37 173,97.28 173,96.75 173.09,96.66 173.26,96.66 173.35,96.75 173.35,97.28 173.43,97.37 173.6,97.37 173.69,97.28 173.69,96.75 173.78,96.66 173.94,96.66 174.03,96.75 174.03,97.28 174.12,97.37 174.29,97.37 174.37,97.28 174.37,96.75 174.46,96.66 175.98,96.66 176.3,96.97 176.3,97.1 175.96,97.43 175.96,97.56 176.08,97.68 176.2,97.68 176.54,97.34 176.67,97.34 176.78,97.46 176.78,97.58 176.45,97.92 176.45,98.04 176.56,98.16 176.69,98.16 177.02,97.83 177.15,97.83 177.57,98.24 177.57,98.8 177.79,99.02 178.34,99.02 178.91,99.58 182.8,99.58 v1(183.04,99.34)
DDR4_DDIMM2_DQ9: length 95.5
  TOP w0.149: v1(182.18,95.28) 182.19,95.26 J1.161
  L12_SIG4 w0.089: v1(124.29,77.33) 125.11,77.33 arc(125.33,77.26) 125.49,77.1 arc(125.65,76.94) 125.86,76.87 125.88,76.87 arc(126.11,76.93) 126.27,77.08 126.29,77.12 arc(126.46,77.27) 126.68,77.33 126.7,77.33 arc(126.92,77.4) 127.08,77.56 arc(127.24,77.72) 127.46,77.79 127.48,77.79 arc(127.7,77.85) 127.87,78 127.89,78.04 arc(128.05,78.19) 128.27,78.25 128.29,78.25 arc(128.51,78.32) 128.67,78.48 arc(128.83,78.64) 129.05,78.71 129.07,78.71 arc(129.29,78.77) 129.46,78.92 129.48,78.95 arc(129.65,79.11) 129.87,79.17 131.68,79.17 131.86,78.94 arc(132.02,78.78) 132.24,78.71 132.26,78.71 arc(132.48,78.77) 132.65,78.93 132.67,78.95 arc(132.83,79.11) 133.05,79.17 133.07,79.17 arc(133.29,79.23) 133.45,79.4 arc(133.62,79.56) 133.84,79.63 arc(134.07,79.58) 134.27,79.45 134.73,78.99 arc(135.36,78.7) 136.02,78.9 arc(136.13,78.97) 136.24,79.03 136.57,79.16 arc(136.61,79.18) 136.66,79.18 137.92,79.18 arc(138.29,79.24) 138.63,79.43 arc(138.87,79.55) 139.13,79.6 arc(139.45,79.67) 139.71,79.85 139.8,79.93 arc(139.86,80.02) 139.89,80.13 arc(140.06,80.39) 140.38,80.42 140.51,80.36 arc(140.6,80.31) 140.68,80.24 arc(140.84,80.13) 141.02,80.09 arc(141.25,80.15) 141.42,80.32 arc(141.59,80.49) 141.82,80.55 141.82,80.55 arc(142.05,80.49) 142.21,80.33 142.22,80.31 arc(142.39,80.15) 142.62,80.09 arc(142.85,80.15) 143.01,80.32 arc(143.13,80.43) 143.28,80.48 146.86,80.48 148.89,78.45 153.87,78.45 154.12,78.7 154.12,78.82 153.51,79.43 153.51,79.56 153.64,79.68 153.77,79.68 154.37,79.07 154.5,79.07 154.62,79.2 154.62,79.33 154.02,79.93 154.02,80.06 154.14,80.19 154.27,80.19 154.88,79.58 155,79.58 155.13,79.7 155.13,79.83 154.52,80.44 154.52,80.56 154.65,80.69 154.77,80.69 155.38,80.08 155.5,80.08 155.97,80.55 156.66,80.55 156.75,80.64 156.75,81.23 156.84,81.32 157,81.32 157.09,81.23 157.09,80.64 157.18,80.55 157.35,80.55 157.43,80.64 157.43,81.23 157.52,81.32 157.69,81.32 157.78,81.23 157.78,80.64 157.87,80.55 158.03,80.55 158.12,80.64 158.12,81.23 158.21,81.32 158.37,81.32 158.46,81.23 158.46,80.64 158.55,80.55 158.72,80.55 158.81,80.64 158.81,81.23 158.89,81.32 159.06,81.32 159.15,81.23 159.15,80.64 159.24,80.55 159.47,80.55 163.71,84.78 163.71,85.43 163.8,85.51 164.3,85.51 164.39,85.6 164.39,85.77 164.3,85.86 163.8,85.86 163.71,85.95 163.71,86.11 163.8,86.2 164.3,86.2 164.39,86.29 164.39,86.45 164.3,86.54 163.8,86.54 163.71,86.63 163.71,87.81 163.8,87.89 164.27,87.89 164.36,87.98 164.36,88.15 164.27,88.24 163.8,88.24 163.71,88.33 163.71,88.78 164.11,89.17 165.19,89.17 171.03,95.01 171.39,95.01 171.49,95.12 172.3,95.12 172.39,95.21 172.39,95.86 172.48,95.95 172.64,95.95 172.73,95.86 172.73,95.21 172.82,95.12 174,95.12 174.08,95.21 174.08,95.88 174.17,95.97 174.34,95.97 174.43,95.88 174.43,95.21 174.52,95.12 175.11,95.12 179.1,99.11 182.35,99.11 182.71,98.76 182.71,95.81 v1(182.18,95.28)
DDR4_DDIMM2_DQ10: length 97.1
  L12_SIG4 w0.089: v1(177.09,99.34) 176.4,98.66 175.53,98.66 175.44,98.75 175.44,99.27 175.35,99.35 175.18,99.35 175.09,99.27 175.09,98.75 175,98.66 174.84,98.66 174.75,98.75 174.75,99.27 174.66,99.35 174.5,99.35 174.41,99.27 174.41,98.75 174.32,98.66 173.84,98.66 173.11,97.92 172.26,97.92 172.17,98.01 172.17,98.85 172.08,98.94 171.91,98.94 171.83,98.85 171.83,98.01 171.74,97.92 171.57,97.92 171.48,98.01 171.48,98.85 171.39,98.94 171.23,98.94 171.14,98.85 171.14,98.01 171.05,97.92 170.89,97.92 170.8,98.01 170.8,98.85 170.71,98.94 170.54,98.94 170.45,98.85 170.45,98.01 170.36,97.92 169.87,97.92 169.29,97.34 169.16,97.34 168.69,97.81 168.56,97.81 168.44,97.69 168.44,97.57 168.92,97.09 168.92,96.97 168.8,96.85 168.68,96.85 168.2,97.33 168.07,97.33 167.96,97.21 167.96,97.08 168.43,96.61 168.43,96.48 168.32,96.37 168.19,96.37 167.72,96.84 167.59,96.84 167.47,96.72 167.47,96.6 167.95,96.12 167.95,96 167.83,95.88 167.71,95.88 167.23,96.36 167.1,96.36 166.99,96.24 166.99,96.11 167.46,95.64 167.46,95.51 167.35,95.4 167.22,95.4 166.75,95.87 166.62,95.87 166.5,95.75 166.5,95.63 166.98,95.15 166.98,95.03 166.46,94.51 166.46,92.23 166.03,91.8 165.91,91.8 165.62,92.09 165.49,92.09 165.38,91.97 165.38,91.85 165.66,91.56 165.66,91.44 165.55,91.32 165.42,91.32 165.14,91.61 165.01,91.61 164.89,91.49 164.89,91.36 165.18,91.08 165.18,90.95 165.06,90.83 164.94,90.83 164.65,91.12 164.52,91.12 164.41,91.01 164.41,90.88 164.69,90.59 164.69,90.47 164.42,90.19 162.96,90.19 162.04,89.27 162.04,88.36 161.95,88.27 161.42,88.27 161.34,88.18 161.34,88.01 161.42,87.93 161.95,87.93 162.04,87.84 162.04,87.67 161.95,87.58 161.42,87.58 161.34,87.49 161.34,87.33 161.42,87.24 161.95,87.24 162.04,87.15 162.04,86.99 161.95,86.9 161.42,86.9 161.34,86.81 161.34,86.64 161.42,86.55 161.95,86.55 162.04,86.46 162.04,86.3 161.95,86.21 161.42,86.21 161.34,86.12 161.34,85.96 161.42,85.87 161.95,85.87 162.04,85.78 162.04,85.21 161.7,84.87 161.57,84.87 161.38,85.06 161.25,85.06 161.13,84.95 161.13,84.82 161.33,84.63 161.33,84.5 161.21,84.38 161.09,84.38 160.89,84.58 160.76,84.58 160.65,84.46 160.65,84.34 160.84,84.14 160.84,84.01 160.73,83.9 160.6,83.9 160.41,84.09 160.28,84.09 160.16,83.98 160.16,83.85 160.36,83.66 160.36,83.53 160.24,83.41 160.12,83.41 159.92,83.61 159.79,83.61 159.68,83.49 159.68,83.37 159.87,83.17 159.87,83.04 159.39,82.56 156.64,82.56 155.88,83.32 155.88,85.3 154.67,86.52 148.28,86.52 143.39,81.63 140.87,81.63 arc(140.51,81.57) 140.18,81.43 arc(140.13,81.39) 140.08,81.36 arc(140.01,81.31) 139.95,81.25 139.88,81.18 arc(139.72,81.07) 139.53,81.03 139.51,81.03 arc(139.24,80.94) 139.02,80.77 138.96,80.72 arc(138.65,80.51) 138.29,80.44 arc(137.86,80.45) 137.43,80.49 arc(137.06,80.59) 136.74,80.78 arc(136.7,80.8) 136.67,80.83 arc(136.31,80.97) 135.96,80.82 135.85,80.71 arc(135.46,80.55) 135.07,80.71 arc(134.99,80.79) 134.91,80.86 134.54,81.23 arc(134.52,81.24) 134.49,81.25 134.03,81.35 arc(134.01,81.35) 133.99,81.36 arc(133.98,81.36) 133.98,81.36 arc(133.9,81.38) 133.82,81.38 arc(133.79,81.38) 133.77,81.38 arc(133.72,81.38) 133.68,81.38 133.41,81.38 arc(133.33,81.38) 133.25,81.36 arc(133.14,81.31) 133.04,81.23 132.76,80.95 arc(132.74,80.91) 132.73,80.88 arc(132.69,80.83) 132.66,80.78 arc(132.49,80.62) 132.27,80.55 132.26,80.55 129.05,80.55 arc(128.83,80.48) 128.67,80.32 arc(128.62,80.24) 128.55,80.18 arc(128.42,80.11) 128.27,80.09 arc(128.05,80.03) 127.89,79.88 127.88,79.86 arc(127.71,79.69) 127.48,79.63 127.46,79.63 127.31,79.59 127.14,79.42 127.09,79.42 127.08,79.4 arc(126.92,79.24) 126.7,79.17 126.68,79.17 arc(126.46,79.11) 126.29,78.96 126.27,78.92 arc(126.11,78.77) 125.88,78.71 125.86,78.71 arc(125.65,78.78) 125.49,78.94 arc(125.33,79.1) 125.11,79.17 125.09,79.17 arc(124.87,79.11) 124.7,78.96 124.68,78.92 arc(124.51,78.77) 124.29,78.71 123.82,78.71 v1(123.49,78.71)
DDR4_DDIMM2_DQ11: length 95.3
  L12_SIG4 w0.089: v1(176.24,93.34) 175.74,93.84 175.6,93.84 175.51,93.93 175.51,94.53 175.42,94.62 175.25,94.62 175.16,94.53 175.16,93.93 175.07,93.84 174.91,93.84 174.82,93.93 174.82,94.53 174.73,94.62 174.57,94.62 174.48,94.53 174.48,93.93 174.39,93.84 174.22,93.84 174.13,93.93 174.13,94.53 174.05,94.62 173.88,94.62 173.79,94.53 173.79,93.93 173.7,93.84 173.54,93.84 173.45,93.93 173.45,94.53 173.36,94.62 173.19,94.62 173.11,94.53 173.11,93.93 173.02,93.84 172.85,93.84 172.76,93.93 172.76,94.53 172.67,94.62 172.51,94.62 172.42,94.53 172.42,93.93 172.33,93.84 171.56,93.84 171.47,93.93 171.47,94.38 171.38,94.47 171.22,94.47 171.13,94.38 171.13,93.93 171.04,93.84 170.83,93.84 170.67,93.68 170.67,93.2 170.45,92.98 169.86,92.98 166.58,89.7 166.58,89.44 166.67,89.35 167.26,89.35 167.35,89.26 167.35,89.1 167.26,89.01 166.67,89.01 166.58,88.92 166.58,87.69 166.06,87.16 165.93,87.16 165.27,87.82 165.15,87.82 165.03,87.7 165.03,87.58 165.69,86.92 165.69,86.79 165.57,86.68 165.45,86.68 164.79,87.34 164.66,87.34 164.55,87.22 164.55,87.09 165.21,86.43 165.21,86.31 165.1,86.2 165.1,85.51 164.77,85.18 164.77,85.05 165.05,84.77 165.05,84.64 164.94,84.53 164.81,84.53 164.53,84.81 164.4,84.81 164.04,84.45 164.04,84.32 164.99,83.36 164.99,83.24 164.88,83.12 164.75,83.12 163.79,84.08 163.67,84.08 163.55,83.96 163.55,83.83 164.51,82.88 164.51,82.75 164.39,82.63 164.27,82.63 163.31,83.59 163.18,83.59 159.09,79.5 158.96,79.5 158.51,79.95 158.38,79.95 158.26,79.83 158.26,79.71 158.72,79.25 158.72,79.13 158.6,79.01 158.48,79.01 158.02,79.47 157.9,79.47 157.78,79.35 157.78,79.22 158.23,78.77 158.23,78.64 157.57,77.98 157.18,77.98 157.09,78.07 157.09,79.22 157,79.3 156.83,79.3 156.74,79.22 156.74,78.07 156.66,77.98 156.49,77.98 156.4,78.07 156.4,79.22 156.31,79.3 156.15,79.3 156.06,79.22 156.06,78.07 155.97,77.98 155.8,77.98 155.72,78.07 155.72,79.22 155.63,79.3 155.46,79.3 155.37,79.22 155.37,78.07 155.28,77.98 148.69,77.98 146.92,79.75 145.95,79.75 145.83,79.63 143.41,79.63 arc(143.19,79.57) 143.02,79.41 143.01,79.4 arc(142.84,79.23) 142.62,79.17 arc(142.39,79.23) 142.22,79.39 142.22,79.4 arc(142.05,79.57) 141.82,79.63 arc(141.59,79.57) 141.42,79.4 141.42,79.4 arc(141.25,79.23) 141.03,79.17 141.02,79.17 arc(140.8,79.23) 140.63,79.39 140.62,79.4 arc(140.46,79.57) 140.23,79.63 140.22,79.63 arc(139.99,79.57) 139.83,79.4 arc(139.78,79.33) 139.72,79.27 arc(139.68,79.25) 139.64,79.24 139.14,79.24 arc(139.1,79.23) 139.06,79.21 138.89,79.04 arc(138.53,78.79) 138.1,78.71 arc(137.35,78.63) 136.63,78.39 136.27,78.22 arc(135.77,78.11) 135.27,78.22 134.45,78.6 arc(134.21,78.68) 133.95,78.71 133.84,78.71 arc(133.62,78.64) 133.45,78.48 arc(133.29,78.32) 133.07,78.25 133.05,78.25 arc(132.83,78.19) 132.66,78.03 132.65,78 arc(132.48,77.85) 132.26,77.79 132.24,77.79 arc(132.02,77.86) 131.86,78.02 arc(131.7,78.18) 131.48,78.25 131.46,78.25 arc(131.24,78.31) 131.07,78.46 131.06,78.48 arc(130.89,78.65) 130.66,78.71 130.65,78.71 arc(130.43,78.64) 130.27,78.48 arc(130.11,78.32) 129.89,78.25 129.87,78.25 arc(129.65,78.19) 129.48,78.03 129.46,78 arc(129.29,77.85) 129.07,77.79 129.05,77.79 arc(128.83,77.72) 128.67,77.56 arc(128.51,77.4) 128.29,77.33 128.27,77.33 arc(128.05,77.27) 127.89,77.12 127.87,77.08 arc(127.7,76.93) 127.48,76.87 arc(127.25,76.81) 127.08,76.65 127.07,76.63 arc(126.91,76.47) 126.68,76.41 arc(126.45,76.35) 126.29,76.19 126.28,76.18 arc(126.11,76.01) 125.88,75.95 125.87,75.95 arc(125.65,76.01) 125.49,76.18 arc(125.32,76.34) 125.1,76.41 125.08,76.41 arc(124.85,76.47) 124.69,76.64 arc(124.52,76.81) 124.3,76.87 v1(123.49,76.87)
DDR4_DDIMM2_DQ12: length 96.8
  TOP w0.149: J1.14 184.74,97.6 183.51,96.38 v1(183.51,95.66)
  L12_SIG4 w0.089: v1(120.31,78.71) 119.91,78.02 119.9,78 arc(119.73,77.85) 119.51,77.79 119.49,77.79 arc(119.27,77.72) 119.11,77.56 arc(118.95,77.4) 118.74,77.33 118.71,77.33 arc(118.49,77.27) 118.33,77.12 118.31,77.1 arc(118.25,76.87) 118.31,76.64 arc(118.38,76.42) 118.32,76.2 118.31,76.18 arc(118.25,75.95) 118.31,75.72 118.32,75.7 arc(118.38,75.48) 118.31,75.26 arc(118.25,75.03) 118.31,74.8 118.31,74.8 arc(118.48,74.63) 118.7,74.57 118.73,74.57 arc(118.95,74.5) 119.11,74.34 arc(119.27,74.18) 119.49,74.11 119.51,74.11 arc(119.74,74.05) 119.91,73.88 119.91,73.87 arc(120.08,73.71) 120.31,73.65 120.31,73.65 arc(120.54,73.59) 120.7,73.42 arc(120.87,73.25) 121.1,73.19 121.1,73.19 arc(121.33,73.13) 121.49,72.97 121.51,72.95 arc(121.68,72.79) 121.9,72.73 arc(122.13,72.67) 122.3,72.5 122.3,72.5 arc(122.46,72.33) 122.69,72.27 122.7,72.27 arc(122.92,72.21) 123.09,72.05 123.1,72.03 arc(123.27,71.87) 123.49,71.81 123.51,71.81 arc(123.73,71.74) 123.89,71.58 arc(124.05,71.41) 124.28,71.35 124.29,71.35 arc(124.51,71.29) 124.68,71.13 arc(124.72,71.07) 124.76,71.02 124.81,70.97 125.28,70.97 125.58,71.28 127.85,71.28 128.79,72.21 129.07,72.27 arc(129.3,72.33) 129.47,72.49 129.47,72.5 arc(129.64,72.67) 129.87,72.73 129.87,72.73 arc(130.1,72.79) 130.27,72.96 arc(130.43,73.13) 130.66,73.19 130.66,73.19 arc(130.89,73.13) 131.06,72.96 131.07,72.96 arc(131.23,72.79) 131.46,72.73 arc(131.69,72.67) 131.86,72.5 arc(132.26,72.27) 132.67,72.5 arc(132.84,72.68) 133.08,72.74 arc(133.3,72.8) 133.45,72.96 133.57,73.35 133.57,73.35 arc(133.75,73.53) 134,73.6 134.01,73.6 arc(134.25,73.67) 134.44,73.85 134.44,73.86 arc(134.62,74.03) 134.87,74.1 arc(135.12,74.03) 135.3,73.85 135.3,73.85 arc(135.48,73.67) 135.73,73.6 135.74,73.6 arc(135.99,73.67) 136.17,73.85 136.17,73.86 arc(136.6,74.1) 137.03,73.86 137.03,73.85 arc(137.22,73.67) 137.46,73.6 137.47,73.6 arc(137.72,73.67) 137.9,73.85 137.9,73.85 arc(138.08,74.03) 138.33,74.1 arc(138.58,74.16) 138.76,74.34 138.77,74.35 arc(138.95,74.53) 139.2,74.6 139.2,74.6 arc(139.45,74.53) 139.63,74.35 139.64,74.34 arc(140.06,74.1) 140.49,74.34 140.5,74.35 arc(140.68,74.53) 140.93,74.6 140.93,74.6 arc(141.18,74.53) 141.36,74.35 141.37,74.34 arc(141.55,74.16) 141.8,74.1 arc(142.04,74.16) 142.23,74.34 142.23,74.35 arc(142.41,74.53) 142.66,74.6 142.66,74.6 arc(142.91,74.67) 143.09,74.85 143.1,74.85 arc(143.28,75.03) 143.52,75.1 147.02,75.1 149.07,73.05 156.28,73.05 157.75,74.53 165.96,74.53 166.64,75.2 166.93,75.2 168.52,76.8 168.52,84.68 172.83,88.99 174.61,88.99 174.68,88.93 180.41,88.93 180.48,88.99 180.6,88.99 184.31,92.7 184.31,93.1 184.36,93.15 184.36,93.54 184.31,93.59 184.31,94.86 v1(183.51,95.66)
DDR4_DDIMM2_DQ13: length 96.6
  L12_SIG4 w0.089: v1(183.89,93.34) 183.7,93.34 183.07,92.71 183.07,92.25 180.23,89.41 174.86,89.41 174.81,89.46 172.64,89.46 168.05,84.87 168.05,79.09 167.96,79 167.26,79 167.17,78.91 167.17,78.75 167.26,78.66 167.96,78.66 168.05,78.57 168.05,78.18 167.96,78.09 166.61,78.09 166.52,78 166.52,77.84 166.61,77.75 167.96,77.75 168.05,77.66 168.05,76.99 167.75,76.7 167.63,76.7 167.45,76.88 167.32,76.88 167.2,76.76 167.2,76.63 167.38,76.45 167.38,76.33 167.27,76.21 167.14,76.21 166.96,76.39 166.84,76.39 166.72,76.28 166.72,76.15 166.9,75.97 166.9,75.84 166.73,75.67 166.44,75.67 165.77,75 165.45,75 165.36,75.09 165.36,75.27 165.27,75.36 165.11,75.36 165.02,75.27 165.02,75.09 164.93,75 157.56,75 156.09,73.52 149.27,73.52 146.81,75.97 146.53,75.97 146.44,75.89 146.44,75.67 146.36,75.58 146.19,75.58 146.1,75.67 146.1,75.89 146.01,75.97 145.85,75.97 145.76,75.89 145.76,75.67 145.67,75.58 145.5,75.58 145.42,75.67 145.42,75.89 145.33,75.97 145.16,75.97 145.07,75.89 145.07,75.67 144.98,75.58 144.82,75.58 144.73,75.67 144.73,75.89 144.64,75.97 144.48,75.97 144.39,75.89 144.39,75.67 144.3,75.58 144.13,75.58 144.04,75.67 144.04,75.89 143.95,75.97 143.44,75.97 arc(143.27,75.94) 143.13,75.84 142.98,75.69 arc(142.83,75.59) 142.66,75.56 142.47,75.56 arc(142.33,75.47) 142.23,75.35 arc(142.05,75.17) 141.8,75.1 141.79,75.1 arc(141.54,75.17) 141.36,75.35 140.93,75.6 140.92,75.6 arc(140.68,75.53) 140.5,75.35 arc(140.32,75.17) 140.07,75.1 140.06,75.1 arc(139.81,75.17) 139.63,75.35 arc(139.45,75.53) 139.21,75.6 139.19,75.6 arc(138.95,75.53) 138.77,75.35 arc(138.58,75.17) 138.34,75.1 138.33,75.1 arc(138.08,75.03) 137.9,74.85 137.9,74.85 arc(137.47,74.6) 137.04,74.85 137.03,74.85 arc(136.85,75.03) 136.61,75.1 136.6,75.1 arc(136.35,75.03) 136.17,74.85 136.17,74.85 arc(135.73,74.6) 135.3,74.85 135.3,74.85 arc(135.12,75.03) 134.87,75.1 134.86,75.1 arc(134.62,75.03) 134.44,74.85 134.43,74.85 arc(134.27,74.68) 134.05,74.6 arc(134,74.59) 133.95,74.57 arc(133.76,74.41) 133.66,74.19 arc(133.6,74.03) 133.49,73.9 arc(133.32,73.79) 133.13,73.73 arc(132.86,73.63) 132.66,73.42 arc(132.49,73.25) 132.26,73.19 132.26,73.19 arc(132.03,73.25) 131.86,73.42 arc(131.69,73.59) 131.46,73.65 131.46,73.65 arc(131.23,73.71) 131.07,73.87 131.06,73.88 arc(130.9,74.05) 130.67,74.11 130.66,74.11 arc(130.43,74.05) 130.27,73.88 130.26,73.88 arc(130.1,73.71) 129.87,73.65 129.86,73.65 arc(129.64,73.59) 129.47,73.42 129.47,73.42 arc(129.3,73.25) 129.07,73.19 129.06,73.19 arc(128.84,73.13) 128.67,72.96 arc(128.51,72.79) 128.28,72.73 128.27,72.73 arc(128.05,72.67) 127.88,72.51 127.87,72.49 arc(127.7,72.33) 127.48,72.27 127.08,72.14 126.75,71.81 125.09,71.81 arc(124.86,71.87) 124.69,72.03 124.68,72.05 arc(124.51,72.21) 124.29,72.27 124.28,72.27 arc(124.05,72.33) 123.89,72.5 arc(123.73,72.66) 123.51,72.73 123.49,72.73 arc(123.27,72.79) 123.1,72.95 123.09,72.97 arc(122.92,73.13) 122.7,73.19 122.69,73.19 arc(122.46,73.25) 122.3,73.42 arc(122.13,73.59) 121.91,73.65 121.9,73.65 arc(121.67,73.71) 121.5,73.87 121.5,73.88 arc(121.33,74.05) 121.11,74.11 121.08,74.11 arc(120.86,74.18) 120.7,74.34 arc(120.54,74.5) 120.32,74.57 120.3,74.57 arc(120.07,74.63) 119.91,74.8 arc(119.74,74.97) 119.51,75.03 119.51,75.03 arc(119.28,75.09) 119.11,75.25 119.1,75.28 arc(119.05,75.5) 119.11,75.72 119.11,75.72 arc(119.17,75.95) 119.11,76.18 arc(119.05,76.4) 119.1,76.62 119.11,76.65 arc(119.28,76.81) 119.51,76.87 arc(119.73,76.92) 119.9,77.08 119.92,77.12 arc(120.09,77.27) 120.31,77.33 120.33,77.33 arc(120.55,77.4) 120.71,77.56 v1(121.1,78.25)
DDR4_DDIMM2_DQ14: length 94
  L12_SIG4 w0.089: v1(178.79,97.95) 179.51,97.95 180.06,98.5 181.37,98.5 181.72,98.15 181.72,95.21 182.24,94.69 182.24,92.08 180.04,89.89 175.89,89.89 175.84,89.93 172.44,89.93 167.58,85.07 167.58,80.1 164.68,77.19 164.68,77.07 164.97,76.77 164.97,76.65 164.86,76.53 164.73,76.53 164.43,76.83 164.31,76.83 164.19,76.71 164.19,76.58 164.49,76.29 164.49,76.16 164.37,76.04 164.25,76.04 163.95,76.34 163.82,76.34 163.71,76.22 163.71,76.1 164,75.8 164,75.68 163.89,75.56 163.76,75.56 163.46,75.86 163.34,75.86 162.95,75.47 157.36,75.47 155.89,73.99 152.51,73.99 152.42,74.08 152.42,74.55 152.33,74.64 152.16,74.64 152.07,74.55 152.07,74.08 151.99,73.99 150.31,73.99 150.22,74.08 150.22,74.51 150.14,74.6 149.97,74.6 149.88,74.51 149.88,74.08 149.79,73.99 149.46,73.99 148.05,75.4 147.01,76.44 142.16,76.44 141.95,76.23 arc(141.8,76.14) 141.63,76.1 138.39,76.1 arc(138.22,76.07) 138.08,75.97 137.79,75.68 arc(137.47,75.55) 137.16,75.68 137.03,75.81 arc(136.61,76.08) 136.17,75.82 arc(135.95,75.62) 135.64,75.62 135.53,75.67 135.14,75.93 arc(135.01,75.99) 134.87,76.01 134.76,76.01 arc(134.54,75.97) 134.36,75.84 134.33,75.82 arc(134.21,75.66) 134.04,75.57 arc(134.03,75.57) 134.02,75.56 133.81,75.5 arc(133.72,75.46) 133.64,75.39 133.58,75.33 arc(133.49,75.19) 133.45,75.03 133.45,74.8 133.45,74.8 arc(133.28,74.63) 133.05,74.57 133.05,74.57 arc(132.82,74.51) 132.66,74.34 arc(132.49,74.17) 132.27,74.11 132.25,74.11 arc(132.03,74.17) 131.86,74.34 arc(131.69,74.51) 131.47,74.57 131.45,74.57 arc(131.23,74.63) 131.06,74.8 arc(130.9,74.97) 130.67,75.03 130.66,75.03 arc(130.44,74.97) 130.27,74.81 130.26,74.8 arc(130.1,74.63) 129.87,74.57 arc(129.64,74.51) 129.47,74.34 129.47,74.34 arc(129.3,74.17) 129.07,74.11 129.06,74.11 arc(128.84,74.05) 128.67,73.88 128.67,73.88 arc(128.5,73.71) 128.27,73.65 128.27,73.65 arc(128.04,73.59) 127.88,73.42 127.87,73.42 arc(127.71,73.25) 127.48,73.19 127.47,73.19 arc(127.24,73.12) 127.08,72.96 arc(126.91,72.79) 126.69,72.73 126.68,72.73 arc(126.45,72.67) 126.29,72.51 126.22,72.4 126.13,72.35 125.61,72.35 125.56,72.4 arc(125.52,72.45) 125.49,72.5 arc(125.32,72.66) 125.1,72.73 125.09,72.73 arc(124.86,72.79) 124.69,72.95 124.68,72.97 arc(124.51,73.13) 124.29,73.19 124.29,73.19 arc(124.06,73.25) 123.89,73.42 arc(123.73,73.59) 123.5,73.65 123.49,73.65 arc(123.27,73.71) 123.1,73.87 123.09,73.88 arc(122.93,74.05) 122.7,74.11 122.68,74.11 arc(122.46,74.17) 122.3,74.34 arc(122.14,74.5) 121.92,74.57 121.89,74.57 arc(121.67,74.63) 121.5,74.8 arc(121.33,74.97) 121.11,75.03 121.1,75.03 arc(120.88,75.09) 120.71,75.25 120.7,75.27 arc(120.53,75.43) 120.31,75.49 arc(120.08,75.55) 119.91,75.72 119.91,75.72 arc(119.85,75.95) 119.91,76.18 v1(120.31,76.87)
DDR4_DDIMM2_DQ15: length 94
  L12_SIG4 w0.089: v1(121.1,77.33) 121.1,77.33 120.7,76.64 arc(120.7,76.19) 121.09,75.95 121.16,75.95 arc(121.27,75.93) 121.36,75.87 121.79,75.44 122.11,75.44 122.3,75.25 arc(122.47,75.09) 122.7,75.03 122.7,75.03 arc(122.93,74.97) 123.09,74.8 arc(123.26,74.63) 123.48,74.57 123.51,74.57 arc(123.73,74.5) 123.89,74.34 arc(124.05,74.17) 124.27,74.11 124.29,74.11 arc(124.52,74.05) 124.69,73.88 124.69,73.87 arc(124.86,73.71) 125.09,73.65 125.09,73.65 arc(125.32,73.59) 125.48,73.42 arc(125.65,73.25) 125.88,73.19 125.88,73.19 arc(126.11,73.25) 126.28,73.42 126.28,73.42 arc(126.45,73.59) 126.68,73.65 126.68,73.65 arc(126.91,73.71) 127.08,73.88 127.08,73.88 arc(127.24,74.05) 127.47,74.11 127.48,74.11 arc(127.7,74.17) 127.87,74.33 127.88,74.35 arc(128.05,74.51) 128.27,74.57 arc(128.5,74.63) 128.67,74.8 128.68,74.81 arc(128.84,74.97) 129.07,75.03 129.08,75.03 arc(129.3,75.09) 129.47,75.26 arc(129.64,75.43) 129.86,75.49 129.87,75.49 arc(130.1,75.55) 130.27,75.72 arc(130.44,75.89) 130.66,75.95 arc(130.89,75.89) 131.06,75.72 131.06,75.72 arc(131.23,75.55) 131.46,75.49 arc(131.69,75.43) 131.86,75.27 131.86,75.25 arc(132.03,75.09) 132.26,75.03 132.26,75.03 arc(132.49,75.09) 132.66,75.26 arc(132.82,75.43) 133.05,75.49 133.14,75.49 arc(133.42,75.61) 133.53,75.88 133.53,75.96 arc(133.67,76.28) 133.98,76.41 137.68,76.41 arc(137.74,76.42) 137.8,76.46 140,76.46 140.09,76.55 140.09,76.84 140.18,76.93 140.35,76.93 140.44,76.84 140.44,76.55 140.53,76.46 141.59,76.46 142.04,76.91 144.37,76.91 144.46,77 144.46,77.1 144.55,77.19 144.72,77.19 144.81,77.1 144.81,77.01 144.9,76.91 145.06,76.91 145.15,77 145.15,77.1 145.24,77.19 145.4,77.19 145.49,77.1 145.49,77.01 145.59,76.91 145.75,76.91 145.83,77 145.83,77.1 145.92,77.19 146.09,77.19 146.18,77.1 146.18,77.01 146.27,76.91 146.43,76.91 146.52,77 146.52,77.1 146.61,77.19 146.77,77.19 146.86,77.1 146.86,77.01 146.96,76.91 147.2,76.91 148.24,75.87 148.95,75.17 156.4,75.17 157.17,75.94 157.17,75.94 157.34,76.1 162.92,76.1 163.14,76.32 163.14,76.45 162.86,76.72 162.86,76.85 162.98,76.96 163.11,76.96 163.38,76.69 163.51,76.69 163.62,76.81 163.62,76.93 163.35,77.2 163.35,77.33 163.47,77.45 163.59,77.45 163.87,77.17 163.99,77.17 164.11,77.29 164.11,77.42 163.83,77.69 163.83,77.82 163.95,77.93 164.08,77.93 164.35,77.66 164.48,77.66 164.59,77.78 164.59,77.9 164.32,78.17 164.32,78.3 164.44,78.42 164.56,78.42 164.84,78.14 164.96,78.14 165.08,78.26 165.08,78.39 164.8,78.66 164.8,78.79 164.92,78.9 165.05,78.9 165.32,78.63 165.45,78.63 165.56,78.75 165.56,78.87 165.29,79.14 165.29,79.27 165.41,79.39 165.53,79.39 165.81,79.11 165.93,79.11 166.05,79.23 166.05,79.36 165.77,79.63 165.77,79.76 165.89,79.87 166.02,79.87 166.29,79.6 166.42,79.6 166.53,79.72 166.53,79.84 166.26,80.11 166.26,80.24 166.38,80.36 166.5,80.36 166.78,80.08 166.9,80.08 167.11,80.29 167.11,85.26 172.3,90.46 174.18,90.46 174.28,90.56 175.67,90.56 175.88,90.77 176.51,90.77 176.6,90.86 176.6,91.16 176.69,91.24 176.86,91.24 176.94,91.16 176.94,90.86 177.03,90.77 177.2,90.77 177.29,90.86 177.29,91.16 177.38,91.24 177.54,91.24 177.63,91.16 177.63,90.86 177.72,90.77 177.88,90.77 177.97,90.86 177.97,91.16 178.06,91.24 178.23,91.24 178.32,91.16 178.32,90.86 178.41,90.77 179.73,90.77 181.77,92.82 181.77,94.49 181.5,94.76 178,94.76 v1(177.93,94.69)
