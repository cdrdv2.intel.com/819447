# Allegro board FM85_AGILEX_PCIE_DK_CMC_ADI_REVC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N51915123: length 77.4
  TOP w0.149: v1(198.22,89.5) 198.36,89.35 R6302.1
  L16_SIG6 w0.081: v1(132.24,69.98) 133.64,69.98 arc(133.65,69.98) 133.66,69.97 133.83,69.8 arc(133.87,69.77) 133.91,69.77 134.47,69.77 arc(134.51,69.77) 134.54,69.8 135.18,70.44 arc(135.22,70.46) 135.26,70.47 135.62,70.47 arc(135.66,70.48) 135.69,70.5 136.25,71.06 arc(136.29,71.08) 136.33,71.09 136.89,71.09 arc(136.93,71.1) 136.97,71.12 137.74,71.9 arc(137.78,71.92) 137.82,71.93 138.52,71.93 arc(138.56,71.94) 138.59,71.96 139.18,72.55 arc(139.22,72.58) 139.26,72.58 139.4,72.58 arc(139.44,72.59) 139.48,72.61 139.88,73.02 arc(139.91,73.04) 139.95,73.05 140.27,73.05 arc(140.31,73.05) 140.34,73.08 140.67,73.4 arc(140.7,73.42) 140.74,73.43 141.06,73.43 arc(141.1,73.44) 141.13,73.46 142.37,74.7 arc(142.4,74.72) 142.44,74.73 143.09,74.73 arc(143.13,74.74) 143.16,74.76 144.14,75.74 arc(144.17,75.76) 144.21,75.77 146.01,75.77 arc(146.05,75.78) 146.08,75.8 148.25,77.97 arc(148.28,77.99) 148.32,78 153.02,78 arc(153.06,78.01) 153.1,78.03 155.97,80.9 arc(156,80.92) 156.04,80.93 183.12,80.93 arc(183.16,80.92) 183.19,80.9 183.48,80.61 arc(183.51,80.59) 183.55,80.58 185.55,80.58 arc(185.59,80.59) 185.63,80.61 186.1,81.09 arc(186.13,81.11) 186.17,81.12 186.39,81.12 arc(186.43,81.11) 186.47,81.09 186.59,80.96 arc(186.63,80.94) 186.67,80.93 187.23,80.93 arc(187.27,80.94) 187.3,80.96 187.36,81.02 arc(187.39,81.04) 187.42,81.05 187.62,81.05 arc(187.66,81.04) 187.69,81.02 187.75,80.96 arc(187.78,80.94) 187.81,80.93 192.04,80.93 arc(192.08,80.94) 192.11,80.96 194.98,83.83 arc(195.01,83.87) 195.01,83.91 195.01,84.05 arc(195.02,84.09) 195.04,84.12 195.39,84.46 arc(195.42,84.49) 195.46,84.49 195.56,84.49 arc(195.6,84.5) 195.63,84.52 197.83,86.72 arc(197.85,86.76) 197.86,86.8 197.86,86.94 arc(197.87,86.98) 197.89,87.01 198.49,87.61 arc(198.5,87.62) 198.51,87.62 198.53,87.64 arc(198.54,87.64) 198.55,87.64 198.87,87.96 arc(198.89,88) 198.9,88.04 198.9,88.78 arc(198.89,88.82) 198.87,88.85 v1(198.22,89.5)
N51917930: length 0.9
  BOTTOM w0.149: v1(133.05,66.75) 133.48,67.17 133.67,67.17 R6306.1
N51946602: length 1.1
  BOTTOM w0.149: v1(133.05,60.31) 133.26,60.1 133.43,60.1 133.54,60.21 R6310.1
N51951812: length 1.4
  BOTTOM w0.149: R6313.1 100.5,50.21 100.24,50.47 100.24,50.5 v1(100.38,50.65)
N363486630: length 1
  BOTTOM w0.254: R837.2 C1006.1
N403487415: length 6.9
  BOTTOM w0.149: J10.1 224.16,99.46 225.33,100.64 225.33,103.86 226.11,104.64 R2736.1
N410618580: length 1.6
  TOP w0.254: R669.1 211.56,33.73 211.87,33.43 C823.1
N410644160: length 1.7
  TOP w0.254: R657.1 44.93,106.26 C806.1
N450516220: length 1.3
  TOP w0.149: R943.2 C1329.1
N478710411: length 1
  TOP w0.203: R6050.2 181.49,65.89 181.6,66 C7568.1

## Copper pours and planes (outline as drawn)
5V on TOP: 234.27,61.7 235.69,61.7 237.62,59.77 242.32,59.77 242.93,59.16 242.93,57.64 242.53,57.23 233.18,57.23 233.05,57.36 233.05,59.26 232.82,59.49 232.82,60.25
5V on TOP: 29.65,41.51 29.12,40.97 28.84,40.97 28.57,40.71 28.57,36.87 28,36.3 14.18,36.3 13.27,35.4 4.69,35.4 4.38,35.71 4.38,44.83 4.61,45.06 28.78,45.06 29.65,44.19
5V on BOTTOM: 14.45,38.04 16.62,35.87 19.84,35.87 20.15,36.17 20.15,37.11 20.07,37.19 19.36,37.19 19.31,37.14 19.31,36.71 19.01,36.4 18.09,36.4 17.74,36.76 17.74,43.23 17.58,43.39 16.9,43.39 16.09,42.57 14.76,42.57 14.45,42.26
5V on BOTTOM: 22.52,56.83 22.52,55.2 23.57,54.16 28.84,54.16 29.18,54.5 29.18,57.33 28.83,57.69 27.51,57.69 27.32,57.5 27.32,56.92 27.45,56.79 27.95,56.79 28.15,56.59 28.15,55.98 28,55.83 27.08,55.83 27.01,55.91 27.01,56.59 26.93,56.67 25.64,56.67 24.82,57.48 23.17,57.48
5V on BOTTOM: 31.91,37.25 31.87,37.29 31.26,37.29 31.17,37.38 30.89,37.38 30.77,37.26 30.77,36.58 30.69,36.5 29.98,36.5 28.61,37.87 28.61,40.87 28.77,41.03 29.24,41.03 29.29,41.08 29.29,44.4 29.09,44.61 27.06,44.61 26.23,43.78 26.23,35.77 26.73,35.27 30.76,35.27 31.91,36.42
5V on BOTTOM: 8.77,34.42 8.9,34.55 8.9,36.81 8.82,36.88 8.19,36.88 8.11,36.81 8.11,35.16 7.88,34.93 4.86,34.93 4.53,35.26 4.53,38.26 4.71,38.43 6.46,38.43 6.66,38.64 6.66,39.55 4.6,39.55 4.45,39.7 4.45,40.77 4.66,40.97 6.56,40.97 6.66,41.07 6.66,42.83 6.51,42.98 6.51,44.61 6.66,44.76 6.66,45.62 6.59,45.7 3.84,45.7 3.84,34.72 4.15,34.42
5V on L03_SIG1: 23.56,56.25 23.56,55.05 23.99,54.62 25.64,54.62 26.17,55.15 26.17,56.1 26.02,56.25
5V on L05_SIG2: 33.01,85.77 33.01,77.04 41.42,68.64 58.99,68.64 64.05,73.7 72.69,73.7 72.88,73.89 72.88,77.02 71.43,78.46 61.92,78.46 57.38,73.93 45.62,73.93 39.35,80.2 39.35,86.63 33.88,86.63
5V on L09_PWR1: 35.59,84.41 35.59,87.24 33.71,89.12 33.71,97.18 31.71,99.19 31.71,107.81 29.8,109.71 5.2,109.71 1.71,106.22 1.71,38.99 4.41,36.29 25.42,36.29 29.25,40.12 29.25,40.13 29.32,40.2 29.32,43.92 24.9,48.33 24.9,60.98 21.16,64.73 21.16,78.63 26.52,83.99 35.17,83.99
5V on L10_PWR2: 70.97,73.59 72.27,73.59 72.35,73.66 72.35,76.48 72.87,77 80.09,77 81.25,78.16 84.77,78.16 86.33,79.72 87.74,79.72 88.27,80.25 88.27,93.66 89.52,94.92 109.99,94.92 113.65,98.58 186.81,98.58 190.35,102.12 194.85,102.12 196.76,100.21 196.76,90.74 197.38,90.13 198.93,90.13 199.59,89.47 199.59,88.01 192.06,80.48 192.06,67.49 194.46,65.09 201.07,65.09 203.8,67.82 205.72,67.82 210.23,63.32 210.23,61.4 213.05,58.58 235.41,58.58 236.25,59.41 236.25,61.47 235.49,62.23 232.06,62.23 224.63,69.67 206.98,69.67 206.36,70.28 206.36,73.94 203.99,76.31 203.99,105.19 202.47,106.71 194.32,106.71 194.04,106.43 107.26,106.43 106.3,105.47 106.3,100.69 105.34,99.72 78.44,99.72 76.54,97.82 76.54,91.19 76.08,90.73 76.08,84.25 70.75,78.92 70.75,73.82
5V on L16_SIG6: 247.53,45.47 249.51,45.47 249.97,45.93 249.97,55.91 242.58,63.3 230.54,63.3 229.47,62.23 229.47,59.18 231.15,57.51 243.49,57.51 245.33,55.67 245.33,51.4 247.45,49.28 247.45,45.54
5V_AGND on TOP: 228.28,57.36 227.97,57.66 227.97,64.44 228.12,64.59 232.1,64.59 232.33,64.37 232.33,63.64 232.21,63.53 231.6,63.53 231.26,63.19 230.35,63.19 230.08,62.92 230.08,59.49 230.23,59.34 230.77,59.34 230.99,59.11 230.99,57.43 230.92,57.36
12V_AUX on TOP: 244.61,85.93 244.61,98.96 244.53,99.04 241.97,99.04 240.98,100.02 240.98,100.03 239.76,101.25 239.76,101.25 234.65,101.25 234.18,101.72 234.18,102.91 231.99,105.11 223.78,105.11 222.77,104.09 222.77,93.42 223.4,92.79 228.99,92.79 229.24,92.53 229.24,91.52 231.66,91.52 231.83,91.35 231.83,88.93 232.04,88.72 236.61,88.72 239.78,85.55 244.23,85.55
12V_AUX on BOTTOM: 245.09,98.58 245.09,91.95 244.36,91.95 244.36,91.39 245.09,91.39 245.09,90.88 244.36,90.88 244.36,90.35 245.09,90.35 245.09,86.29 244.36,85.55 238.77,85.55 236.1,88.22 232.04,88.22 231.66,88.6 231.66,90.27 230.95,90.98 226.99,90.98 225.81,92.15 225.81,93.8 225.18,94.44 223.65,94.44 223.15,94.95 223.15,97.61 223.53,98 232.62,98 234.5,99.88 234.5,100.94 234.8,101.25 239.76,101.25 241.97,99.04 244.63,99.04
12V_AUX on L03_SIG1: 233.97,103.2 243.97,103.2 244.99,102.19 244.99,86.31 243.85,85.17 234.35,85.17 231.22,88.29 231.22,90.81 230.84,91.19 226.8,91.19 222.88,95.11 222.88,97.48 223.6,98.2 232.82,98.2 233.36,98.73 233.36,102.59
12V_AUX on L05_SIG2: 244.48,85.04 240.67,85.04 237.2,88.51 226.91,88.51 220.1,95.32 220.1,99.9 220.86,100.66 230.64,100.66 232.67,102.69 243.47,102.69 245.37,100.79 245.37,85.93
12V_G1 on TOP: 174.36,78.3 174.36,75.56 172.92,74.11 172.92,66.56 174.57,64.91 174.57,61.79 172.9,60.12 172.9,52.4 174.57,50.74 174.57,47.44 172.8,45.67 172.8,37.9 174.22,36.48 174.22,30.49 173.74,30.01 170.73,30.01 170.44,30.29 170.44,35.34 170.55,35.45 171.28,35.45 171.6,35.78 171.6,36.47 171.38,36.69 171.38,60.98 171.3,61.05 171.3,91.75 171.81,92.26 173.37,92.26 173.68,91.96 173.68,88.66 172.78,87.77 172.78,79.88
12V_G1 on TOP: 231.96,85.04 230.77,85.04 230.64,84.91 230.64,78.9 231.48,78.06 233.05,78.06 233.31,77.8 233.31,76.02 233.05,75.77 231.44,75.77 230.77,75.1 230.77,68.66 231.15,68.28 237.73,68.28 238.01,68.55 238.01,71.83 236.76,73.08 236.76,75.31 237.75,76.3 237.75,76.66 238.64,77.55 238.64,85.55 237.18,87.01 233.97,87.01 233.29,87.68 232.29,87.68 232.1,87.49 232.1,86.58 232.11,86.57 232.11,85.19
12V_G1 on TOP: 184.16,59.64 184.16,60.58 184.28,60.71 188.35,60.71 188.37,60.68 188.37,59.34 188.25,59.21 183.95,59.21 183.93,59.24 183.24,59.24 183.24,59.44 183.95,59.44
12V_G1 on TOP: 198.48,60.1 198.48,58.96 198.61,58.83 198.61,57.66 198.53,57.58 195.87,57.58 195.56,57.89 195.56,58.83 195.51,58.88 193.58,58.88 193.2,59.26 193.2,61.17 194.62,61.17 194.62,60.96 197.62,60.96
12V_G1 on BOTTOM: 197.22,67.62 199.7,67.62 201.38,65.94 201.38,58.1 201.15,57.86 196.35,57.86 196.02,58.19 196.02,59.44 196.17,59.59 196.76,59.59 196.96,59.79 196.96,63.25 196.63,63.58 196.22,63.58 195.94,63.86 195.94,64.87 196.17,65.1 196.17,66.58 196.25,66.65 196.76,66.65 196.92,66.82 196.92,67.32
12V_G1 on BOTTOM: 183.27,59.74 183.27,59.08 185.41,56.94 185.41,56.27 185.57,56.11 188.46,56.11 188.66,56.3 188.66,59.11 188.65,59.11 188.65,60.57 188.51,60.71 188.43,60.71 188.42,60.71 188.4,60.73 184.26,60.73
12V_G1 on BOTTOM: 170.81,51.65 170.95,51.79 170.95,60.56 171.03,60.63 171.03,73.71 170.42,74.32 170.42,80.02 171.14,80.75 171.14,89.16 171.21,89.23 173.11,89.23 173.31,89.03 173.31,87.15 172.93,86.77 172.93,80.27 174.07,79.12 174.07,76.25 172.93,75.11 172.93,67.67 174.78,65.81 174.78,58.52 174.15,57.89 174.15,38.48 175.09,37.54 175.09,31.65 174.51,31.07 170.34,31.07 170.11,31.3 170.11,35.41 171.2,36.5 171.2,44.43 170.81,44.82
12V_G1 on BOTTOM: 233.31,86.44 232.42,86.44 230.77,84.79 230.77,68.53 231.15,68.15 237.37,68.15 237.88,68.66 237.88,71.63 236.76,72.75 236.76,75.31 237.88,76.43 237.88,81.74 237.37,82.25 235.34,82.25 234.32,83.26 234.32,85.42
12V_G1 on BOTTOM: 196.93,106.45 196.93,94.62 197.06,94.49 198.25,94.49 198.48,94.72 198.48,106.45 198.36,106.58 197.06,106.58
12V_G1 on L05_SIG2: 226.96,58.85 226.96,63.2 232.16,68.4 236.86,68.4 237.05,68.6 237.05,77.99 237.88,78.82 237.88,85.8 236.52,87.16 232.61,87.16 231.91,86.47 231.91,84.52 229.45,82.05 211.78,82.05 211.07,81.34 211.07,74.06 209.83,72.82 196.94,72.82 196.38,72.26 196.38,68.18 194.55,66.35 180.83,66.35 178.97,64.49 178.97,57.39 178.56,56.98 175.73,56.98 174.2,58.51 171.76,58.51 171.3,58.05 171.3,33.3 172.31,32.29 174.79,32.29 175.29,32.79 175.29,37.62 177.3,39.63 177.3,39.63 181.86,44.19 183.27,44.19 184.57,42.89 189.76,42.89 191.17,44.3 191.17,56.28 192.61,57.73 225.83,57.73
12V_G1 on L12_SIG4: 192.92,90.12 196.16,93.36 196.16,106.26 196.7,106.81 198.45,106.81 198.68,106.59 198.68,98.2 199.09,97.79 199.09,95.28 200.31,94.06 233.56,94.06 234.2,93.42 234.2,82.88 234.96,82.12 248.8,82.12 250.96,79.96 250.96,26.88 250.07,25.99 245.63,25.99 243.47,28.15 243.47,31.96 246.26,34.75 246.26,70.18 244.61,71.83 239.91,71.83 236.84,68.76 218.98,68.76 214.36,73.38 206.76,73.38 205.67,72.29 176.16,72.29 171.08,77.37 171.08,83.39 171.1,83.42 171.1,88.85 172.4,90.15 175.85,90.15 176.33,89.66 176.79,90.12
12V_G1 on L14_SIG5: 180.6,65.74 180.6,70.94 181.36,71.71 202.57,71.71 204.22,70.06 213.75,70.06 215.02,71.33 235.21,71.33 237.88,73.99 237.88,86.06 236.94,87 232.42,87 230.77,85.35 230.77,82.88 230.26,82.37 217.05,82.37 216.54,82.88 202.28,82.88 196.52,88.65 177.24,88.65 174.87,86.28 169.79,86.28 169.32,85.8 169.32,72.53 168.03,71.24 168.03,66.12 168.92,65.23 180.09,65.23
12V_G2 on TOP (solid shape): 207.96,45.27 208.59,45.27 208.64,45.32 209.15,45.32 210.07,44.4 210.57,44.4 210.83,44.15 210.83,42.75 210.57,42.5 208.67,42.5 208.41,42.75 208.41,43.06 206.69,44.78 205.37,44.78 205.11,44.53 205.11,44.15 204.99,44.02 203.97,44.02 203.87,44.12 203.87,45.09 204.2,45.42 207.8,45.42
12V_G2 on TOP (solid shape): 34.58,102.14 34.7,102.01 35.24,102.01 35.53,101.73 35.55,101.71 35.6,101.67 35.65,101.64 35.71,101.63 35.76,101.62 35.79,101.62 36.67,101.62 36.7,101.61 36.75,101.6 36.77,101.6 37.24,101.6 37.24,100.89 36.77,100.89 36.74,100.89 36.67,100.88 36.64,100.87 36.48,100.87 35.59,99.98 33.99,99.98 33.99,100 32.42,100 32.42,102.14 34.32,102.14 34.32,102.39 33.94,102.39 33.94,102.14 32.42,102.14 32.42,102.39 32.67,102.64 34.58,102.64
12V_G2 on TOP (solid shape): 44.57,101.95 44.61,101.95 45.12,101.95 45.15,101.95 45.2,101.96 45.68,101.96 45.68,100.03 45.65,100 44.05,100 44.05,99.98 42.45,99.98 41.56,100.87 41.34,100.89 41.27,100.89 40.8,100.89 40.8,101.6 41.27,101.6 41.32,101.61 41.37,101.62 41.7,101.62 41.75,101.62 41.82,101.63 41.91,101.68 41.97,101.73 42.2,101.96 44.53,101.96
12V_G2 on TOP (solid shape): 59.47,101.78 59.47,100.26 59.27,100.05 58.12,100.05 58.12,100.03 56.01,100.03 55.69,100.36 55.7,100.38 55.73,100.46 55.73,100.55 55.62,100.83 55.34,100.94 55.18,100.94 55.03,101.09 54.64,101.09 54.64,101.68 54.7,101.68 54.77,101.66 54.83,101.65 55.34,101.65 55.39,101.66 55.44,101.67 55.77,101.67 55.92,101.7 56.04,101.78 56.27,102.01 59.24,102.01
12V_G2 on TOP (solid shape): 48.72,102.82 48.71,102.82 48.71,102.31 48.74,102.31 48.74,102.2 49.26,101.68 49.77,101.68 49.8,101.67 49.84,101.67 49.87,101.67 50.75,101.67 50.77,101.66 50.82,101.65 50.85,101.65 51.35,101.65 51.39,101.65 51.42,101.65 51.44,101.63 51.46,101.61 51.47,101.58 51.47,101.57 51.47,101.03 51.47,101.02 51.46,100.99 51.44,100.97 51.42,100.95 51.39,100.94 51.35,100.94 50.85,100.94 50.81,100.94 50.75,100.93 50.71,100.92 50.43,100.92 49.54,100.03 48.06,100.03 48.06,100.05 46.44,100.05 46.44,100.03 45.83,100.03 45.83,102.19 47.89,102.19 47.89,102.44 47.51,102.44 47.51,102.19 45.83,102.19 45.83,102.59 46.18,102.95 48.6,102.95
12V_G2 on BOTTOM (solid shape): 59.44,101.75 59.44,100.28 59.19,100.03 56.27,100.03 56.01,100.28 56.01,101.74 56.26,101.99 59.2,101.99
12V_G2 on TOP: 182.73,19.71 182.73,21.64 183.01,21.92 183.01,22.81 183.37,23.17 185.43,23.17 185.6,22.99 185.6,20.25 185.96,19.89 185.96,19.54 185.99,19.51 186.6,19.51 186.65,19.56 186.65,21.69 186.82,21.87 186.82,23.02 187.1,23.29 189.11,23.29 189.47,22.94 189.47,19.94 189.8,19.61 190.35,19.61 190.35,21.72 190.68,22.05 190.68,22.91 190.96,23.19 191.68,23.19 191.93,22.94 191.93,22.13 192.13,21.92 193.07,21.92 193.3,21.69 193.3,20.14 193.89,19.56 195.79,19.56 196.02,19.79 196.02,25.28 195.46,25.83 182.1,25.83 181.77,25.5 181.77,23.22 181.82,23.17 181.82,21.34 182.18,20.98 182.18,19.71 182.23,19.66 182.68,19.66
12V_G2 on TOP: 63.05,76.13 63.05,75.39 63.43,75.01 69.58,75.01 70.64,76.08 72.88,76.08 73.06,75.9 73.06,75.34 73.29,75.11 78.16,75.11 78.24,75.19 78.24,76.05 77.32,76.96 72.19,76.96 71.76,77.4 69.27,77.4 68.84,76.96 63.89,76.96
12V_G2 on TOP: 68.36,88.83 74.64,88.83 74.96,89.14 74.96,90.71 74.16,91.5 66.78,91.5 66.25,90.96 66.25,87.26 67.34,86.17 67.78,86.17 68.09,86.47 68.09,88.53 68.08,88.54
12V_G2 on TOP: 231.71,43.67 230.77,43.67 230.49,43.94 226.04,43.94 225.58,43.49 225.58,41.38 226.07,40.9 228.56,40.9 228.71,41.05 228.71,42.04 229.47,42.8 231.71,42.8 231.86,42.95 231.86,43.51
12V_G2 on TOP: 66.1,55.37 66.1,56.5 68.82,56.5 68.82,55.4 68.99,55.22 70.01,55.22 70.16,55.37 70.16,57.01 70.6,57.45 72.68,57.45 72.8,57.33 72.8,55.3 72.91,55.2 73.51,55.2 73.74,55.43 73.74,57.48 76.33,57.48 76.64,57.18 76.64,55.17 77.55,55.17 77.58,55.2 77.58,57.56 77.55,57.58 77.55,58.47 77.4,58.63 76.77,58.63 76.03,57.89 73.9,57.89 73.74,58.04 73.74,58.52 73.59,58.68 72.88,58.68 72.8,58.6 72.8,58.17 72.5,57.86 70.5,57.86 69.96,58.41 69.96,58.55 69.81,58.7 69.12,58.7 69.02,58.6 69.02,58.17 68.71,57.86 66.43,57.86 66.25,58.04 66.25,58.4 66.05,58.6 65.23,58.6 65.11,58.47 65.11,55.37 65.13,55.35 66.07,55.35
12V_G2 on TOP: 204.48,36.91 204.48,37.8 203.59,38.69 203.59,40.08 203.72,40.21 206.38,40.21 206.38,39.7 205.75,39.7 205.62,39.58 205.62,38.31 205.24,37.92 205.24,36.91
12V_G2 on TOP: 235.8,43.67 235.13,43.67 235.03,43.56 235.03,42.88 235.11,42.8 237.04,42.8 237.19,42.65 237.19,42.14 237.32,42.01 238.11,42.01 238.54,41.58 238.54,40.06 243.42,40.06 243.42,42.95 241.99,44.38 237.73,44.38 237.52,44.17 236.3,44.17
12V_G2 on TOP: 233.94,64.85 236.35,64.85 236.61,64.59 242.2,64.59 242.45,64.85 242.45,67.26 242.2,67.52 233.94,67.52 233.69,67.26 233.69,65.1
12V_G2 on TOP: 202.06,52.4 203.08,52.4 203.21,52.53 203.21,53.04 203.33,53.16 204.99,53.16 206.99,51.16 206.99,50.4 207.17,50.22 209.33,50.22 209.33,52.76 209.13,52.96 206.97,52.96 206.13,53.8 202.32,53.8 201.94,53.42 201.94,52.53
12V_G2 on TOP: 204.48,33.61 204.48,32.72 203.59,31.83 203.59,28.53 205.49,28.53 205.75,28.78 205.75,31.83 205.24,32.34 205.24,33.61
12V_G2 on TOP: 205.47,22.86 205.47,21.85 205.62,21.69 208.54,21.69 208.77,21.47 209.2,21.47 209.43,21.69 209.43,23.07 209.38,23.12 205.72,23.12
12V_G2 on TOP: 204.03,101.46 204.03,98.91 204.37,98.57 213.16,98.57 213.66,99.07 213.66,99.62 213.83,99.79 214.8,99.79 214.95,99.64 214.95,99.15 215.53,98.57 221.54,98.57 221.77,98.8 221.77,101.6 221.26,102.11 218.82,102.11 218.11,101.4 216.44,101.4 215.73,102.11 215.28,102.11 214.56,101.39 212.54,101.39 211.82,102.11 211.17,102.11 210.45,101.4 208.61,101.4 207.9,102.11 207.63,102.11 206.89,101.38 205.04,101.38 204.66,101.76 204.33,101.76
12V_G2 on TOP: 71.02,33.3 71.02,35.52 71.2,35.71 71.45,35.71 71.53,35.62 71.53,34.48 71.84,34.16 73.92,34.16 74.17,34.42 74.17,39.69 73.94,39.93 71.89,39.93 71.65,39.68 71.65,38.59 71.42,38.36 71.08,38.36 70.88,38.56 70.88,39.85 70.67,40.06 70.67,40.97 70.93,41.23 75.12,41.23 75.87,40.49 75.87,33.94 75.11,33.18 71.14,33.18
12V_G2 on TOP: 193.86,88.32 193.86,83.42 195.05,83.42 195.33,83.14 195.33,78.36 194.9,77.93 193.99,77.93 193.86,77.8 193.86,73.69 194.7,72.85 197.01,72.85 197.42,73.26 197.42,77.4 197.8,77.78 197.8,77.8 200.08,77.8 200.36,78.08 200.36,84.08 200.62,84.33 204.83,84.33 205.57,83.59 205.57,76.53 207.37,74.73 209.48,74.73 210.4,75.64 211.03,75.64 211.26,75.87 211.26,75.92 211.7,76.37 211.7,78 211.03,78.67 210.78,78.67 210.7,78.74 210.7,79.43 210.8,79.53 212.1,79.53 212.1,82.92 211.36,83.66 210.8,83.66 210.27,84.19 210.27,85.02 209.66,85.63 203.72,85.63 203.41,85.93 203.41,90.96 203.33,91.04 199.83,91.04 199.8,91.01 199.8,84.51 199.7,84.41 197.64,84.41 197.42,84.18 196.2,84.18 196.17,84.2 196.17,85.58 196.22,85.63 196.98,85.63 197.21,85.85 197.21,88.22 197.24,88.24 196.6,88.88 194.42,88.88
12V_G2 on BOTTOM: 205.49,31.7 204.1,31.7 203.9,31.51 203.9,24.83 205.44,23.3 205.44,21.85 205.54,21.75 207.47,21.75 207.74,22.01 208.19,22.01 208.39,21.82 209.63,21.82 210.14,22.33 210.14,24.55 209.76,24.93 205.86,24.93 205.82,24.89 205.52,25.19 205.52,28.1 205.75,28.32 205.75,31.45
12V_G2 on BOTTOM: 61.32,75.72 61.83,75.21 66.63,75.21 67.01,74.83 75.6,74.83 75.98,75.21 76.74,75.21 77.12,74.83 80.12,74.83 80.27,74.98 80.27,76.81 79.48,77.6 67.8,77.6 67.79,77.61 67.41,77.61 67.16,77.85 67.16,79.15 66.94,79.38 61.68,79.38 61.32,79.02
12V_G2 on BOTTOM: 185.94,21.08 186.52,21.08 186.65,21.21 186.65,22.71 186.52,22.84 185.94,22.84 185.81,22.71 185.81,21.21
12V_G2 on BOTTOM: 74.61,88.95 71.79,88.95 71.74,89 71.74,89.82 71.13,90.43 69.76,90.43 69.55,90.63 69.55,92.43 69.68,92.56 72.73,92.56 72.98,92.31 72.98,91.06 73.84,90.2 74.63,90.2 74.78,90.05 74.78,89.13
12V_G2 on BOTTOM: 70.84,35.6 70.84,34.42 70.37,33.95 70.37,32.09 70.54,31.92 71.69,31.92 71.91,32.15 71.91,34.08 71.58,34.41 71.58,35.55 71.42,35.71 70.94,35.71
12V_G2 on BOTTOM: 192.21,21.24 192.97,21.24 193.35,21.62 193.35,22.99 193.43,23.07 194.8,23.07 194.95,22.91 194.95,20.09 194.57,19.71 192.13,19.71 192.06,19.79 192.06,21.08
12V_G2 on BOTTOM: 189.82,19.56 190.33,19.56 190.46,19.69 190.46,22.71 190.33,22.84 189.82,22.84 189.69,22.71 189.69,19.69
12V_G2 on BOTTOM: 207.02,52.15 210.32,52.15 210.83,51.64 211.97,51.64 213.88,49.73 213.88,41.85 213.53,41.51 208.5,41.51 208.29,41.29 208.29,39.45 208.13,39.3 207.37,39.3 206.92,38.84 206.92,37.26 206.84,37.19 203.89,37.19 203.56,36.86 200.82,36.86 200.74,36.93 200.74,39.68 200.97,39.91 203.3,39.91 203.6,40.21 206,40.21 206.38,40.59 206.92,40.59 206.99,40.67 206.99,42.37 207.14,42.52 207.47,42.52 207.68,42.73 207.68,44.4 208.21,44.94 209.8,44.94 211.12,43.62 211.84,43.62 212.41,44.19 212.41,46.02 210.55,47.88 210.55,50.14 210.32,50.37 207.12,50.37 206.84,50.65 206.84,51.97
12V_G2 on BOTTOM: 71.72,38.21 71.72,39.66 71.94,39.88 71.94,41.68 71.89,41.73 70.67,41.73 70.5,41.56 70.5,39.95 70.93,39.53 70.93,38.21
12V_G2 on BOTTOM: 236.4,44.17 236.4,43.18 236.56,43.03 238.23,43.03 238.54,42.73 238.54,40.06 243.49,40.06 243.49,42.88 242.04,44.33 236.56,44.33
12V_G2 on BOTTOM: 42.31,101.55 42.31,100.21 42.58,99.94 48.65,99.94 49.35,100.64 49.35,101.75 48.65,102.45 44.84,102.45 44.37,101.98 42.74,101.98
12V_G2 on BOTTOM: 239.76,53.98 242.58,53.98 242.58,51.44 239.76,51.44
12V_G2 on BOTTOM: 182.99,21.58 182.99,22.86 182.86,22.99 181.9,22.99 181.77,22.86 181.77,21.75 181.51,21.5 181.51,19.77 181.54,19.74 183.32,19.74 183.35,19.78 183.35,21.22
12V_G2 on BOTTOM: 204.06,100.82 204.06,99.34 204.56,98.84 221.29,98.84 221.29,98.86 221.73,99.29 221.73,101.53 220.95,102.31 207.6,102.31 207.27,101.97 207.27,101.25 207.17,101.15 204.4,101.15
12V_G2 on BOTTOM: 194.14,87.79 194.14,82.96 195.71,82.96 196.02,82.65 196.02,81.21 195.87,81.05 195.18,81.05 194.95,80.83 194.95,80.37 194.88,80.29 194.14,80.29 194.14,73.41 194.7,72.85 196.2,72.85 196.27,72.93 196.27,75.34 196.5,75.57 199.55,75.57 199.78,75.8 199.78,77.35 200.44,78.01 200.44,86.62 200.82,87 206.61,87 206.69,86.92 206.69,74.63 206.99,74.32 209.81,74.32 210.09,74.6 210.09,82.48 211.03,83.42 211.87,83.42 211.94,83.49 211.94,83.77 211.89,83.82 210.78,83.82 210.09,84.51 210.09,87.71 209.89,87.91 207.02,87.91 206.79,88.14 199.68,88.14 199.45,87.91 199.45,86.06 199.27,85.88 196.7,85.88 196.7,87.84 196.4,88.14 194.49,88.14
12V_G2 on BOTTOM: 31.88,102.47 31.88,99.72 32.04,99.57 35.16,99.57 35.39,99.8 35.39,102.39 35.08,102.69 32.11,102.69
12V_G2 on BOTTOM: 242.2,64.59 242.45,64.85 242.45,67.21 241.94,67.72 233.33,67.72 233.08,67.47 233.08,66.32 233.28,66.12 234.04,66.12 234.27,65.89 234.27,64.9 236.18,64.9 236.48,64.59
12V_G2 on L05_SIG2: 192.67,36.91 192.67,33.78 193.58,32.87 201.3,32.87 204.08,30.1 242.15,30.1 243.09,31.04 243.09,66.91 242.12,67.87 233.28,67.87 227.97,62.56 227.97,57.87 225.87,55.76 194.35,55.76 191.19,52.61 191.19,49.05 191.21,49.04 191.21,38.37 ; 2 cut-outs
12V_G2 on L05_SIG2: 194.08,73.17 209.42,73.17 210.42,74.17 210.42,86.39 210.09,86.72 203.42,86.72 201.76,88.37 194.26,88.37 193.69,87.8 193.69,73.55
12V_G2 on L07_SIG3: 222.38,93.53 222.38,73.99 219.28,70.89 219.28,52.86 216.88,50.45 213.39,50.45 212.58,51.26 210.46,51.26 210.04,50.84 210.04,48.75 211.59,47.2 220.35,47.2 221.88,48.72 242.32,48.72 242.35,48.75 242.35,53.24 241.21,54.38 231.1,54.38 230.64,54.84 230.64,61.04 231.02,61.42 232.42,61.42 232.93,60.91 232.93,58.37 233.81,57.48 242.58,57.48 244.1,59.01 244.1,101.55 240.44,105.21 214.31,105.21 214.27,105.17 205.45,105.17 204.07,103.79 204.07,96.18 205.72,94.53 221.38,94.53
12V_G2 on L09_PWR1: 252.74,110.06 252.74,14.05 243.72,14.05 242.96,14.81 242.96,31.83 242.17,32.62 242.17,49.84 240.65,51.36 240.65,57.53 236.23,61.95 236.23,76.02 234.45,77.8 205.11,77.8 204.86,78.06 204.86,90.38 204.28,90.95 204.28,100.32 204.4,100.44 207.21,100.44 207.51,100.74 207.51,101.97 207.7,102.16 218.46,102.16 218.96,102.66 218.96,106.49 218.56,106.89 204.46,106.89 203.27,108.07 198.9,108.07 197.87,107.05 89.92,107.05 89.26,106.38 89.26,100.06 89.15,99.95 79.42,99.95 79.42,99.95 36.02,99.95 35.65,99.58 32.74,99.58 32.22,100.09 32.22,109.53 32.76,110.06
12V_G2 on L10_PWR2: outline of 91 points within 31.81,14.05 252.74,110.06
12V_G2 on L12_SIG4: 210.62,30.94 209.68,30 209.68,21.84 209.28,21.45 207.74,21.45 207.3,21.88 205.2,21.88 202.52,19.2 180.21,19.2 179.79,19.62 179.79,25.45 181.92,27.59 192.11,27.59 193.38,28.86 198.36,28.86 199.27,29.77 199.27,33.34 195.01,37.6 195.01,49.76 193.4,51.37 193.4,53.36 195.42,55.38 206.32,55.38 210.62,51.08
12V_GROUP1 on TOP (solid shape): 230.15,82.83 228.05,82.83 228.05,86.23 230.15,86.23
12V_GROUP1 on TOP (solid shape): 231.45,88.68 228.05,88.68 228.05,90.78 231.45,90.78
12V_GROUP1 on L14_SIG5 (solid shape): outline of 976 points within 212.35,73.1 244.23,92.43
12V_GROUP1 on TOP: 218,82.76 218.13,82.63 230,82.63 230.15,82.78 230.15,86.46 231.4,87.71 231.4,90.38 231.02,90.76 226.91,90.76 226.83,90.83 226.83,91.39 226.14,91.39 226.14,90.83 225.94,90.63 224.14,90.63 223.98,90.78 223.98,91.39 223.27,91.39 223.27,90.81 223.1,90.63 213.7,90.63 213.24,90.17 213.24,87.58 213.62,87.58 213.62,89.49 213.75,89.61 214.38,89.61 214.51,89.49 214.51,87.58 214.89,87.58 214.89,89.49 215.02,89.61 217.68,89.61 218,89.29
12V_GROUP1 on BOTTOM: 218.07,83.26 218.7,82.63 229.75,82.63 230,82.88 230,86.31 230.89,87.2 230.89,90.38 230.64,90.63 218.32,90.63 218.07,90.38
12V_GROUP2 on TOP (solid shape): 214.81,78.39 212.71,78.39 212.71,81.79 214.81,81.79
12V_GROUP2 on TOP (solid shape): 214.81,72.17 212.71,72.17 212.71,75.57 214.81,75.57
12V_GROUP2 on TOP: 213.11,82.12 214.51,82.12 215.15,82.76 215.15,84.81 215.25,84.91 215.81,84.91 215.91,84.81 215.91,82.63 216.42,82.12 221.62,82.12 222.13,81.61 222.13,70.61 221.86,70.35 213.59,70.35 213.11,70.83 213.11,71.71 212.73,72.09 212.73,81.74
12V_GROUP2 on BOTTOM: 218.07,81.87 221.75,81.87 222.13,81.49 222.13,72.09 221.88,71.83 220.23,71.83 218.45,70.06 211.13,70.06 210.95,70.23 210.95,71.33 211.67,71.33 211.67,70.82 211.79,70.69 213.6,70.69 213.8,70.89 213.8,71.33 214.76,71.33 215.02,71.58 215.02,72.34 214.64,72.72 212.99,72.72 212.86,72.85 212.86,82.25 213.11,82.5 213.11,83.26 214,83.26 214.13,83.14 214.13,82.12 214.38,81.87 215.53,81.87 215.78,82.12 215.78,83.77 217.56,83.77 217.56,82.37 ; 1 cut-out
12V_GROUP2 on L03_SIG1: 214.84,81.64 216.21,80.27 221.95,80.27 222.13,80.09 222.13,72.21 221.88,71.96 213.11,71.96 210.95,74.12 210.95,86.63 211.28,86.95 212.03,86.95 213.15,85.83 214.44,85.83 214.84,85.43
AGND_1P8V_PRE on TOP: 12.62,38.13 12.4,38.35 12.4,40.08 12.6,40.28 14.23,40.28 14.46,40.05 14.46,38.36 14.23,38.13
GND on TOP (solid shape): 40.16,100.61 40.68,100.61 40.72,100.61 40.76,100.6 41.27,100.6 41.31,100.61 42.45,99.47 44.05,99.47 44.05,99.44 45.63,99.44 45.63,94.9 40.77,94.9 40.77,95.41 41.94,95.41 42.45,95.91 42.45,98.2 41.31,99.34 41.15,99.34 41.08,99.37 41.02,99.38 40.77,99.38 40.55,99.6 37.5,99.6 37.28,99.38 37.02,99.38 36.96,99.37 36.89,99.34 36.74,99.34 35.59,98.2 35.59,95.91 35.92,95.59 35.9,95.52 35.9,95.47 35.99,95.24 36.23,95.14 36.42,95.2 36.54,95.37 36.55,95.41 37.27,95.41 37.27,94.9 32.42,94.9 32.42,99.44 33.99,99.44 33.99,99.47 35.59,99.47 36.73,100.61 36.77,100.6 37.28,100.6 37.32,100.61 37.36,100.61 37.88,100.61 37.88,102.9 40.16,102.9
GND on TOP (solid shape): outline of 81 points within 196.73,43 206.76,48.85
GND on TOP (solid shape): outline of 209 points within 45.98,94.95 59.19,102.95
GND on BOTTOM (solid shape): 157.18,21.72 157.18,20.7 157.05,20.58 156.04,20.58 155.91,20.7 155.91,21.72 156.04,21.85 157.05,21.85
GND on BOTTOM (solid shape): outline of 123 points within 32.27,94.92 59.19,102.92
GND on TOP: 231.68,63.22 233.59,63.22 233.97,63.6 233.97,64.21 234.3,64.54 236.23,64.54 236.56,64.21 242.27,64.21 242.45,64.04 242.45,60.35 242.35,60.25 237.78,60.25 236.07,61.95 231.68,61.95 231.45,62.18 231.45,62.99
GND on TOP: outline of 82 points within 180.58,13.77 196.43,23.19
GND on TOP: outline of 94 points within 162.64,29.92 171.41,92.87
GND on TOP: 236.79,38.48 236.79,37.77 237.12,37.44 237.12,36.58 237.09,36.55 237.09,36.25 237.24,36.1 237.62,36.1 237.95,36.43 237.95,38.43 237.85,38.53 236.84,38.53
GND on TOP: 60.75,38.01 60.75,37.32 61.02,37.05 61.84,37.05 61.95,37.16 61.95,37.33 61.59,37.68 61.59,37.98 61.51,38.06 60.8,38.06
GND on TOP: 58.55,88.98 58.81,88.72 58.81,83.47 56.09,83.47 56.09,79.02 58.81,79.02 58.81,73.36 58.55,73.1 45.85,73.1 45.55,73.41 45.55,88.68 45.85,88.98 ; 3 cut-outs
GND on TOP: 214.89,38.43 214.89,16.46 215.02,16.33 222.64,16.33 222.89,16.59 222.89,33.28 222.74,33.43 222.74,38.43 222.75,38.45 222.64,38.56 215.02,38.56
GND on TOP: 18.7,42.32 18.32,42.32 18.07,42.07 18.07,41.02 17.79,40.74 17.79,38.53 17.91,38.41 20.17,38.41 20.3,38.53 20.3,43.74 20.12,43.92 19.08,43.92 19.01,43.84 19.01,42.62
GND on TOP: outline of 89 points within 174,70.49 204.73,91.07
GND on TOP: 201.12,40.67 201.58,40.21 202.83,40.21 203.08,39.96 203.08,38.69 204.22,37.54 204.22,36.4 206.51,36.4 206.51,34.11 204.22,34.11 204.22,32.97 203.08,31.83 203.08,28.98 202.95,28.86 199.68,28.86 199.22,29.31 199.22,32.51 199.6,32.9 202.8,32.9 202.95,33.05 202.95,33.61 203.21,33.86 203.21,36.65 202.95,36.91 202.95,37.16 202.34,37.77 199.22,37.77 199.22,40.52 199.37,40.67
GND on TOP: 29.95,41.99 29.95,41.13 29.67,40.85 29.67,39.02 29.87,38.83 31.99,38.83 32.19,39.02 32.19,43.34 31.96,43.56 31.31,43.56 31.19,43.45 31.19,42.64 30.7,42.14 30.1,42.14
GND on TOP: 183.14,63.1 184.16,63.1 184.44,63.38 184.44,63.78 188.4,63.78 188.55,63.63 188.55,62.56 188.48,62.49 183.78,62.49 183.7,62.41 183.17,62.41 183.12,62.46 183.12,63.07
GND on TOP: 78.26,75.03 78.39,74.91 78.39,66.45 78.11,66.17 73.29,66.17 73.13,66.02 73.13,65.31 72.78,64.95 68.46,64.95 68.26,65.15 68.26,65.97 68.13,66.09 63.25,66.09 63.1,66.25 63.1,74.68 63.23,74.81 69.73,74.81 70.9,75.97 72.91,75.97 72.94,75.94 72.94,75.3 73.21,75.03 76.33,75.03 76.67,74.7 77.39,74.7 77.73,75.03
GND on TOP: 45.55,48.64 45.55,63.91 45.83,64.19 58.55,64.19 58.81,63.93 58.81,58.68 56.09,58.68 56.09,54.23 58.81,54.23 58.81,48.57 58.55,48.31 45.88,48.31 ; 3 cut-outs
GND on TOP: 175.67,13.92 175.67,25.67 175.71,25.72 176.55,25.72 176.69,25.58 176.69,23.36 177.44,22.6 177.44,13.92
GND on TOP: 182.75,67.53 182.45,67.53 182.3,67.38 182.3,66.57 182.49,66.38 182.49,65.55 182.48,65.54 182.53,65.49 183.13,65.49 183.22,65.58 183.22,66.35 182.88,66.69 182.88,67.4
GND on TOP: outline of 99 points within 62.82,52.12 78.44,63.15
GND on TOP: 71.14,83.48 71.14,84.61 71.34,84.81 72.14,84.81 72.63,85.3 72.63,85.71 73.06,86.14 74.73,86.14 75.92,87.34 75.92,89.03 75.64,89.31 75.49,89.31 74.58,88.41 69.17,88.41 68.79,88.02 68.79,84.26 69.78,83.27 70.93,83.27
GND on TOP: 24.3,104.94 26.08,104.94 26.08,103.8 26.33,103.8 26.33,104.94 27.35,104.94 27.58,104.71 30.68,104.71 30.91,104.94 30.91,109 30.65,109.26 28.04,109.26 27.99,109.21 27.99,108.6 29.43,108.6 29.74,108.29 29.74,107.38 29.59,107.23 27.83,107.23 27.6,107 27.6,106.72 27.35,106.46 25.83,106.46 25.83,107.61 25.57,107.61 25.57,106.46 23.29,106.46 23.13,106.62 20.87,106.62 20.82,106.57 20.82,105.6 20.9,105.52 23.29,105.52 23.54,105.27 23.54,104.69 24.05,104.69
GND on TOP: 207.53,103.32 209.31,103.32 209.9,102.74 210.84,102.74 211.43,103.32 213.02,103.32 213.71,102.63 214.59,102.63 215.28,103.32 216.12,103.32 216.79,102.64 218.48,102.64 218.94,103.1 218.94,105.62 218.36,106.2 208.42,106.2 207.6,105.38 205.95,105.38 205.85,105.48 205.85,107.59 206.81,108.55 218.8,108.55 220.1,107.25 220.1,102.84 219.58,102.32 218.74,102.32 218.01,101.59 218.01,101.59 216.48,101.59 215.86,102.21 214.96,102.21 214.31,101.55 212.62,101.55 211.91,102.26 211.16,102.26 210.43,101.53 208.67,101.53 207.4,102.79 207.4,103.19
GND on TOP: 214.89,67.13 214.89,45.16 215.02,45.04 222.64,45.04 222.89,45.29 222.89,67.01 222.64,67.26 215.02,67.26
GND on TOP: 191.83,61.88 191.7,62 189.59,62 189.47,61.88 189.47,59.47 188.74,58.75 186.31,58.75 186.28,58.72 186.28,57.96 186.39,57.84 186.39,56.83 186.44,56.78 189.34,56.78 190.63,58.07 191.63,58.07 191.83,58.28
GND on TOP: 200.41,56.54 200.41,54.82 200.54,54.69 200.84,54.69 201.15,54.38 201.15,52.66 200.36,51.87 200.36,51.59 200.44,51.51 200.67,51.51 201.68,52.53 201.68,53.55 202.19,54.05 203.97,54.05 205.24,55.32 205.59,55.32 205.65,55.37 205.65,56.59 205.85,56.8 207.19,56.8 207.4,56.59 207.4,55.07 207.07,54.74 205.75,54.74 205.75,54.21 206.31,54.21 206.59,53.93 207.17,53.93 207.37,53.72 207.37,53.39 207.5,53.27 209.48,53.27 209.51,53.29 209.51,54.43 209.18,54.77 209.18,54.94 209.18,57.74 208.8,58.12 208.8,58.83 208.64,58.98 202.85,58.98 ; 2 cut-outs
GND on TOP: 67.79,41.3 67.48,41 67.48,33.63 67.87,33.24 70.41,33.24 70.78,33.62 70.78,35.58 71.04,35.84 71.65,35.84 71.85,35.64 71.85,34.5 71.94,34.41 73.44,34.41 73.51,34.48 73.51,39.36 73.22,39.65 72.2,39.65 72.08,39.53 72.08,38.43 71.86,38.21 71.01,38.21 70.8,38.42 70.8,39.74 70.57,39.98 70.57,41.1 70.37,41.3
GND on TOP: 190.68,54.31 191.98,54.31 192.06,54.38 192.06,56.29 192.21,56.44 195.87,56.44 196.1,56.21 196.1,55.76 196.17,55.68 197.85,55.68 198.08,55.91 198.08,57.05 198,57.13 190.76,57.13 190.53,56.9 190.53,54.46
GND on TOP: 232.19,43.54 232.19,41.51 234.65,41.51 234.65,43.56 234.91,43.82 235.74,43.82 236.56,44.63 237.57,44.63 237.8,44.86 239.94,44.86 243.11,48.03 243.11,52.08 244.17,53.14 244.17,56.45 243.99,56.62 239.73,56.62 239.45,56.34 239.45,54 238.69,53.24 238.69,50.57 238.39,50.27 238.39,47.96 235.52,45.09 234.73,45.09 234.6,44.96 232.26,44.96 232.15,45.08 232,45.08 231.91,45.16 230.84,45.16 230.61,45.39 230.61,46.61 228.25,48.97 228.25,50.19 228.11,50.33 228.11,53.18 227.44,53.85 227.44,56.21 226.98,56.67 224.06,56.67 223.68,56.29 223.68,46.87 226.14,44.4 230.56,44.4 231.15,43.82 231.91,43.82
GND on TOP: 7.88,42.95 7.88,42.22 7.68,42.01 6.92,42.01 6.71,41.81 6.71,38.79 7.07,38.43 9.07,38.43 9.15,38.51 9.15,43 9.04,43.12 8.05,43.12
GND on TOP: 223.27,82.12 229.75,82.12 230,81.87 230,68.66 229.62,68.28 223.02,68.28 222.77,68.53 222.77,81.61
GND on TOP: 68.09,50.86 68.09,48.99 71.36,48.99 71.36,50.86
GND on TOP: 178.59,53.62 178.59,52.61 178.81,52.39 185.41,52.39 185.81,52 185.81,49 185.94,48.87 185.94,43.26 185.66,42.98 183.85,42.98 183.42,42.55 183.42,41 184.03,40.39 184.61,40.39 184.74,40.26 184.74,39.53 185.12,39.14 185.66,39.14 186.04,38.76 186.04,33.12 186.16,33 189.11,33 189.64,32.46 189.64,27.49 189.19,27.03 178.75,27.03 178.57,27.21 178.57,30.84 178.34,31.07 175.7,31.07 175.34,30.71 175.34,28.02 177.12,26.24 194.42,26.24 194.8,26.62 194.8,37.7 194.55,37.95 188.42,37.95 187.99,38.38 187.99,43.06 188.4,43.46 191.98,43.46 194.22,45.7 194.22,48.21 193.48,48.95 191.09,48.95 190.46,49.58 190.46,53.32 189.49,54.28 179.25,54.28
GND on TOP: 204.33,98.48 204.33,96.01 204.93,95.41 208.55,95.41 209.4,94.56 221.38,94.56 222.07,95.26 222.07,98.14 221.82,98.4 215.24,98.4 214.7,98.93 214.7,99.42 214.59,99.53 213.92,99.53 213.8,99.41 213.8,99.03 213.26,98.49 204.34,98.49
GND on TOP: 201.87,23.69 201.87,16.33 200.58,15.05 200.58,15.04 200.26,14.71 200.26,14.1 200.58,13.78 210.05,13.78 210.24,13.97 210.24,14.67 210.21,14.69 210.21,23.77 209.99,23.99 202.23,23.99 201.93,23.69
GND on TOP: 240.04,68.28 243.85,68.28 244,68.43 244,70.92 243.85,71.07 240.04,71.07 239.78,70.82 239.78,68.53
GND on BOTTOM: 192.21,55.83 192.89,55.83 193.5,56.44 195.64,56.44 195.94,56.14 195.94,55.6 196.1,55.45 197.7,55.45 197.85,55.6 197.85,57.2 197.44,57.61 190.63,57.61 190.3,57.28 190.3,54.7 190.85,54.16 191.9,54.16 192.06,54.31 192.06,55.68
GND on BOTTOM: 88.07,63.43 88.88,63.43 89.14,63.68 89.14,64.59 88.88,64.85 88.07,64.85 87.81,64.59 87.81,63.68
GND on BOTTOM: 20.45,29.31 21.37,29.31 21.75,29.7 21.75,30.46 21.83,30.53 22.97,30.53 23.12,30.38 23.12,28.7 22.74,28.32 20.45,28.32 20.3,28.48 20.3,29.16
GND on BOTTOM: 58.68,83.63 58.41,83.35 57,83.35 56.74,83.61 56.74,83.97 56.66,84.05 55.47,84.05 55.47,85.46 55.25,85.68 54.87,85.68 54.74,85.8 54.74,89.11 57.92,89.11 58.68,88.34
GND on BOTTOM: 15.88,25.3 15.88,26.37 15.76,26.49 14.28,26.49 14.21,26.42 14.21,26.27 13.75,26.27 13.75,26.42 13.67,26.49 11.82,26.49 11.82,32.03 11.69,32.16 11.08,32.16 11.08,32.51 15.2,32.51 15.37,32.34 15.37,31.96 15.5,31.83 15.76,31.83 15.88,31.96 15.88,32.36 16.26,32.36 16.26,32.08 18.3,32.08 18.3,31.7 17.66,31.7 17.53,31.57 17.53,26.19 17.28,25.94 16.39,25.94 16.26,25.81 16.26,25.3 ; 3 cut-outs
GND on BOTTOM: 60.33,74.63 60.33,72.67 60.94,72.06 63.15,72.06 63.38,71.83 63.38,66.73 63.58,66.53 69.88,66.53 69.88,66.6 70.11,66.83 72.32,66.83 72.63,66.53 78.77,66.53 79.28,67.03 79.28,73.63 79.16,73.75 71.33,73.75 70.58,74.5 69.55,74.5 69.54,74.51 66.9,74.51 66.63,74.78 60.48,74.78 ; 3 cut-outs
GND on BOTTOM: 87.89,55.96 89.03,55.96 89.11,56.04 89.11,62.64 88.91,62.84 88.02,62.84 87.81,62.64 87.81,56.04
GND on BOTTOM: 105.16,84.79 105.42,85.04 105.42,87.2 105.04,87.58 103.26,87.58 103,87.33 103,85.04 103.26,84.79
GND on BOTTOM: 50.3,57.61 51.95,57.61 52.2,57.86 52.2,61.04 51.57,61.67 49.54,61.67 48.9,61.04 48.9,57.86 49.03,57.74 50.17,57.74
GND on BOTTOM: 51.95,82.37 52.2,82.63 52.2,85.8 51.57,86.44 49.54,86.44 48.9,85.8 48.9,83.14 49.66,82.37
GND on BOTTOM: 88.07,69.24 89.03,69.24 89.29,69.5 89.29,70.08 89.03,70.34 88.07,70.34 87.81,70.08 87.81,69.5
GND on BOTTOM: 64.47,63.2 64.47,61.9 63.02,60.45 63.02,52.35 64.09,51.29 77.68,51.29 79.99,53.59 79.99,59.97 80.72,60.7 80.99,60.7 81.62,61.32 81.62,61.47 81.64,61.5 81.64,63.35 81.59,63.4 64.68,63.4
GND on BOTTOM: 130.06,90 129.8,89.74 129.8,87.9 129.95,87.76 143.68,87.76 143.82,87.9 143.82,89.87 143.69,90
GND on BOTTOM: 179.01,54.47 189.69,54.47 190.49,53.67 190.51,53.67 190.89,53.3 190.89,50.52 192.67,48.75 193.78,48.75 194.22,48.31 194.22,46.54 193.99,46.31 192.89,46.31 192.82,46.23 192.82,44.17 192.01,43.36 187.23,43.36 186.93,43.06 186.87,43.06 186.87,41.86 187.13,41.61 187.13,38.69 188.22,37.59 193.35,37.59 193.63,37.32 193.63,28.73 192.16,27.26 178.39,27.26 178.14,27.51 178.14,29.52 178.62,30 188.78,30 189.24,30.46 189.24,33 186.16,33 185.86,33.3 185.86,37.39 185.73,37.52 185.73,38.61 185.48,38.86 184.92,38.86 184.82,38.76 184.23,38.76 184.13,38.86 184.13,40.26 184.14,40.27 183.42,41 183.42,42.55 183.85,42.98 184.79,42.98 185.94,44.12 185.94,48.87 185.55,49.25 185.55,51.84 185.3,52.1 179.1,52.1 178.59,52.61 178.59,54.05 ; 1 cut-out
GND on BOTTOM: 204.05,32.67 203.57,32.19 203.57,30.54 202.83,29.8 198.25,29.8 198,30.05 198,38.38 197.85,38.53 197.16,38.53 197.09,38.61 197.09,40.13 197.62,40.67 200.26,40.67 200.41,40.52 200.41,36.53 200.67,36.27 203.59,36.27 203.94,36.63 207.53,36.63 207.68,36.48 207.68,35.33 207.53,35.18 207.53,32.82 207.37,32.67
GND on BOTTOM: 58.94,61.8 58.94,58.88 58.68,58.63 57.03,58.63 56.52,59.13 55.51,59.13 55.51,60.66 55.25,60.91 54.87,60.91 54.74,61.04 54.74,62.31 53.8,63.25 53.8,71.28 56.34,71.28 56.37,71.25 56.37,62.64 57.08,61.93 58.81,61.93
GND on BOTTOM: outline of 88 points within 51.6,20.33 57.67,28.92
GND on BOTTOM: 237.09,63.83 242.2,63.83 242.45,63.58 242.45,60.53 237.04,60.53 236.79,60.78 236.79,63.53
GND on BOTTOM: 20.17,57.97 21.32,57.97 21.42,58.07 21.42,58.75 21.62,58.96 22.31,58.96 22.89,58.37 22.89,58.09 23.02,57.97 23.76,57.97 23.86,58.07 23.86,58.93 24.16,59.24 25.33,59.24 25.51,59.41 25.51,60.23 25.43,60.3 20.66,60.3 20.1,59.74 20.1,58.04
GND on BOTTOM: 223.68,56.29 223.68,41.96 233.12,32.52 242.52,32.52 243.43,33.44 243.43,38.22 243.03,38.62 243.03,55.6 241.97,56.67 224.06,56.67
GND on BOTTOM: 118.32,54.74 119.95,54.74 119.97,54.77 119.97,64.06 119.69,64.34 118.63,64.34 117.86,63.58 114.92,63.58 114.15,64.34 113.55,64.34 113.06,63.86 113.06,54.66 113.29,54.43 114.56,54.43 115.32,55.2 117.86,55.2
GND on BOTTOM: 184.51,62.54 188.78,62.54 189.01,62.31 189.01,58.65 189.16,58.5 190.38,58.5 190.46,58.58 190.46,61.09 190.61,61.24 191.68,61.24 191.83,61.39 191.83,61.78 191.68,61.93 190.68,61.93 190.46,62.16 190.46,64.52 190.3,64.67 188.25,64.67 187.48,63.91 184.59,63.91 184.51,63.83
GND on BOTTOM: 159.7,92.18 159.7,31.65 159.71,31.64 159.71,31.03 159.82,30.91 169.41,30.91 169.58,31.08 169.58,35.56 170.96,36.94 170.96,44.32 170.36,44.91 170.36,51.51 171.11,52.26 171.11,60.04 170.57,60.58 170.57,67.98 171.11,68.52 171.11,73.27 169.9,74.48 169.9,79.85 170.8,80.75 170.8,80.76 170.98,80.95 170.98,89.24 171.03,89.28 171.03,92.61 170.77,92.87 160.15,92.87 160.14,92.85 159.06,93.93 152.36,93.93 151.21,92.79 146,92.79 145.9,92.68 145.9,91.44 146.83,90.5 154.41,90.5 156.47,92.56 159.32,92.56
GND on BOTTOM: 192.29,18.04 192.36,18.11 194.04,18.11 194.42,17.73 194.42,16.28 194.95,15.75 195.41,15.75 195.79,15.37 195.79,14.07 195.33,13.62 191.9,13.62 191.6,13.92 191.6,16.36 191.68,16.44 192.13,16.44 192.29,16.59
GND on BOTTOM: 93.35,87.07 93.35,84.79 93.61,84.53 95.89,84.53 96.15,84.79 96.15,87.07 95.89,87.33 93.61,87.33
GND on BOTTOM: 199.37,46.15 199.14,45.93 196.98,45.93 196.86,46.05 196.86,47.45 196.63,47.68 196.63,48.36 196.7,48.44 199.98,48.44 200.59,47.83 201.2,47.83 201.28,47.75 201.28,46.31 201.12,46.15
GND on BOTTOM: 179.79,15.6 181.62,15.6 181.92,15.9 181.92,16.28 181.54,16.67 181.54,17.88 181.62,17.96 183.14,17.96 183.22,17.88 183.22,16.67 183.45,16.44 183.75,16.44 183.83,16.36 183.83,14.53 183.75,14.46 179.79,14.46 179.71,14.53 179.71,15.52
GND on BOTTOM: 21.85,70.63 19.12,70.63 18.93,70.44 18.93,67.8 19.39,67.34 26.12,67.34 26.12,69.07 26.07,69.12 21.95,69.12 21.85,69.22
GND on BOTTOM: 54.49,54.94 54.11,54.56 54.11,53.58 53.82,53.29 50.05,53.29 49.78,53.03 49.78,50.21 50.12,49.86 58.3,49.86 58.55,50.12 58.55,54.31 57.92,54.94
GND on BOTTOM: 74.51,97.28 74.51,96.39 73.22,95.1 73.22,94.37 73.3,94.3 75.36,94.3 76.09,95.03 76.09,97.12 75.94,97.28
GND on BOTTOM: 207.78,47.58 209.56,47.58 209.81,47.83 209.81,49.48 209.56,49.74 207.78,49.74 207.53,49.48 207.53,47.83
GND on BOTTOM: 71.6,42.2 68.11,42.2 68.11,43.83 68.77,43.83 68.92,43.97 68.92,44.99 69.1,45.16 69.1,48.64 68.54,49.2 68.54,49.51 68.61,49.58 70.82,49.58 70.9,49.51 70.9,49.13 70.63,48.86 70.63,48.55 70.62,48.54 70.62,45.16 70.82,44.96 70.82,43.94 70.95,43.81 71.6,43.81
GND on BOTTOM: 30.73,105.14 30.73,105.65 30.6,105.78 28.72,105.78 28.59,105.65 28.59,105.14 28.72,105.02 30.6,105.02
GND on BOTTOM: outline of 111 points within 175.19,68.25 203.97,90.05
GND on BOTTOM: 69.5,34.48 69.72,34.26 70.33,34.26 70.69,34.61 70.69,35.66 70.87,35.84 71.67,35.84 71.84,35.67 71.84,34.44 72.07,34.21 72.95,34.21 73.24,34.5 73.24,35.82 73.32,35.9 73.87,35.9 74,36.04 74,39.57 73.8,39.77 71.96,39.77 71.81,39.62 71.81,38.46 71.96,38.3 72.32,38.3 72.41,38.21 72.41,37.45 72.32,37.36 70.27,37.36 70.15,37.48 70.15,38.26 70.2,38.32 70.58,38.32 70.74,38.47 70.74,39.57 70.54,39.76 69.46,39.76 69.32,39.62 69.32,36.03 69.5,35.85
GND on BOTTOM: 87.94,46.43 88.96,46.43 89.16,46.64 89.16,54.26 88.96,54.46 88.64,54.46 88.51,54.33 88.51,52.91 88.43,52.84 87.9,52.84 87.81,52.75 87.81,46.56
GND on BOTTOM: 35.47,67.36 32.54,67.36 32.54,69.78 32.8,70.03 35.21,70.03 35.47,69.78
GND on BOTTOM: 98.94,53.11 98.94,51.61 98.75,51.43 97.56,51.43 97.3,51.69 97.3,52.58 97.83,53.11
GND on BOTTOM: 204.29,98.63 204.29,96.14 205.02,95.41 206.93,95.41 208.32,94.01 219.7,94.01 221.85,96.16 221.85,98.07 221.43,98.49 205.26,98.49 205,98.75 204.41,98.75
GND on BOTTOM: 114.69,34.5 114.69,32.46 114.94,32.21 116.47,32.21 116.72,32.46 116.72,34.24 116.47,34.5
GND on BOTTOM: 87.93,66.43 88.71,66.43 88.98,66.7 88.98,67.7 88.84,67.85 87.81,67.85 87.81,66.55
GND on BOTTOM: 48.65,75.77 48.65,76.28 48.9,76.53 49.41,76.53 49.66,76.79 49.66,77.68 50.07,78.08 53.76,78.08 53.92,78.24 53.92,79.56 54.1,79.74 57.89,79.74 58.3,79.33 58.3,76.41 58.05,76.15 54.74,76.15 54.24,75.64 48.78,75.64
GND on BOTTOM: 87.81,70.93 88.97,70.93 89.18,71.14 89.18,72.17 88.98,72.37 88.07,72.37 87.81,72.11
GND on BOTTOM: 46.36,36.78 49.41,36.78 49.66,37.04 49.66,39.96 49.41,40.21 46.36,40.21 46.11,39.96 46.11,37.04
GND on BOTTOM: 243.06,104.39 241.02,104.39 240.86,104.23 240.86,103.08 241.05,102.89 243.07,102.89 243.21,103.04 243.21,104.23
GND on BOTTOM: 223.02,81.87 229.75,81.87 230,81.61 230,68.53 229.62,68.15 223.27,68.15 222.77,68.66 222.77,81.61
GND on BOTTOM: 231.07,63.22 231.07,62.77 231.3,62.54 231.3,61.7 231.38,61.62 231.83,61.62 232.14,61.93 233.2,61.93 233.36,62.08 233.36,63.22 233.2,63.38 231.83,63.38 231.68,63.22
GND on L02_GND1, L08_GND4, L11_GND5, L17_GND8: 14.37,5.13 0.63,5.13 0.63,110.52 253.37,110.52 253.37,13.38 140.78,13.38 139.09,12.69 138.39,11 138.39,9.7 139.09,8.01 140.78,7.31 144.11,7.31 144.11,5.5 142.98,3.58 132.82,3.58 132.68,3.72 132.68,7.62 130.67,9.63 128.67,7.62 128.67,1.69 58.74,1.69 58.74,7.45 57.15,9.03 55.57,7.45 55.57,5.64 45.64,5.64 45.64,10.92 43.18,13.38 40.72,10.92 40.72,5.13 33.99,5.13 33.99,13.38 14.37,13.38
GND on L03_SIG1: 223.68,56.52 223.68,42.04 231.68,34.04 243.11,34.04 243.49,34.42 243.49,50.47 243.97,50.95 243.97,54.52 242.48,56.02 242.48,56.51 241.69,57.3 224.46,57.3
GND on L04_GND2, L06_GND3, L13_GND6, L15_GND7: 14.37,5.13 0.63,5.13 0.63,110.52 253.37,110.52 253.37,13.38 140.78,13.38 139.09,12.69 138.39,11 138.39,9.7 139.09,8.01 140.78,7.31 144.11,7.31 144.11,5.5 142.98,3.58 132.82,3.58 132.68,3.72 132.68,7.62 130.67,9.63 128.67,7.62 128.67,5.6 58.74,5.6 58.74,7.45 57.15,9.03 55.57,7.45 55.57,5.64 45.64,5.64 45.64,10.92 43.18,13.38 40.72,10.92 40.72,5.13 33.99,5.13 33.99,13.38 14.37,13.38
GND on L16_SIG6: 223.68,55.37 223.68,41.96 226.06,39.58 234.33,39.58 235.08,38.83 235.08,34.85 235.89,34.04 242.88,34.04 243.49,34.65 243.49,50.01 244.92,51.43 244.92,55.32 243.11,57.13 225.43,57.13
GND_CHS on BOTTOM: 0.69,33.05 2.98,33.05 5.14,30.89 5.14,30.38 4.81,30.05 4.2,30.05 3.23,31.02 2.47,31.02 2.47,25.81 3.23,25.81 4.12,26.7 4.81,26.7 5.14,26.37 5.14,25.94 2.85,23.65 2.85,23.42 2.7,23.27 0.77,23.27 0.69,23.35
GND_QSFPDD0_CAGE on TOP: 46.49,70.54 0.64,70.54 0.64,91.55 42.04,91.55 42.04,90.54 35.31,90.54 35.31,88.55 33.95,88.55 33.95,73.53 35.31,73.53 35.31,71.54 46.49,71.54
GND_QSFPDD0_CAGE on BOTTOM: 18.93,73.1 21.6,73.1 21.85,72.85 21.85,71.01 19.12,71.01 18.93,71.2
GND_QSFPDD1_CAGE on TOP: 46.49,45.75 0.64,45.75 0.64,66.75 42.04,66.75 42.04,65.75 35.31,65.75 35.31,63.76 33.95,63.76 33.95,48.74 35.31,48.74 35.31,46.75 46.49,46.75
GND_QSFPDD1_CAGE on BOTTOM: 32.54,64.82 35.21,64.82 35.47,65.08 35.47,66.86 32.54,66.86
PVCC on TOP: 194.88,62.66 194.9,62.64 195.59,62.64 195.76,62.82 195.76,64.67 195.23,65.2 192.46,65.2 192.34,65.08 192.34,63.38 192.39,63.32 193.68,63.32 193.78,63.43 194.8,63.43 194.88,63.35
PVCC on BOTTOM: 192.77,65.31 195.16,65.31 195.56,64.9 195.56,62.56 195.36,62.36 194.72,62.36 194.6,62.23 194.6,61.09 194.72,60.96 195.59,60.96 195.76,60.78 195.76,58.68 195.49,58.4 192.36,58.4 192.21,58.55 192.21,64.67 192.21,64.74
PVCC on L07_SIG3: 173.92,84.18 183.22,84.18 183.52,83.87 183.52,71.99 188.55,66.96 198.69,66.96 200.9,64.75 200.9,57.94 196.13,53.18 196.13,45.9 191.94,41.72 183.62,41.72 182.12,40.22 174.35,40.22 174.42,40.28 174.42,41.59 176.65,43.82 176.65,47.08 177.75,48.18 184.97,48.18 185.31,48.52 185.31,50.97 181.26,55.02 181.26,55.84 179.55,57.56 179.55,65.63 177.44,67.74 175.8,67.74 173.77,69.77 173.77,84.03 ; 1 cut-out
PVCC on L09_PWR1: 171.55,54.28 175.33,54.28 175.45,54.4 175.45,57.94 175.91,58.39 177.72,58.39 178.36,59.03 178.36,70.59 177.23,71.71 171.93,71.71 171.1,70.89 171.1,54.72
VCC_HSSI_AGND on TOP: 174.89,37.72 174.89,35.97 175.09,35.77 177.43,35.77 177.58,35.92 177.58,37.57 177.35,37.8 174.96,37.8
VCC_HSSI_AGND on BOTTOM: 180.73,41.3 180.73,42.62 180.77,42.66 183.05,42.66 183.1,42.71 183.37,42.45 183.37,40.67 184.02,40.02 184.02,38.8 184.59,38.23 184.59,36.78 184.28,36.48 182.38,36.48 182.15,36.25 182.15,35.56 181.69,35.11 178.57,35.11 177.35,33.89 176.13,33.89 175.9,34.11 175.9,39.8 175.99,39.89 178.33,39.89 178.57,40.13 178.57,40.54 178.72,40.69 180.12,40.69 ; 1 cut-out
VCC_HSSI_AGND on L14_SIG5: 175.98,36.56 175.98,36.34 176.59,35.73 177.97,35.73 181.46,39.22 182.99,39.22 182.99,41.35 182.84,41.51 181.01,41.51 176.28,36.78 176.2,36.78
VCCA_PLL_FLTR on TOP: 134.5,84.38 138.69,84.38 138.93,84.62 138.93,87.54 138.68,87.8 134.59,87.8 134.33,87.54 134.33,84.55
VCCA_PLL_FLTR on BOTTOM: 139.33,84.03 139.73,84.43 139.73,87.18 139.39,87.52 133.17,87.52 132.72,87.07 132.72,84.53 133.23,84.03
VCCA_PLL_FLTR on L07_SIG3: 134.46,87.91 143.63,87.91 144.51,87.04 144.51,78.95 148.47,74.99 148.47,53.8 148.09,53.42 123.32,53.42 121.8,51.89 121.8,48.34 120.66,47.2 109.61,47.2 109.35,47.45 109.35,61.67 113.29,65.61 113.29,71.45 113.55,71.71 114.18,71.71 114.43,71.45 131.62,71.45 132.47,72.31 132.47,79.47 130.1,81.84 130.1,83.56 ; 5 cut-outs
VCCE_PLL_DTS_GXR on BOTTOM: 72.18,43.99 72.02,44.15 71.38,44.15 71.2,44.33 71.2,45.09 70.97,45.32 70.97,46.94 71.89,46.94 71.94,46.99 72.47,46.99 72.52,46.94 72.52,46.18 72.78,45.93 74.3,45.93 74.51,46.13 74.51,49.33 74.25,49.58 73.72,49.58 73.72,50.12 74.48,50.12 75.47,49.13 75.47,44.78 76.08,44.17 76.08,42.42 75.86,42.2 72.18,42.2
VCCE_PLL_DTS_GXR on L14_SIG5: 75.87,42.38 88.23,54.73 105.9,54.73 106.43,55.26 106.43,60.43 104.88,61.98 87.33,61.98 87.33,61.99 85.59,60.25 83.7,60.25 74.68,51.22 66.77,51.22 65.91,50.37 65.91,42.46 67.02,41.35 75.01,41.35 75.87,42.21
VCCE_PLL_DTS_GXR on L16_SIG6: 105.67,56.09 106.56,56.97 124.21,56.97 127.01,54.18 127.01,53.67 126.63,53.29 125.61,53.29 123.96,54.94 106.18,54.94 105.67,55.45
VCCED_AGND on L07_SIG3: 199.37,56.44 199.37,49.81 200.59,48.59 206.53,48.59 207.07,49.13 207.07,55.3 205.77,56.59 199.52,56.59
VCCFUSEWR_GXF on TOP: 187.56,67.49 187.61,67.54 187.61,68.13 187.76,68.28 188.98,68.28 189.03,68.33 189.03,69.47 189.14,69.57 191.6,69.57 191.62,69.6 191.62,70.49 191.55,70.56 187.87,70.56 187.69,70.39 187.69,69.27 187.66,69.24 186.75,69.24 186.72,69.22 186.72,67.59 186.82,67.49
VCCFUSEWR_GXF on L14_SIG5: 104.15,66.25 105.29,66.25 105.38,66.16 113.53,66.16 114.71,64.98 144.81,64.98 144.89,64.9 147.25,64.9 149.63,67.28 149.63,69.7 151.35,71.41 161.84,71.41 168.35,64.9 180.09,64.9 181.24,66.04 181.24,68.56 181.25,68.57 181.25,70.69 181.99,71.43 187.37,71.43 188.09,70.7 188.09,67.98 187.5,67.39 186.71,67.39 185.28,68.82 184.1,68.82 183.58,68.31 183.58,65.27 180.88,62.56 102.34,62.56 101.77,63.14 101.77,64.59 103.43,66.26 104.16,66.26
VCCFUSEWR_SDM on TOP: 71.46,84.51 72.3,84.51 72.91,85.12 72.91,85.47 73.26,85.83 74.76,85.83 76.33,87.4 76.33,91.37 76.54,91.57 77.86,91.57 78.01,91.42 78.01,83.63 77.63,83.25 71.51,83.25 71.36,83.4 71.36,84.41
VCCFUSEWR_SDM on BOTTOM: 71.41,84.51 72.3,84.51 72.91,85.12 72.91,85.47 73.06,85.63 74.86,85.63 74.99,85.5 74.99,84.2 74.48,83.7 74.12,83.7 73.82,83.39 73.82,81.99 73.72,81.89 72.05,81.89 71.97,81.97 71.97,82.86 71.62,83.21 71.33,83.21 71.2,83.34 71.2,84.31
