# Allegro board FM85_AGILEX_PCIE_DK_CMC_ADI_REVC.brd (continued)
## Nets (continued)
GND: C1.2 C2.2 C3.2 C4.2 C5.1 C6.2 C7.2 C8.1 C9.2 C10.2 C11.2 C12.2 C13.2 C14.2 C15.2 C16.2 C17.2 C18.2 C19.2 C20.2 C21.2 C22.2 C23.2 C24.2 C25.2 C26.1 C27.1 C28.2 C29.2 C30.2 C31.2 C32.2 C33.2 C34.2 C35.2 C36.2 C37.2 C38.2 C39.2 C40.2 C41.2 C42.2 C43.2 C44.2 C45.2 C46.2 C47.2 C48.2 C49.2 C50.2 C51.1 C52.2 C53.2 C54.1 C55.2 C56.2 C57.2 C58.2 C59.2 C60.2 C61.2 C62.2 C63.2 C64.2 C65.2 C66.2 C67.2 C68.2 C69.2 C70.2 C71.2 C72.1 C73.1 C74.2 C75.2 C76.2 C77.2 C78.2 C79.2 C80.2 C81.2 C82.2 C83.2 C84.2 C85.2 C86.2 C87.2 C88.2 C89.2 C90.2 C91.2 C92.2 C93.2 C94.2 C95.2 C96.1 C97.1 C98.2 C99.2 C100.2 C101.2 C102.2 C103.1 C104.2 C105.2 C106.1 C107.2 C108.2 C109.2 C110.2 C111.2 C112.2 C113.2 C114.2 C115.2 C116.2 C117.2 C118.2 C119.2 C120.2 C121.2 C122.2 C123.2 C124.1 C125.1 C126.2 C127.2 C128.2 C129.2 C130.2 C131.2 C132.2 C133.2 C134.2 C135.2 C136.2 C137.2 C138.2 C139.2 C140.2 C141.2 C142.2 C143.2 C144.2 C145.2 C146.2 C147.2 C148.2 C149.1 C150.2 C151.2 C152.1 C153.2 C154.2 C155.2 C156.2 C157.2 C158.2 C159.2 C160.2 C161.2 C162.2 C163.2 C164.2 C165.2 C166.2 C167.2 C168.2 C169.2 C170.1 C171.1 C172.2 C173.2 C174.2 C175.2 C176.2 C177.2 C178.2 C179.2 C180.2 C181.2 C182.2 C183.2 C184.2 C185.2 C186.2 C187.2 C188.2 C189.2 C190.2 C191.2 C192.2 C193.1 C194.2 C195.1 C196.2 C197.2 C198.2 C199.2 C200.2 C201.2 C202.2 C203.2 C204.2 C205.2 C206.2 C207.2 C208.2 C209.2 C210.2 C211.2 C212.1 C213.2 C214.2 C215.2 C216.1 C217.1 C218.2 C219.2 C220.2 C221.2 C222.2 C223.2 C224.2 C225.2 C226.2 C227.1 C228.2 C229.2 C230.2 C231.2 C232.2 C233.2 C234.2 C235.2 C236.2 C237.2 C238.2 C239.2 C240.2 C241.2 C242.2 C243.2 C244.2 C245.2 C246.1 C247.2 C248.2 C249.2 C250.2 C251.2 C252.1 C253.1 C254.2 C255.2 C256.2 C257.2 C258.2 C259.2 C260.2 C261.1 C262.2 C263.2 C264.2 C265.2 C266.1 C267.2 C268.1 C269.1 C270.1 C271.2 C272.1 C273.1 C274.1 C275.2 C276.1 C277.1 C278.1 C279.2 C280.2 C281.1 C282.2 C283.1 C284.1 C285.1 C286.2 C287.1 C288.1 C289.1 C290.2 C291.1 C292.1 C293.1 C294.2 C295.1 C296.1 C297.1 C298.1 C299.1 C300.1 C301.1 C302.1 C303.1 C304.1 C305.1 C308.2 C309.2 C310.2 C340.2 C353.1 C370.2 C371.2 C372.2 C389.1 C390.2 C391.2 C392.2 C394.2 C395.2 C396.2 C397.2 C404.2 C405.1 C406.2 C407.2 C408.2 C409.2 C410.2 C411.2 C412.1 C413.2 C414.2 C415.1 C416.1 C417.2 C418.2 C419.2 C420.2 C421.2 C422.2 C423.2 C424.2 C425.2 C426.2 C427.2 C428.2 C429.2 C430.2 C431.2 C432.2 C433.2 C434.2 C435.2 C436.2 C437.2 C438.2 C439.2 C440.2 C441.2 C442.2 C443.2 C444.2 C455.2 C456.2 C457.2 C458.2 C459.2 C460.2 C461.2 C462.2 C463.2 C464.2 C471.2 C472.2 C477.1 C478.1 C479.1 C480.1 C481.2 C482.1 C483.2 C484.2 C485.2 C486.1 C487.2 C488.1 C489.2 C490.1 C491.1 C492.1 C493.1 C494.2 C495.1 C496.2 C497.2 C498.2 C499.2 C500.2 C501.2 C502.2 C503.2 C504.2 C505.2 C506.2 C507.2 C508.2 C509.2 C510.2 C512.2 C513.2 C514.2 C515.2 C516.2 C517.2 C518.2 C519.2 C520.2 C521.2 C522.2 C523.2 C524.2 C525.2 C526.2 C527.2 C528.2 C529.2 C530.2 C531.2 C532.2 C533.2 C534.2 C535.2 C536.2 C537.2 C538.2 C539.2 C540.2 C541.2 C542.2 C543.2 C544.2 C545.2 C546.2 C547.2 C548.2 C549.2 C550.2 C551.2 C552.2 C553.2 C554.2 C555.2 C556.2 C557.2 C558.2 C559.2 C560.2 C561.2 C562.2 C565.2 C567.2 C570.2 C572.1 C573.2 C574.2 C575.1 C576.1 C577.1 C578.1 C579.1 C580.2 C581.2 C583.2 C584.2 C585.2 C586.2 C587.2 C588.2 C589.1 C590.2 C591.2 C592.2 C593.2 C594.2 C595.2 C596.2 C597.1 C618.1 C715.1 C716.1 C717.1 C718.1 C719.1 C721.2 C722.2 C723.2 C724.2 C783.1 C784.2 C785.2 C808.2 C809.2 C810.1 C811.1 C812.1 C813.1 C814.2 C815.2 C816.2 C817.2 C818.1 C819.2 C820.1 C825.2 C826.2 C827.1 C828.1 C829.1 C830.1 C831.2 C832.1 C833.2 C834.1 C835.2 C837.2 C838.2 C891.2 C892.2 C977.1 C978.2 C979.2 C980.2 C981.2 C982.2 C983.2 C984.2 C985.2 C986.1 C987.2 C988.2 C989.2 C990.2 C991.2 C992.2 C993.2 C994.2 C995.2 C996.2 C997.2 C998.2 C1004.2 C1005.2 C1006.2 C1019.2 C1020.2 C1021.2 C1022.2 C1023.2 C1024.2 C1025.2 C1026.2 C1027.2 C1028.2 C1029.2 C1030.2 C1031.2 C1032.2 C1033.2 C1034.1 C1035.1 C1036.1 C1037.2 C1038.2 C1039.2 C1040.2 C1041.1 C1042.1 C1043.1 C1044.2 C1045.2 C1046.2 C1047.2 C1048.2 C1049.2 C1050.2 C1051.2 C1052.2 C1053.2 C1054.2 C1055.2 C1056.2 C1057.2 C1058.2 C1059.2 C1060.2 C1061.2 C1062.2 C1063.2 C1064.2 C1065.2 C1066.2 C1067.2 C1068.2 C1069.2 C1070.2 C1090.2 C1091.2 C1092.2 C1093.2 C1094.2 C1095.2 C1096.2 C1097.2 C1098.2 C1099.2 C1100.2 C1101.2 C1102.2 C1103.2 C1104.2 C1105.2 C1106.2 C1107.2 C1108.2 C1109.2 C1110.2 C1111.2 C1112.2 C1113.2 C1114.2 C1115.2 C1116.2 C1117.2 C1118.2 C1119.2 C1120.2 C1121.2 C1122.2 C1123.2 C1124.2 C1125.2 C1126.2 C1127.2 C1128.2 C1129.2 C1130.2 C1131.2 C1132.2 C1133.2 C1134.2 C1135.1 C1136.1 C1137.1 C1138.1 C1139.1 C1140.1 C1141.1 C1142.1 C1143.1 C1144.1 C1145.1 C1146.1 C1147.1 C1148.1 C1149.1 C1150.1 C1151.1 C1152.1 C1153.1 C1154.1 C1155.1 C1159.1 C1160.1 C1161.2 C1162.1 C1163.1 C1164.2 C1165.1 C1166.1 C1167.2 C1168.1 C1169.1 C1170.1 C1171.1 C1172.1 C1173.1 C1174.1 C1175.1 C1176.1 C1177.1 C1178.1 C1179.1 C1180.2 C1181.2 C1182.2 C1183.2 C1184.2 C1185.2 C1186.2 C1187.2 C1188.2 C1189.1 C1190.2 C1191.2 C1192.2 C1193.2 C1194.1 C1195.2 C1196.2 C1197.2 C1198.2 C1199.1 C1200.2 C1201.2 C1202.2 C1203.2 C1204.1 C1205.2 C1208.2 C1209.2 C1210.2 C1211.1 C1212.2 C1213.2 C1214.2 C1215.2 C1216.1 C1217.2 C1218.2 C1219.2 C1220.2 C1221.1 C1222.2 C1223.2 C1224.2 C1225.2 C1226.1 C1227.2 C1232.1 C1233.1 C1234.1 C1235.1 C1236.1 C1237.1 C1238.1 C1239.2 C1240.2 C1241.2 C1242.2 C1243.2 C1244.1 C1245.1 C1246.2 C1247.2 C1248.2 C1249.2 C1250.2 C1251.2 C1255.1 C1256.1 C1257.1 C1258.1 C1259.1 C1260.1 C1261.1 C1262.1 C1265.1 C1266.2 C1267.1 C1268.1 C1269.1 C1270.1 C1271.2 C1272.1 C1273.1 C1277.2 C1279.1 C1280.1 C1283.1 C1284.2 C1286.1 C1293.2 C1294.2 C1309.1 C1310.2 C1311.1 C1312.2 C1313.2 C1314.2 C1315.2 C1316.2 C1317.2 C1318.2 C1319.2 C1320.2 C1321.2 C1322.2 C1323.2 C1324.2 C1325.2 C1326.2 C1331.2 C1332.2 C1333.1 C1334.1 C1335.1 C1336.1 C1338.1 C1339.1 C1340.2 C1341.2 C1342.2 C1343.2 C1346.2 C1350.2 C1351.1 C1354.1 C1355.1 C1360.2 C1361.2 C1364.1 C1367.2 C1371.2 C1372.1 C1375.1 C1376.1 C1381.2 C1382.2 C1385.1 C1386.1 C1387.1 C1389.2 C1390.2 C1391.2 C1392.2 C1393.1 C1394.1 C1395.2 C1396.2 C1397.2 C1398.2 C1399.1 C1400.1 C1401.2 C1402.2 C1403.2 C1404.2 C1405.2 C1406.2 C1407.2 C1408.2 C1409.2 C1410.2 C1411.2 C1412.2 C1413.2 C1414.2 C1415.2 C1416.2 C1417.2 C1418.2 C1419.2 C1420.2 C1421.2 C1422.2 C1423.2 C1424.2 C1425.2 C1426.2 C1427.2 C1428.2 C1429.2 C1430.2 C1431.2 C1432.2 C1433.2 C1435.2 C1436.2 C1437.2 C1438.2 C1439.2 C1440.2 C1441.2 C1442.2 C1443.2 C1444.2 C1445.2 C1446.2 C1447.2 C1448.2 C1449.2 C1450.1 C1456.2 C1533.1 C1557.2 C1558.1 C1559.1 C1560.1 C1561.1 C1562.1 C1563.1 C1564.2 C1565.2 C1575.2 C1576.1 C1577.1 C1578.1 C1579.1 C1580.1 C1581.1 C1582.2 C1622.2 C1623.2 C1624.2 C1625.2 C1626.2 C1627.2 C1628.2 C1629.2 C1630.1 C1631.1 C1632.1 C1633.1 C1714.2 C1715.2 C1716.2 C1718.1 C1719.2 C1720.2 C1721.2 C1728.1 C1729.1 C1730.2 C1731.2 C1732.1 C1733.1 C1734.1 C1735.1 C1738.2 C1739.1 C1740.1 C1741.2 C1742.2 C1743.1 C1744.1 C1745.1 C1746.1 C1749.2 C1750.1 C1751.1 C1886.2 C1887.1 C1888.1 C1889.1 C1890.2 C1891.1 C1892.1 C1893.1 C1894.1 C1958.1 C1959.1 C1960.2 C1961.2 C1962.1 C1963.1 C1964.1 C1967.1 C2028.1 C7192.1 C7394.2 C7395.2 C7396.2 C7397.2 C7398.2 C7399.2 C7400.2 C7401.1 C7402.2 C7403.2 C7404.2 C7405.2 C7406.2 C7422.1 C7423.2 C7424.2 C7425.2 C7426.2 C7427.2 C7428.2 C7429.2 C7430.2 C7431.2 C7432.2 C7433.2 C7434.2 C7435.2 C7436.2 C7437.2 C7438.2 C7439.1 C7442.1 C7465.2 C7466.1 C7467.1 C7468.1 C7469.1 C7470.1 C7471.1 C7472.1 C7473.1 C7474.1 C7475.1 C7477.2 C7478.2 C7479.1 C7480.1 C7481.1 C7517.1 C7518.1 C7519.1 C7520.1 C7521.1 C7522.1 C7523.1 C7524.1 C7525.2 C7526.2 C7556.2 C7557.2 C7558.1 C7559.1 C7560.2 C7561.1 C7562.1 C7563.2 C7564.1 C7565.1 C7568.2 C7571.1 C7572.1 C7574.2 C7575.1 C7578.1 C7579.1 C7580.1 C7581.1 C7582.1 C7583.1 C7584.2 C7585.1 C7586.1 C7587.1 C7588.2 C7589.1 C7590.1 C7591.1 C7592.1 C7593.1 C7594.1 C7595.1 C7596.2 C7597.1 C7598.1 C7599.1 C7600.2 C7602.1 C7603.1 C7604.1 C7605.1 C7606.1 C7607.1 C7608.2 C7609.2 C7610.1 C7611.1 C7612.1 C7615.1 C7616.1 C7617.1 C7618.2 C7619.2 C7620.1 C7621.1 C7622.1 C7625.1 C7626.1 C7627.1 C7630.1 C7631.1 C7632.1 C7634.1 C7636.1 C7637.1 C7638.1 C7639.1 C7640.1 C7641.1 C7646.1 C7647.1 C7648.1 C7649.1 C7650.2 C7653.1 C7654.1 C7655.1 C7656.1 C7664.1 C7665.2 C7666.1 C7667.1 C7668.1 C7669.1 C7670.1 C7671.1 C7672.1 C7674.1 C7676.2 C7679.1 C7680.1 C7681.2 C7682.2 C7684.1 C7685.1 C7686.1 C7687.1 C7688.1 C7689.1 C7690.1 C7691.2 C7692.2 C7693.1 C7694.1 C7695.1 C7696.1 C7697.1 C7699.1 C7700.1 C7701.1 C7703.1 C7704.1 C7708.1 C7709.1 C7712.1 C7713.1 C7714.1 C7719.1 C7726.2 C7727.2 C7728.2 C7729.2 C7730.2 C7731.2 C7732.2 C7733.2 C7734.2 C7735.2 C7736.2 C7737.2 C7738.2 C7739.2 C7740.2 C7741.2 C7742.2 C7743.2 C7744.2 C7745.2 C7746.2 C7747.2 C7748.2 C7749.2 C7750.2 C7751.2 C7752.2 C7753.2 C7754.2 C7755.2 C7756.2 C7757.2 C7758.2 C7759.2 C7760.1 C7765.2 C7766.2 C7767.1 C7768.1 C7769.1 C7770.1 C7771.2 C7772.2 C7773.2 C7774.2 C7775.2 C7776.2 C7777.2 C7778.1 C7779.1 C7783.2 CN1.5 CN1.6 CN1.7 CN1.8 CN2.5 CN2.6 CN2.7 CN2.8 CN3.5 CN3.6 CN3.7 CN3.8 CN4.5 CN4.6 CN4.7 CN4.8 CN5.5 CN5.6 CN5.7 CN5.8 CN6.5 CN6.6 CN6.7 CN6.8 D12.2 D13.2 EU1.8 EU1.13 EU2.8 EU2.13 J1.2 J1.4 J1.6 J1.9 J1.11 J1.13 J1.15 J1.17 J1.20 J1.22 J1.24 J1.26 J1.28 J1.31 J1.33 J1.35 J1.37 J1.39 J1.42 J1.44 J1.46 J1.48 J1.50 J1.53 J1.55 J1.57 J1.94 J1.96 J1.98 J1.101 J1.103 J1.105 J1.107 J1.109 J1.112 J1.114 J1.116 J1.118 J1.120 J1.123 J1.125 J1.127 J1.129 J1.131 J1.134 J1.136 J1.138 J1.147 J1.149 J1.151 J1.154 J1.156 J1.158 J1.160 J1.162 J1.165 J1.167 J1.169 J1.171 J1.173 J1.176 J1.178 J1.180 J1.182 J1.184 J1.187 J1.189 J1.191 J1.193 J1.195 J1.198 J1.200 J1.202 J1.239 J1.241 J1.243 J1.246 J1.248 J1.250 J1.252 J1.254 J1.257 J1.259 J1.261 J1.263 J1.265 J1.268 J1.270 J1.272 J1.274 J1.276 J1.279 J1.281 J1.283 J2.2 J2.4 J2.6 J2.9 J2.11 J2.13 J2.15 J2.17 J2.20 J2.22 J2.24 J2.26 J2.28 J2.31 J2.33 J2.35 J2.37 J2.39 J2.42 J2.44 J2.46 J2.48 J2.50 J2.53 J2.55 J2.57 J2.94 J2.96 J2.98 J2.101 J2.103 J2.105 J2.107 J2.109 J2.112 J2.114 J2.116 J2.118 J2.120 J2.123 J2.125 J2.127 J2.129 J2.131 J2.134 J2.136 J2.138 J2.147 J2.149 J2.151 J2.154 J2.156 J2.158 J2.160 J2.162 J2.165 J2.167 J2.169 J2.171 J2.173 J2.176 J2.178 J2.180 J2.182 J2.184 J2.187 J2.189 J2.191 J2.193 J2.195 J2.198 J2.200 J2.202 J2.239 J2.241 J2.243 J2.246 J2.248 J2.250 J2.252 J2.254 J2.257 J2.259 J2.261 J2.263 J2.265 J2.268 J2.270 J2.272 J2.274 J2.276 J2.279 J2.281 J2.283 J3.1 J3.4 J3.7 J3.13 J3.16 J3.19 J3.20 J3.23 J3.26 J3.32 J3.35 J3.38 J3.39 J3.42 J3.45 J3.51 J3.54 J3.57 J3.58 J3.61 J3.64 J3.70 J3.73 J3.76 J4.1 J4.4 J4.7 J4.13 J4.16 J4.19 J4.20 J4.23 J4.26 J4.32 J4.35 J4.38 J4.39 J4.42 J4.45 J4.51 J4.54 J4.57 J4.58 J4.61 J4.64 J4.70 J4.73 J4.76 J5.A4 J5.A12 J5.A15 J5.A18 J5.A20 J5.A23 J5.A24 J5.A27 J5.A28 J5.A31 J5.A34 J5.A37 J5.A38 J5.A41 J5.A42 J5.A45 J5.A46 J5.A49 J5.A51 J5.A54 J5.A55 J5.A58 J5.A59 J5.A62 J5.A63 J5.A66 J5.A67 J5.A70 J5.A71 J5.A74 J5.A75 J5.A78 J5.A79 J5.A82 J5.B4 J5.B7 J5.B13 J5.B16 J5.B18 J5.B21 J5.B22 J5.B25 J5.B26 J5.B29 J5.B32 J5.B35 J5.B36 J5.B39 J5.B40 J5.B43 J5.B44 J5.B47 J5.B49 J5.B52 J5.B53 J5.B56 J5.B57 J5.B60 J5.B61 J5.B64 J5.B65 J5.B68 J5.B69 J5.B72 J5.B73 J5.B76 J5.B77 J5.B80 J6.A1 J6.A4 J6.A7 J6.A10 J6.A13 J6.A16 J6.A19 J6.A22 J6.A25 J6.A28 J6.A31 J6.A34 J6.A37 J6.B1 J6.B4 J6.B7 J6.B10 J6.B13 J6.B16 J6.B19 J6.B22 J6.B25 J6.B28 J6.B31 J6.B34 J6.B37 J6.MH1 J6.MH2 J6.MH3 J6.MH4 J7.A1 J7.A4 J7.A7 J7.A10 J7.A13 J7.A16 J7.A19 J7.A22 J7.A25 J7.A28 J7.A31 J7.A34 J7.A37 J7.B1 J7.B4 J7.B7 J7.B10 J7.B13 J7.B16 J7.B19 J7.B22 J7.B25 J7.B28 J7.B31 J7.B34 J7.B37 J7.MH1 J7.MH2 J7.MH3 J7.MH4 J8.5 J9.1 J10.10 J11.4(SENSE1) J11.5 J11.6 J11.7 J11.8 J12.3 J13.3 J14.3 J15.3 Q1.2(SOURCE) Q2.2(SOURCE) Q3.2(SOURCE) Q4.2(SOURCE) Q5.2(SOURCE) Q6.2(SOURCE) Q7.2(SOURCE) Q8.2(SOURCE) Q9.2(SOURCE) Q10.2(SOURCE) Q11.2(SOURCE) Q12.2(SOURCE) Q14.2(SOURCE) Q15.2(SOURCE) R1.2 R2.2 R3.2 R4.2 R7.2 R8.2 R9.2 R10.2 R13.1 R14.1 R15.1 R16.1 R17.1 R18.1 R19.1 R20.1 R21.1 R23.1 R24.2 R25.2 R30.1 R32.1 R33.2 R37.2 R39.2 R40.2 R41.2 R42.2 R45.2 R46.2 R47.2 R48.2 R51.1 R52.1 R53.1 R54.1 R55.1 R56.1 R57.1 R58.1 R59.1 R61.1 R62.2 R63.2 R68.1 R70.1 R71.2 R75.2 R79.1 R84.1 R85.1 R86.1 R88.1 R89.1 R90.1 R97.1 R101.1 R102.1 R103.1 R104.1 R108.2 R122.2 R125.1 R127.2 R130.1 R137.2 R146.2 R159.1 R160.1 R161.1 R162.1 R163.1 R164.1 R165.1 R166.1 R167.1 R168.1 R169.1 R174.1 R175.1 R176.1 R177.1 R178.2 R179.2 R190.2 R191.2 R204.1 R206.1 R207.1 R208.1 R210.1 R213.2 R216.1 R223.2 R225.2 R242.2 R244.2 R246.2 R248.2 R253.2 R260.2 R264.2 R267.2 R270.2 R272.2 R284.1 R285.1 R286.1 R288.1 R294.2 R304.2 R317.1 R318.1 R319.1 R320.1 R344.2 R345.2 R346.2 R351.2 R352.2 R353.2 R358.1 R360.2 R371.1 R373.1 R374.2 R375.2 R383.1 R413.1 R434.2 R448.1 R449.1 R450.1 R451.2 R452.1 R460.2 R466.2 R467.1 R468.1 R469.1 R476.2 R477.2 R486.2 R488.2 R490.2 R497.2 R504.1 R505.2 R579.2 R585.2 R588.1 R589.2 R662.1 R665.1 R667.1 R672.1 R677.1 R679.1 R818.1 R820.2 R824.1 R826.2 R840.1 R866.1 R867.2 R916.1 R917.2 R921.1 R925.1 R936.2 R937.2 R939.2 R941.2 R948.1 R951.1 R953.1 R960.1 R963.1 R972.1 R975.1 R977.1 R979.1 R980.2 R981.2 R995.2 R1034.1 R1048.1 R2206.1 R2635.1 R2715.1 R2716.1 R2717.1 R2718.1 R2719.1 R2739.2 R2743.2 R2782.1 R2784.2 R2786.1 R5870.1 R5871.1 R5873.1 R5876.2 R5888.2 R5941.1 R6002.1 R6005.1 R6008.1 R6026.1 R6037.2 R6041.1 R6043.2 R6053.2 R6074.2 R6075.2 R6078.1 R6088.2 R6095.2 R6098.1 R6101.1 R6104.1 R6148.1 R6165.2 R6168.2 R6169.1 R6173.1 R6187.1 R6190.1 R6193.1 R6195.2 R6196.1 R6201.1 R6202.1 R6254.2 R6267.1 R6270.1 R6272.1 R6280.1 R6298.1 R6303.2 R6304.2 R6306.2 R6308.2 R6310.2 R6311.2 R6313.2 R6314.2 R6316.2 R6322.2 R6323.2 S1.1 S2.1 S3.1 S4.2 S5.1 ST1.2 ST2.2 ST3.2 ST6.2 ST9.1 ST10.1 ST13.2 ST17.2 ST18.2 ST20.2 ST23.2 ST24.2 ST25.2 ST26.2 ST27.2 ST28.1 ST29.2 ST30.1 ST31.1 ST32.1 ST34.1 SW8.7 SW8.8 U1.A2 U1.A8 U1.B2 U1.C9 U1.D2 U1.D8 U1.E1 U1.E3 U1.E8 U1.F1 U1.G8 U1.H1 U1.H9 U1.K1 U1.K9 U1.N1 U1.T1 U1.T7 U2.A2 U2.A8 U2.B2 U2.C9 U2.D2 U2.D8 U2.E1 U2.E3 U2.E8 U2.F1 U2.G8 U2.H1 U2.H9 U2.K1 U2.K9 U2.N1 U2.T1 U2.T7 U3.A2 U3.A8 U3.B2 U3.C9 U3.D2 U3.D8 U3.E1 U3.E3 U3.E8 U3.F1 U3.G8 U3.H1 U3.H9 U3.K1 U3.K9 U3.N1 U3.T1 U3.T7 U4.A2 U4.A8 U4.B2 U4.C9 U4.D2 U4.D8 U4.E1 U4.E3 U4.E8 U4.F1 U4.G8 U4.H1 U4.H9 U4.K1 U4.K9 U4.N1 U4.T1 U4.T7 U5.A2 U5.A8 U5.B2 U5.C9 U5.D2 U5.D8 U5.E1 U5.E3 U5.E8 U5.F1 U5.G8 U5.H1 U5.H9 U5.K1 U5.K9 U5.N1 U5.T1 U5.T7 U6.A69 U6.A72 U6.A74 U6.A76 U6.A78 U6.A80 U6.A82 U6.AA63 U6.AA65 U6.AB10 U6.AB22 U6.AC72 U6.AC74 U6.AC78 U6.AC80 U6.AD64 U6.AE8 U6.AE12 U6.AE20 U6.AE24 U6.AF75 U6.AF77 U6.AF81 U6.AF83 U6.AG27 U6.AG29 U6.AG31 U6.AG33 U6.AG35 U6.AG37 U6.AG39 U6.AG41 U6.AG43 U6.AG45 U6.AG47 U6.AG49 U6.AG51 U6.AG53 U6.AG55 U6.AG57 U6.AG59 U6.AG61 U6.AH1 U6.AH6 U6.AH14 U6.AH18 U6.AJ72 U6.AJ76 U6.AJ78 U6.AJ82 U6.AK26 U6.AL3 U6.AL12 U6.AL16 U6.AL24 U6.AM73 U6.AM75 U6.AM79 U6.AM81 U6.AN63 U6.AN65 U6.AN68 U6.AP6 U6.AP10 U6.AP18 U6.AP22 U6.AR72 U6.AR74 U6.AR78 U6.AR80 U6.AU8 U6.AU12 U6.AU20 U6.AU24 U6.AW75 U6.AW77 U6.AW81 U6.AW83 U6.AY26 U6.AY28 U6.AY30 U6.AY32 U6.AY34 U6.AY36 U6.AY38 U6.AY40 U6.AY42 U6.AY44 U6.AY46 U6.AY48 U6.AY50 U6.AY52 U6.AY54 U6.AY56 U6.AY58 U6.AY60 U6.AY62 U6.B5 U6.B9 U6.B65 U6.BA1 U6.BA6 U6.BA14 U6.BA18 U6.BB72 U6.BB76 U6.BB78 U6.BB82 U6.BD3 U6.BD12 U6.BD16 U6.BD24 U6.BE73 U6.BE75 U6.BE79 U6.BE81 U6.BF64 U6.BF66 U6.BF70 U6.BG6 U6.BG10 U6.BG18 U6.BG22 U6.BH72 U6.BH74 U6.BH78 U6.BH80 U6.BJ35 U6.BJ37 U6.BJ39 U6.BJ41 U6.BJ43 U6.BJ45 U6.BJ47 U6.BJ49 U6.BJ51 U6.BJ53 U6.BJ55 U6.BK8 U6.BK12 U6.BK20 U6.BK24 U6.BL75 U6.BL77 U6.BL81 U6.BL83 U6.BM36 U6.BM56 U6.BN1 U6.BN6 U6.BN14 U6.BN18 U6.BP72 U6.BP76 U6.BP78 U6.BP82 U6.BR27 U6.BR29 U6.BR31 U6.BR33 U6.BR35 U6.BR37 U6.BR57 U6.BR59 U6.BR61 U6.BT3 U6.BT12 U6.BT16 U6.BT24 U6.BU73(GND#BU73) U6.BU75 U6.BU79 U6.BU81 U6.BV40 U6.BV42 U6.BV44 U6.BV46 U6.BV48 U6.BV50 U6.BV52 U6.BV54 U6.BV56 U6.BW6 U6.BW10 U6.BW18 U6.BW22 U6.BY72 U6.BY74 U6.BY78 U6.BY80 U6.C67 U6.C73 U6.C75 U6.C79 U6.C81 U6.C83 U6.CA63 U6.CA65 U6.CA68 U6.CB8 U6.CB12 U6.CB20 U6.CB24 U6.CC75 U6.CC77 U6.CC81 U6.CC83 U6.CD36 U6.CD38 U6.CD40 U6.CD42 U6.CD44 U6.CD46 U6.CD48 U6.CD50 U6.CD52 U6.CD54 U6.CD60 U6.CD62 U6.CD64 U6.CD66 U6.CE1 U6.CE6 U6.CE14 U6.CE18 U6.CF72 U6.CF76 U6.CF78 U6.CF82 U6.CG61 U6.CH3 U6.CH12 U6.CH16 U6.CH24 U6.CJ73 U6.CJ75 U6.CJ79 U6.CJ81 U6.CK26 U6.CK28 U6.CK30 U6.CK32 U6.CK34 U6.CK36 U6.CK38 U6.CK40 U6.CK42 U6.CK44 U6.CK46 U6.CK48 U6.CK50 U6.CK52 U6.CK54 U6.CK58 U6.CK60 U6.CK62 U6.CK66 U6.CL6 U6.CL10 U6.CL18 U6.CL22 U6.CM72 U6.CM74 U6.CM78 U6.CM80 U6.CN59 U6.CN63 U6.CP8 U6.CP12 U6.CP20 U6.CP24 U6.CR28 U6.CR38 U6.CR52 U6.CR56 U6.CR58 U6.CR62 U6.CR66 U6.CT75 U6.CT77 U6.CT81 U6.CT83 U6.CU29 U6.CU45 U6.CU51 U6.CU57 U6.CV1 U6.CV6 U6.CV14 U6.CV18 U6.CW72 U6.CW76 U6.CW78 U6.CW82 U6.CY40 U6.CY46 U6.CY52 U6.CY64 U6.CY66 U6.D4 U6.DA3 U6.DA12 U6.DA16 U6.DA24 U6.DB73 U6.DB75 U6.DB79 U6.DB81 U6.DC33 U6.DC37 U6.DC41 U6.DC47 U6.DC53 U6.DC59 U6.DC61 U6.DC63 U6.DD6 U6.DD10 U6.DD18 U6.DD22 U6.DE72 U6.DE74 U6.DE78 U6.DE80 U6.DF30 U6.DF34 U6.DF42 U6.DF48 U6.DF54 U6.DF58 U6.DF60 U6.DF66 U6.DG8 U6.DG12 U6.DG20 U6.DG24 U6.DH75 U6.DH77 U6.DH79 U6.DH81 U6.DH83 U6.DJ29 U6.DJ35 U6.DJ37 U6.DJ43 U6.DJ49 U6.DJ55 U6.DK1 U6.DK6 U6.DK14 U6.DK18 U6.DL72 U6.DL76 U6.DL78 U6.DL80 U6.DL82 U6.DM28 U6.DM36 U6.DM38 U6.DM44 U6.DM50 U6.DM56 U6.DM62 U6.DM66 U6.DN3 U6.DN12 U6.DN16 U6.DN24 U6.DP73 U6.DP75 U6.DP77 U6.DP79 U6.DP81 U6.DP83 U6.DR31 U6.DR35 U6.DR39 U6.DR57 U6.DT6 U6.DT10 U6.DT18 U6.DT22 U6.DU72 U6.DU74 U6.DU76 U6.DU78 U6.DU80 U6.DV28 U6.DV32 U6.DV58 U6.DV62 U6.DV66 U6.DW8 U6.DW12 U6.DW20 U6.DW24 U6.DY75 U6.DY77 U6.DY79 U6.DY83 U6.E72 U6.E74 U6.E78 U6.E80 U6.E82 U6.EA59 U6.EA63 U6.EB1 U6.EB6 U6.EB14 U6.EB18 U6.EC72 U6.EC76 U6.EC78 U6.EC80 U6.EC82 U6.ED28 U6.ED32 U6.ED36 U6.ED54 U6.ED66 U6.EE3 U6.EE12 U6.EE16 U6.EE24 U6.EF75 U6.EF77 U6.EF79 U6.EF81 U6.EF83 U6.EG37 U6.EG55 U6.EG59 U6.EG65 U6.EH6 U6.EH10 U6.EH18 U6.EH22 U6.EJ28 U6.EJ34 U6.EJ38 U6.EJ56 U6.EJ58 U6.EJ60 U6.EJ64 U6.EJ66 U6.EJ70 U6.EK76 U6.EK78 U6.EK80 U6.EL31 U6.EL33 U6.EL35 U6.EL39 U6.EL57 U6.EL59 U6.EL61 U6.EL63 U6.EL65 U6.EL68 U6.EM8 U6.EM12 U6.EM20 U6.EM24 U6.EN75 U6.EN77 U6.EN79 U6.EN83 U6.EP28 U6.EP30 U6.EP36 U6.EP62 U6.EP64 U6.EP66 U6.ER1 U6.ER6 U6.ER14 U6.ER18 U6.ET72 U6.ET74 U6.ET76 U6.ET78 U6.ET80 U6.ET82 U6.EU61 U6.EU63 U6.EU65 U6.EU68 U6.EV3 U6.EV12 U6.EV16 U6.EV24 U6.EW73 U6.EW75 U6.EW77 U6.EW79 U6.EW81 U6.EW83 U6.EY28 U6.EY32 U6.EY54 U6.EY58 U6.EY60 U6.EY62 U6.EY64 U6.EY66 U6.EY70 U6.F2 U6.F5 U6.F9 U6.F13 U6.F17 U6.F21 U6.F25 U6.F27 U6.F29 U6.F31 U6.F33 U6.F35 U6.F37 U6.F39 U6.F41 U6.F43 U6.F45 U6.F47 U6.F49 U6.F51 U6.F53 U6.F55 U6.F57 U6.F59 U6.F61 U6.F63 U6.F65 U6.FA6 U6.FA10 U6.FA18 U6.FA22 U6.FB72 U6.FB74 U6.FB76 U6.FB78 U6.FB80 U6.FC31 U6.FC35 U6.FC37 U6.FC55 U6.FC61 U6.FC63 U6.FC65 U6.FC68 U6.FD8 U6.FD12 U6.FD20 U6.FD24 U6.FE75 U6.FE77 U6.FE79 U6.FE83 U6.FF28 U6.FF32 U6.FF34 U6.FF36 U6.FF38 U6.FF56 U6.FF62 U6.FF64 U6.FF66 U6.FF70 U6.FG1 U6.FG6 U6.FG14 U6.FG18 U6.FH72 U6.FH74 U6.FH76 U6.FH78 U6.FH80 U6.FH82 U6.FJ33 U6.FJ35 U6.FJ61 U6.FJ63 U6.FJ65 U6.FJ68 U6.FK3 U6.FK12 U6.FK16 U6.FK24 U6.FL75 U6.FL77 U6.FL79 U6.FL81 U6.FL83 U6.FM28 U6.FM30 U6.FM32 U6.FM34 U6.FM60 U6.FM62 U6.FM64 U6.FM66 U6.FN6 U6.FN10 U6.FN18 U6.FN22 U6.FP76 U6.FP78 U6.FP80 U6.FR29 U6.FR31 U6.FR33 U6.FR35 U6.FR57 U6.FR59 U6.FR61 U6.FR65 U6.FR68 U6.FT8 U6.FT12 U6.FT20 U6.FT24 U6.FU75 U6.FU77 U6.FU79 U6.FU83 U6.FV28 U6.FV30 U6.FV32 U6.FV34 U6.FV36 U6.FV54 U6.FV60 U6.FV62 U6.FV64 U6.FW1 U6.FW6 U6.FW14 U6.FW18 U6.FY74 U6.FY76 U6.FY78 U6.FY80 U6.FY82 U6.G67 U6.G71 U6.G75 U6.G77 U6.G81 U6.G83 U6.GA29 U6.GA31 U6.GA33 U6.GA35 U6.GA37 U6.GA55 U6.GA61 U6.GA68 U6.GB3 U6.GB12 U6.GB16 U6.GB24 U6.GC73 U6.GC75 U6.GC77 U6.GC79 U6.GC81 U6.GC83 U6.GD28 U6.GD30 U6.GD32 U6.GD34 U6.GD38 U6.GD56 U6.GD70 U6.GE6 U6.GE10 U6.GE18 U6.GE22 U6.GF29 U6.GF31 U6.GF33 U6.GF35 U6.GF39 U6.GF57 U6.GF61 U6.GF63 U6.GF68 U6.GG72 U6.GG74 U6.GG76 U6.GG80 U6.GG82 U6.GH28 U6.GH30 U6.GH32 U6.GH34 U6.GH36 U6.GH58 U6.GH62 U6.GH64 U6.GH70 U6.GJ8 U6.GJ12 U6.GJ20 U6.GJ24 U6.GK73 U6.GK75 U6.GK79 U6.GK81 U6.GL29 U6.GL31 U6.GL33 U6.GL35 U6.GL61 U6.GL65 U6.GL68 U6.GM1 U6.GM6 U6.GM14 U6.GM18 U6.GN72 U6.GN74 U6.GN76 U6.GN78 U6.GN80 U6.GP28 U6.GP30 U6.GP32 U6.GP34 U6.GP54 U6.GR3 U6.GR12 U6.GR16 U6.GR24 U6.GT73 U6.GT75 U6.GT77 U6.GT81 U6.GT83 U6.GU29 U6.GU31 U6.GU33 U6.GU35 U6.GU37 U6.GU55 U6.GU57 U6.GU59 U6.GU61 U6.GU68 U6.GV6 U6.GV10 U6.GV18 U6.GV22 U6.GW72 U6.GW74 U6.GW76 U6.GW78 U6.GW82 U6.GY28 U6.GY30 U6.GY32 U6.GY34 U6.GY36 U6.GY38 U6.GY44 U6.GY50 U6.GY56 U6.GY62 U6.GY64 U6.H4 U6.HA8 U6.HA12 U6.HA20 U6.HA24 U6.HB73 U6.HB75 U6.HB79 U6.HB81 U6.HC29 U6.HC31 U6.HC33 U6.HC35 U6.HC39 U6.HC45 U6.HC51 U6.HC63 U6.HD1 U6.HD6 U6.HD14 U6.HD18 U6.HE72 U6.HE74 U6.HE78 U6.HE80 U6.HF28 U6.HF30 U6.HF32 U6.HF34 U6.HF40 U6.HF46 U6.HF52 U6.HF60 U6.HF66 U6.HG3 U6.HG12 U6.HG16 U6.HG24 U6.HH75 U6.HH77 U6.HH81 U6.HH83 U6.HJ29 U6.HJ31 U6.HJ33 U6.HJ35 U6.HJ41 U6.HJ47 U6.HJ53 U6.HJ57 U6.HK6 U6.HK10 U6.HK18 U6.HK22 U6.HL72 U6.HL76 U6.HL78 U6.HL82 U6.HM28 U6.HM30 U6.HM32 U6.HM34 U6.HM36 U6.HM42 U6.HM48 U6.HM54 U6.HM62 U6.HM66 U6.HN8 U6.HN12 U6.HN20 U6.HN24 U6.HP75 U6.HP79 U6.HP81 U6.HR29 U6.HR31 U6.HR33 U6.HR35 U6.HR37 U6.HR43 U6.HR49 U6.HR55 U6.HR59 U6.HT1 U6.HT6 U6.HT14 U6.HT18 U6.HU72 U6.HU78 U6.HU80 U6.HV26 U6.HV28 U6.HV30 U6.HV36 U6.HV38 U6.HV58 U6.HV66 U6.HV70 U6.HW3 U6.HW12 U6.HW16 U6.HW24 U6.HY29 U6.HY63 U6.HY65 U6.J2 U6.J65 U6.JA75 U6.JA77 U6.JA81 U6.JA83 U6.JB30 U6.JB36 U6.JB38 U6.JB40 U6.JB42 U6.JB44 U6.JB46 U6.JB48 U6.JB50 U6.JB52 U6.JB54 U6.JB56 U6.JB58 U6.JB60 U6.JB66 U6.JC6 U6.JC10 U6.JC18 U6.JC22 U6.JD72 U6.JD76 U6.JD78 U6.JD82 U6.JE37 U6.JE61 U6.JF8 U6.JF12 U6.JF20 U6.JF24 U6.JG73 U6.JG75 U6.JG79 U6.JG81 U6.JH28 U6.JH30 U6.JH32 U6.JH34 U6.JH36 U6.JH38 U6.JH40 U6.JH42 U6.JH44 U6.JH46 U6.JH48 U6.JH50 U6.JH52 U6.JH54 U6.JH56 U6.JH58 U6.JH66 U6.JJ1 U6.JJ6 U6.JJ14 U6.JJ18 U6.JK72 U6.JK74 U6.JK78 U6.JK80 U6.JL68 U6.JM3 U6.JM12 U6.JM16 U6.JM24 U6.JN75 U6.JN77 U6.JN81 U6.JN83 U6.JP38 U6.JP40 U6.JP42 U6.JP44 U6.JP46 U6.JP48 U6.JP50 U6.JP52 U6.JP54 U6.JP56 U6.JP58 U6.JP60 U6.JP62 U6.JP64 U6.JR6 U6.JR10 U6.JR18 U6.JR22 U6.JT72 U6.JT76 U6.JT78 U6.JT82 U6.JU27 U6.JU29 U6.JU31 U6.JU33 U6.JU35 U6.JU37 U6.JU68 U6.JV8 U6.JV12 U6.JV20 U6.JV24 U6.JW73 U6.JW75 U6.JW79 U6.JW81 U6.JY38 U6.JY56 U6.JY58 U6.JY64 U6.JY70 U6.K69 U6.K72 U6.K76 U6.K78 U6.K82 U6.KA1 U6.KA6 U6.KA14 U6.KA18 U6.KB72 U6.KB74 U6.KB78 U6.KB80 U6.KC39 U6.KC41 U6.KC43 U6.KC45 U6.KC47 U6.KC49 U6.KC51 U6.KC53 U6.KC55 U6.KC57 U6.KC59 U6.KC61 U6.KC63 U6.KC65 U6.KD3 U6.KD12 U6.KD16 U6.KD24 U6.KE75 U6.KE77 U6.KE81 U6.KE83 U6.KF66 U6.KG6 U6.KG10 U6.KG18 U6.KG22 U6.KH72 U6.KH76 U6.KH78 U6.KH82 U6.KJ68 U6.KK8 U6.KK12 U6.KK20 U6.KK24 U6.KL73 U6.KL75 U6.KL79 U6.KL81 U6.KM26 U6.KM28 U6.KM30 U6.KM32 U6.KM34 U6.KM36 U6.KM38 U6.KM40 U6.KM42 U6.KM44 U6.KM46 U6.KM48 U6.KM50 U6.KM52 U6.KM54 U6.KM56 U6.KM58 U6.KM60 U6.KM62 U6.KM64 U6.KM66 U6.KM70 U6.KN1 U6.KN6 U6.KN14 U6.KN18 U6.KP72 U6.KP74 U6.KP78 U6.KP80 U6.KR68 U6.KT3 U6.KT12 U6.KT16 U6.KT24 U6.KU70 U6.KV75 U6.KV77 U6.KV81 U6.KV83 U6.KY6 U6.KY10 U6.KY18 U6.KY22 U6.LA72 U6.LA76 U6.LA78 U6.LA82 U6.LB70 U6.LC8 U6.LC12 U6.LC20 U6.LC24 U6.LD73 U6.LD75 U6.LD79 U6.LD81 U6.LE27 U6.LE29 U6.LE31 U6.LE33 U6.LE35 U6.LE37 U6.LE39 U6.LE41 U6.LE43 U6.LE45 U6.LE47 U6.LE49 U6.LE51 U6.LE53 U6.LE55 U6.LE57 U6.LE59 U6.LE61 U6.LE63 U6.LE65 U6.LE68 U6.LF1 U6.LF6 U6.LF14 U6.LF18 U6.LG72 U6.LG74 U6.LG78 U6.LG80 U6.LH66 U6.LJ3 U6.LJ16 U6.LK71 U6.LK75 U6.LK77 U6.LK81 U6.LK83 U6.LL65 U6.LM69 U6.LM72 U6.LM76 U6.LM78 U6.LM82 U6.LP67 U6.LP73 U6.LP75 U6.LP79 U6.LP81 U6.LR2 U6.LT69 U6.LT72 U6.LT74 U6.LT78 U6.LT80 U6.LU7 U6.LU11 U6.LU15 U6.LU19 U6.LU23 U6.LU26 U6.LU28 U6.LU30 U6.LU32 U6.LU34 U6.LU36 U6.LU38 U6.LU40 U6.LU42 U6.LU44 U6.LU46 U6.LU48 U6.LU50 U6.LU52 U6.LU54 U6.LU56 U6.LU58 U6.LU60 U6.LU62 U6.LU64 U6.LV67 U6.LV71 U6.LV75 U6.LV77 U6.LV81 U6.LV83 U6.LY69 U6.LY72 U6.LY76 U6.LY78 U6.LY82 U6.M67 U6.M73 U6.M75 U6.M79 U6.M81 U6.MB67 U6.MB73 U6.MB75 U6.MB79 U6.MB81 U6.MB83 U6.MC2 U6.MD4 U6.ME72 U6.ME74 U6.ME78 U6.ME80 U6.ME82 U6.MF9 U6.MF13 U6.MF17 U6.MF21 U6.MF25 U6.MF27 U6.MF29 U6.MF31 U6.MF33 U6.MF35 U6.MF37 U6.MF39 U6.MF41 U6.MF43 U6.MF45 U6.MF47 U6.MF49 U6.MF51 U6.MF53 U6.MF55 U6.MF57 U6.MF59 U6.MF61 U6.MF63 U6.MF65 U6.MG67 U6.MG71 U6.MG75 U6.MG77 U6.MG79 U6.MG81 U6.MG83 U6.MH4 U6.MJ69 U6.MJ72 U6.MJ76 U6.MJ78 U6.MJ80 U6.MJ82 U6.MK5 U6.MK9 U6.MK65 U6.ML73 U6.ML75 U6.ML77 U6.ML79 U6.N65 U6.P72 U6.P74 U6.P78 U6.P80 U6.R4 U6.R7 U6.R11 U6.R15 U6.R19 U6.R23 U6.R26 U6.R28 U6.R30 U6.R32 U6.R34 U6.R36 U6.R38 U6.R40 U6.R42 U6.R44 U6.R46 U6.R48 U6.R50 U6.R52 U6.R54 U6.R56 U6.R58 U6.R60 U6.R62 U6.R64 U6.T67 U6.T71 U6.T75 U6.T77 U6.T81 U6.T83 U6.U65 U6.V69 U6.V72 U6.V76 U6.V78 U6.V82 U6.Y67 U6.Y71 U6.Y73 U6.Y75 U6.Y79 U6.Y81 U7.A2 U7.A8 U7.B2 U7.C9 U7.D2 U7.D8 U7.E1 U7.E3 U7.E8 U7.F1 U7.G8 U7.H1 U7.H9 U7.K1 U7.K9 U7.N1 U7.T1 U7.T7 U8.A2 U8.A8 U8.B2 U8.C9 U8.D2 U8.D8 U8.E1 U8.E3 U8.E8 U8.F1 U8.G8 U8.H1 U8.H9 U8.K1 U8.K9 U8.N1 U8.T1 U8.T7 U9.A2 U9.A8 U9.B2 U9.C9 U9.D2 U9.D8 U9.E1 U9.E3 U9.E8 U9.F1 U9.G8 U9.H1 U9.H9 U9.K1 U9.K9 U9.N1 U9.T1 U9.T7 U10.A2 U10.A8 U10.B2 U10.C9 U10.D2 U10.D8 U10.E1 U10.E3 U10.E8 U10.F1 U10.G8 U10.H1 U10.H9 U10.K1 U10.K9 U10.N1 U10.T1 U10.T7 U11.A2 U11.A8 U11.B2 U11.C9 U11.D2 U11.D8 U11.E1 U11.E3 U11.E8 U11.F1 U11.G8 U11.H1 U11.H9 U11.K1 U11.K9 U11.N1 U11.T1 U11.T7 U12.7 U13.7 U14.21 U14.27 U14.28 U14.57 U15.7 U16.4 U17.3 U18.7 U19.3 U21.2 U22.65 U23.8 U23.32 U23.33 U24.11 U24.12 U24.41 U25.11 U25.12 U25.41 U26.4 U27.4 U28.7 U29.7 U30.7 U31.7 U32.7 U33.1 U34.A1 U34.A16 U34.B14 U34.C8 U34.C11 U34.D2 U34.D3 U34.D6 U34.E2(REFGND__E2) U34.E6 U34.E13 U34.F3 U34.F15 U34.G3 U34.G8 U34.G10 U34.H7 U34.H14 U34.J10 U34.K1 U34.K3 U34.K7 U34.K9 U34.K16 U34.L14 U34.M4 U34.N9 U34.N12 U34.N15 U34.P3 U34.P7 U34.R13 U34.T1 U34.T10 U34.T16 U35.3(GND) U36.B3 U38.6 U38.13 U39.2 U40.11 U41.2 U42.11 U43.4 U46.4 U46.7 U47.1 U47.9 U51.4 U51.7 U52.1 U52.9 U53.2 U66.B2 U66.B6 U66.C3 U66.C4 U66.C5 U66.C6 U66.C7 U66.D5 U66.D6 U66.D7 U66.E5 U66.E6 U66.E7 U66.F5 U66.F6 U66.F7 U66.G6 U66.G7 U67.B2 U67.B6 U67.C3 U67.C4 U67.C5 U67.C6 U67.C7 U67.D5 U67.D6 U67.D7 U67.E5 U67.E6 U67.E7 U67.F5 U67.F6 U67.F7 U67.G6 U67.G7 U68.6 U68.7 U68.8 U68.15 U68.16 U68.17 U68.29 U68.30 U68.31 U68.32 U69.6 U69.7 U69.8 U69.15 U69.16 U69.17 U69.29 U69.30 U69.31 U69.32 U71.6 U71.7 U71.8 U71.15 U71.16 U71.17 U71.29 U71.30 U71.31 U71.32 U84.4 U84.8 U84.11 U85.4 U85.8 U85.11 U88.1 U88.2 U88.9 U103.B3 U103.C1 U103.E5(VSSQ2) U104.B3 U105.11 U106.11 U107.9 U107.25 U108.4 U108.8 U108.11 U114.A4 U114.A5 U114.B1 U114.B2 U114.C5 U114.D3 U114.D4 U114.D5 U114.E1 U114.E2 U114.F5 U114.G3 U114.G4 U114.G5 U114.H1 U114.H2 U114.J5 U114.K3 U114.K4 U114.L1 U114.L2 U116.B5 U116.C1 U116.C2 U116.D5 U117.A2 U117.A3 U117.A5 U117.A6 U117.B2 U117.B3 U117.B5 U117.B6 U117.C2 U117.C6 U117.D3 U117.D4 U117.D5 U117.E2 U117.E6 U117.F2 U117.F3 U117.F5 U117.F6 U117.G2 U117.G3 U117.G5 U117.G6 U118.A2 U118.A3 U118.A4 U118.A5 U118.A6 U118.A7 U118.A8 U118.B2 U118.B3 U118.B4 U118.B5 U118.B6 U118.B7 U118.C2 U118.C4 U118.C5 U118.C6 U118.C7 U118.C8 U118.D2 U118.D5 U118.E1 U118.E9 U118.F1 U118.F8 U118.G1 U118.G8 U118.G9 U118.H1 U118.H8 U118.H9 U118.J2 U118.J8 U118.K2 U118.K5 U118.K6 U118.K7 U118.K8 U118.L2 U118.L3 U118.L4 U118.L5 U118.L6 U118.L7 U118.M2 U118.M3 U118.M4 U118.M5 U118.M6 U118.M7 U118.M8 U119.40 U119.41(VSENSE1-) U119.53 U120.7 U120.8 U120.9 U120.17 U120.18 U120.19 U120.27 U120.31 U120.39 U120.40 U120.41 U121.7 U121.8 U121.9 U121.17 U121.18 U121.19 U121.27 U121.31 U121.39 U121.40 U121.41 U122.B3 U122.C3 U122.D3 U122.D4 U122.E3 U123.B3 U123.B4 U123.C3 U123.D3 U123.D4 U123.E3 U124.B3 U124.B4 U124.C3 U124.D3 U124.D4 U124.E3 U125.7 U125.8 U125.9 U125.17 U125.18 U125.19 U125.27 U125.31 U125.39 U125.40 U125.41 U126.7 U126.8 U126.9 U126.17 U126.18 U126.19 U126.27 U126.31 U126.39 U126.40 U126.41 U128.B3 U128.B4 U128.C3 U128.D3 U128.D4 U128.E3 U129.A1 U130.6 U130.17 U131.6 U131.17 U132.8 U132.11 U133.B3 U133.B4 U133.C3 U133.D3 U133.D4 U133.E3 U134.B3 U134.B4 U134.C3 U134.D3 U134.D4 U134.E3 U135.A3 U135.A4 U135.A5 U135.A6 U135.B1 U135.B3 U135.B4 U135.B5 U135.B6 U135.C1 U135.C2 U135.C3 U135.C4 U135.C5 U135.C6 U135.D2 U135.D3 U135.D4 U135.D5 U135.D6 U135.E5 U135.E6 U135.F5 U135.F6 U135.F7 U135.G5 U135.G6 U135.G7 U135.G8 U135.H5 U135.H6 U135.H7 U135.H8 U135.J2 U135.J3 U135.J4 U135.J5 U135.J6 U135.K2 U135.K3 U135.K4 U135.K5 U135.K6 U135.L1 U135.L3 U135.L4 U135.L5 U135.L6 U135.M3 U135.M4 U135.M5 U135.M6 U136.A2 U136.A3 U136.A4 U136.A5 U136.A6 U136.A7 U136.A8 U136.B2 U136.B3 U136.B4 U136.B5 U136.B6 U136.B7 U136.C2 U136.C4 U136.C5 U136.C6 U136.C7 U136.C8 U136.D2 U136.D5 U136.E1 U136.E9 U136.F1 U136.F8 U136.G1 U136.G8 U136.G9 U136.H1 U136.H8 U136.H9 U136.J2 U136.J8 U136.K2 U136.K5 U136.K6 U136.K7 U136.K8 U136.L2 U136.L3 U136.L4 U136.L5 U136.L6 U136.L7 U136.M2 U136.M3 U136.M4 U136.M5 U136.M6 U136.M7 U136.M8 U137.6 U137.7 U137.8 U137.15 U137.16 U137.17 U137.29 U137.30 U137.31 U137.32 U138.A4 U138.A5 U138.B1 U138.B2 U138.C5 U138.D3 U138.D4 U138.D5 U138.E1 U138.E2 U138.F5 U138.G3 U138.G4 U138.G5 U138.H1 U138.H2 U138.J5 U138.K3 U138.K4 U138.L1 U138.L2 U139.A4 U139.A5 U139.B1 U139.B2 U139.C5 U139.D3 U139.D4 U139.D5 U139.E1 U139.E2 U139.F5 U139.G3 U139.G4 U139.G5 U139.H1 U139.H2 U139.J5 U139.K3 U139.K4 U139.L1 U139.L2 U141.4 U142.B3 U142.B4 U142.C3 U142.D3 U142.D4 U142.E3 U143.6 U143.10 U143.12 U143.14 U143.26 U143.28 U143.41 U143.53 U143.56 U143.57 Y2.2 Y2.4 Y3.2 Y3.4 Y4.2
GND_CHS: C496.1 J8.6 J8.7 J8.8 J8.9 R375.1
GND_QSFPDD0_CAGE: B1.1 B1.2 B1.3 B1.4 B1.5 B1.6 B1.7 B1.8 B1.9(PIN9) B1.10 B1.11 B1.12 C279.1 R125.2
GND_QSFPDD1_CAGE: B2.1 B2.2 B2.3 B2.4 B2.5 B2.6 B2.7 B2.8 B2.9(PIN9) B2.10 B2.11 B2.12 C294.1 R130.2
GNDSENSE: C393.1 R221.1 U6.FJ39
PVCC: C1728.2 C7572.2 C7579.2 C7581.2 C7583.2 C7654.2 C7683.2 C7684.2 R5884.2 R6066.2 R6067.2 R6068.2 U116.A1 U116.B1(VOUT2_2) U116.D1 U116.E1 U120.28 U120.29 U121.28 U121.29 U125.28 U125.29 U126.28 U126.29
SVIN4: C808.1 R663.1 U68.3
SVIN5: C825.1 R673.1 U69.3
SVIN6: C1331.1 R949.1 U71.3
VBUS_5V: J8.1(VBUS) R382.1
VCC_HSSI_AGND: C7461.2 C7462.2 R768.2 R5948.2 R5949.1 R5950.1 R6170.1 ST13.1 U135.F9 U135.F10 U135.G9 U135.G10
VCC_HSSI_GXF_EN: R5940.2 R6231.1
VCC_HSSI_GXF_PG: D18.1(K) U34.D9
VCC_HSSI_GXR_EN: R6232.1 R6284.1
VCC_HSSI_GXR_PG: R6164.2 U34.F9 U135.D9 U135.J7
VCC_INT: C1456.1 U135.E7
VCCA_PLL_FLTR: C783.2 C784.1 C785.1 C1135.2 C1136.2 C1137.2 C1138.2 C1139.2 C1140.2 C1141.2 C1142.2 C1143.2 FB26.1 U6.BM44 U6.BM46 U6.BM48 U6.BM50 U6.JY44 U6.JY46 U6.JY48 U6.JY50
VCCCLK_GXR_EN: R6249.1 R6260.1 U129.B3
VCCCLK_GXR_PG: R6174.2 U34.T7 U129.C3
VCCE_PLL_DTS_GXR: C396.1 C1271.1 C1311.2 C1312.1 R923.2 TP985.1 U6.DJ33 U6.DM34 U6.ED60 U6.EG61 U132.9 U132.10
VCCED_AGND: C1345.2 C1347.2 C1348.2 R978.2 ST31.2 U66.A7
VCCED_GXR_EN: R979.2 R6239.1 U66.B4
VCCED_GXR_PG: R955.2 U34.P9 U66.B5
VCCED_SNS_N: R963.2 R964.1 U66.C2(VOUTS-)
VCCED_SNS_P: R961.1 U66.B1
VCCEPLL_EN: R916.2 R918.1 R6237.1 U132.3
VCCEPLL_PG: R920.1 U34.A9 U132.4
VCCERT_FGT_GXF_EN: R660.1 R662.2 R6233.1 U68.2
VCCERT_FGT_GXF_PG: R656.1 U34.P4 U68.26
VCCFUSE_GXR_PG: R6176.2 U34.P2 U131.5
VCCFUSEWR_EN: R6004.2 R6230.2
VCCFUSEWR_GXF: C397.1 C1043.2 C7559.2 TP997.1 U6.HC61 U6.HF62 U130.9 U130.10 U130.11 U130.12 U130.13 U130.14(VOUT5)
VCCFUSEWR_GXF_PG: R6175.2 U34.N5 U130.5
VCCFUSEWR_PG: R6223.2 U34.R1 U133.C2
VCCFUSEWR_SDM: C416.2 C1284.1 C7519.2 C7520.2 C7711.2 C7712.2 TP986.1 U6.HF56 U6.HM56 U133.C1 U133.D1 U133.D2 U133.E1 U133.E2(VOUT5)
VCCH_AGND: C1327.2 C1328.1 C1329.2 R944.2 ST30.2
VCCH_EN: R946.1 R948.2 R6235.1 U71.2
VCCH_FGT_GXF: C407.1 C408.1 C409.1 C1249.1 C1250.1 C1251.1 FB30.1 FB41.1 U6.FV66 U6.GA65 U6.GD66 U6.GF65 U6.GH66 U6.GP66 U6.GU65 U6.GY66
VCCH_PG: R942.1 U34.A4 U71.26
VCCL_HPS_AGND: C1366.2 C1368.2 C1369.2 R970.2 ST32.2 U67.A7
VCCL_HPS_EN: R977.2 R6236.1 U67.B4
VCCL_HPS_PG: R965.2 U34.M6 U67.B5
VCCL_HPS_SNS_N: R975.2 R976.1 U67.C2(VOUTS-)
VCCL_HPS_SNS_P: R973.1 U67.B1
VCCLSENSE: C393.2 R220.1 U6.FC39
VCCPLLDIG_HPS: C394.1 C395.1 C1244.2 C1245.2 FB1.2 U6.BV38 U6.CA39
VCCPLLDIG_SDM: C891.1 C892.1 C1269.2 C1270.2 FB29.2 U6.HY57 U6.JE57
VCCR_CORE: C1165.2 C1166.2 C1167.1 C7593.2 C7594.2 C7595.2 C7596.1 C7597.2 C7598.2 C7599.2 C7600.1 FB26.2 R5835.1 TP972.1 U6.CG41 U6.CG53 U6.CN41 U6.CN53 U6.CR54 U6.HY37 U6.HY39 U6.HY51 U6.JE39 U6.JE51 U118.A1 U118.B1 U118.C1 U118.D1 U118.J1 U118.K1 U118.L1 U118.M1
VCCR_CORE_AGND: C7663.1 R5848.1 R5853.1 R5854.1 R5923.1 R5924.2 R6156.1 ST6.1 U118.F5 U118.F6 U118.G5 U118.G6
VCCR_CORE_EN: R5850.2 R6240.1
VCCR_CORE_PG: D17.1(K) U34.R3
VCCRT_GXR_EN: R671.1 R672.2 R6234.1 U69.2
VCCRT_GXR_PG: R668.1 U34.P5 U69.26
VDD33_OUT1: C7766.1 R6261.2 R6265.2 R6269.2 U137.20
0P6V_VREF_DDR4_CH01: C1.1 C2.1 C47.1 C48.1 C93.1 C99.1 C100.1 C145.1 C146.1 C191.1 C417.1 C418.1 C419.1 C420.1 C983.1 TP990.1 U1.M1 U2.M1 U3.M1 U4.M1 U5.M1 U6.BM40 U6.BM42 U6.BM52 U6.BM54 U7.M1 U8.M1 U9.M1 U10.M1 U11.M1 U84.6
0P6V_VREF_DDR4_CH2: C248.1 C250.1 C997.1 C7435.1 C7436.1 C7437.1 C7438.1 J2.146 TP992.1 U6.JY40 U6.JY42 U85.6
0P6V_VREF_DDR4_CH3: C214.1 C223.1 C421.1 C422.1 C423.1 C424.1 C7433.1 J1.146 TP999.1 U6.JY52 U6.JY54 U108.6
0P6V_VTT_DDR4_CH01: C97.2 C195.2 C978.1 C979.1 C980.1 C984.1 CN1.1 CN1.2 CN1.3 CN1.4 CN2.1 CN2.2 CN2.3 CN2.4 CN3.1 CN3.2 CN3.3 CN3.4 CN4.1 CN4.2 CN4.3 CN4.4 CN5.1 CN5.2 CN5.3 CN5.4 CN6.1 CN6.2 CN6.3 CN6.4 R27.1 R34.2 R65.1 R72.2 R868.1 R869.1 R870.1 R871.1 R872.1 R873.1 R874.1 R875.1 R876.1 R877.1 R878.1 R879.1 R880.1 R881.1 R882.1 R883.1 R884.1 R885.1 R886.1 R887.1 R888.1 R889.1 R890.1 R891.1 R892.1 R893.1 R894.1 R895.1 R896.1 R897.1 R898.1 R899.1 R900.1 R901.1 R902.1 R903.1 R904.1 R905.1 R906.1 R907.1 R908.1 R909.1 R910.1 R911.1 R912.1 R913.1 R914.1 R915.1 TP989.1 U84.3 U84.5(VOSNS)
0P6V_VTT_DDR4_CH2: C246.2 C247.1 C249.1 C251.1 C260.1 C987.1 C988.1 C989.1 C990.1 C991.1 C992.1 C995.1 C996.1 J2.77 J2.221 TP991.1 U85.3 U85.5(VOSNS)
0P6V_VTT_DDR4_CH3: C212.2 C213.1 C215.1 C224.1 C226.1 C7423.1 C7424.1 C7425.1 C7426.1 C7427.1 C7428.1 C7431.1 C7432.1 J1.77 J1.221 TP998.1 U108.3 U108.5(VOSNS)
0P8V_VCC_HSSI_GXF: C1034.2 C1035.2 C1036.2 C1041.2 C1042.2 C1045.1 C1046.1 C1047.1 C1058.1 C1059.1 C1060.1 C1061.1 C1062.1 C1886.1 C1887.2 C1888.2 C1889.2 C7584.1 C7585.2 C7586.2 C7587.2 FB29.1 R5925.1 TP980.1 U6.EP60 U6.EU59 U6.FC59 U6.FF58 U6.FF60 U6.FJ59 U6.FM58 U6.FV58 U6.GA59 U6.GD58 U6.GD60 U6.GF59 U6.GH60 U6.GL59 U6.GP58 U6.GP60 U6.GY58 U6.GY60 U6.HY53 U6.HY55 U6.JE53 U6.JE55 U136.A1 U136.B1 U136.C1 U136.D1 U136.J1 U136.K1 U136.L1 U136.M1
0P8V_VCCH: C1144.2 C1145.2 C1146.2 C1147.2 C1148.2 C1149.2 C1150.2 C1151.2 C1152.2 C1153.2 C1154.2 C1155.2 C1168.2 C1169.2 C1170.2 C1171.2 C1172.2 C1173.2 C1174.2 C1175.2 C1176.2 C1177.2 C1178.2 C1179.2 C1180.1 C1181.1 C1182.1 C1183.1 C1184.1 C1185.1 C1338.2 C1339.2 C1340.1 C1341.1 C1342.1 C1343.1 C1449.1 L22.2 R952.1 TP979.1 U6.CY58 U6.DF36 U6.DM58 U6.DV36 U6.ED58 U6.EJ36 U6.EP58 U6.EY36 U6.FJ57 U6.FM36 U6.GA57 U6.GD36 U6.GL57 U6.GP36 U6.HC57 U6.HF36 U6.HV54
0P9V_VCC_HSSI_GXR: C1121.1 C1122.1 C1123.1 C1124.1 C1125.1 C1126.1 C1127.1 C1267.2 C1268.2 C1314.1 C1315.1 C1316.1 C1317.1 C1318.1 C1319.1 C1448.1 C7472.2 C7473.2 C7474.2 C7475.2 C7477.1 C7478.1 C7479.2 C7480.2 C7481.2 R6199.1 TP977.1 U6.CN61 U6.CR60 U6.CU59 U6.CU61 U6.CY60 U6.DJ59 U6.DJ61 U6.DM60 U6.DR33 U6.DR59 U6.DR61 U6.DV34 U6.DV60 U6.EA33 U6.EA35 U6.EA61 U6.ED34 U6.EG33 U6.EG35 U6.EP34 U6.EU33 U6.EU35 U6.EY34 U6.FC33 U135.A7 U135.A8 U135.A9 U135.A10 U135.B7 U135.B8 U135.B9 U135.B10 U135.B11 U135.B12 U135.C7 U135.C8 U135.C9 U135.D7 U135.K7 U135.K8 U135.K9 U135.K10 U135.K11 U135.L7 U135.L8 U135.L9 U135.L10 U135.L11 U135.L12 U135.M7 U135.M8 U135.M9 U135.M10
0P9V_VCCED_GXR: C1114.1 C1115.1 C1116.1 C1320.1 C1350.1 C1351.2 C1354.2 C1355.2 C1356.1 C1386.2 R961.2 TP973.1 U6.CY62 U6.DF62 U6.EJ32 U6.EP32 U66.A1 U66.A2 U66.A3 U66.A4 U66.A5 U66.F3 U66.G1 U66.G2 U66.G3
0P9V_VCCL_HPS: C1094.1 C1095.1 C1096.1 C1097.1 C1265.2 C1266.1 C1371.1 C1372.2 C1375.2 C1376.2 C1387.2 C1388.1 FB1.1 R973.2 TP974.1 U6.CG39 U6.CN37 U6.CN39 U6.CU37 U6.CU39 U67.A1 U67.A2 U67.A3 U67.A4 U67.A5 U67.F3 U67.G1 U67.G2 U67.G3
0P9V_VOSNS2+_U135: C7463.2 R6199.2 U135.A11 U135.M11
0P9V_VOSNS2-_U135: C7463.1 ST34.2 U135.A12 U135.M12
1P0V_VCCCLK_GXR: C353.2 C389.2 C1246.1 C1247.1 C1248.1 C7565.2 C7566.1 C7719.2 L26.2 R183.2 R195.2 R927.2 R6048.1 R6324.1 R6325.2 TP995.1 U6.DF32 U6.DM32 U6.ED62 U6.EJ62 U17.5 U19.5
1P0V_VCCERT_FGT_GXF: C815.1 C816.1 C817.1 C818.2 C819.1 C820.2 C1098.1 C1099.1 C1100.1 C1101.1 C1102.1 C1103.1 C1104.1 L20.2 R666.1 TP975.1 U6.FR63 U6.GA63 U6.GD62 U6.GD64 U6.GL63 U6.GP62 U6.GP64 U6.GU63
1P0V_VCCFUSE_GXR: C1279.2 C1280.2 C7562.2 TP996.1 U6.DJ31 U6.DM30 U6.ED64 U6.EG63 U131.9 U131.10 U131.11 U131.12 U131.13 U131.14(VOUT5)
1P0V_VCCFUSE_GXR_EN: R6253.2 U130.4 U131.4
1P0V_VCCRT_GXR: C832.2 C833.1 C834.2 C835.1 C837.1 C838.1 C1128.1 C1129.1 C1130.1 C1131.1 C1132.1 C1133.1 C1134.1 C1277.1 C1321.1 C1322.1 C1323.1 C1324.1 C1326.1 C1447.1 L21.2 R678.1 TP976.1 U6.DC65 U6.DF64 U6.DJ63 U6.DJ65 U6.DM64 U6.DR29 U6.DR63 U6.DR65 U6.DV30 U6.DV64 U6.EA29 U6.EA31 U6.EA65 U6.ED30 U6.EG29 U6.EG31 U6.EJ30 U6.EL29
1P2V_DDR4_CH01: C9.1 C10.1 C11.1 C12.1 C13.1 C14.1 C15.1 C16.1 C17.1 C18.1 C19.1 C20.1 C21.1 C22.1 C23.1 C24.1 C25.1 C26.2 C27.2 C28.1 C29.1 C30.1 C31.1 C32.1 C33.1 C34.1 C35.1 C36.1 C37.1 C38.1 C39.1 C40.1 C41.1 C42.1 C43.1 C44.1 C45.1 C46.1 C55.1 C56.1 C57.1 C58.1 C59.1 C60.1 C61.1 C62.1 C63.1 C64.1 C65.1 C66.1 C67.1 C68.1 C69.1 C70.1 C71.1 C72.2 C73.2 C74.1 C75.1 C76.1 C77.1 C78.1 C79.1 C80.1 C81.1 C82.1 C83.1 C84.1 C85.1 C86.1 C87.1 C88.1 C89.1 C90.1 C91.1 C92.1 C107.1 C108.1 C109.1 C110.1 C111.1 C112.1 C113.1 C114.1 C115.1 C116.1 C117.1 C118.1 C119.1 C120.1 C121.1 C122.1 C123.1 C124.2 C125.2 C126.1 C127.1 C128.1 C129.1 C130.1 C131.1 C132.1 C133.1 C134.1 C135.1 C136.1 C137.1 C138.1 C139.1 C140.1 C141.1 C142.1 C143.1 C144.1 C153.1 C154.1 C155.1 C156.1 C157.1 C158.1 C159.1 C160.1 C161.1 C162.1 C163.1 C164.1 C165.1 C166.1 C167.1 C168.1 C169.1 C170.2 C171.2 C172.1 C173.1 C174.1 C175.1 C176.1 C177.1 C178.1 C179.1 C180.1 C181.1 C182.1 C183.1 C184.1 C185.1 C186.1 C187.1 C188.1 C189.1 C190.1 C372.1 C481.1 C485.1 C487.1 C489.1 C557.1 C562.1 C981.1 C982.1 C1208.1 C1209.1 C1210.1 C1211.2 C1212.1 C1213.1 C1214.1 C1215.1 C1216.2 C1217.1 C1218.1 C1219.1 C1220.1 C1221.2 C1222.1 C1223.1 C1224.1 C1225.1 C1226.2 C1227.1 C1961.1 C1962.2 C1963.2 C1964.2 C7399.1 C7401.2 C7715.1 C7726.1 C7727.1 C7728.1 C7729.1 C7730.1 C7731.1 C7732.1 C7733.1 C7734.1 C7735.1 C7736.1 C7737.1 C7738.1 C7739.1 C7740.1 C7741.1 C7742.1 C7743.1 C7744.1 C7745.1 C7746.1 C7747.1 C7748.1 C7749.1 C7750.1 C7751.1 C7752.1 C7753.1 C7754.1 C7755.1 C7756.1 C7757.1 C7758.1 C7759.1 R22.1 R28.1 R29.1 R31.1 R60.1 R66.1 R67.1 R69.1 R321.1 R322.2 R323.2 R332.2 R335.2 R336.2 R337.1 R436.1 R437.1 R438.1 R439.1 R441.1 R442.1 R444.1 R457.1 R819.2 R2707.1 R2714.1 R6216.2 R6217.1 TP987.1 U1.A1 U1.A9 U1.B3 U1.B9 U1.C1 U1.D1 U1.D9 U1.F2 U1.F8 U1.G1 U1.G7 U1.G9 U1.J1 U1.J2 U1.J8 U1.J9 U1.L1 U1.L9 U1.R1 U1.T9 U2.A1 U2.A9 U2.B3 U2.B9 U2.C1 U2.D1 U2.D9 U2.F2 U2.F8 U2.G1 U2.G7 U2.G9 U2.J1 U2.J2 U2.J8 U2.J9 U2.L1 U2.L9 U2.R1 U2.T9 U3.A1 U3.A9 U3.B3 U3.B9 U3.C1 U3.D1 U3.D9 U3.F2 U3.F8 U3.G1 U3.G7 U3.G9 U3.J1 U3.J2 U3.J8 U3.J9 U3.L1 U3.L9 U3.R1 U3.T9 U4.A1 U4.A9 U4.B3 U4.B9 U4.C1 U4.D1 U4.D9 U4.F2 U4.F8 U4.G1 U4.G7 U4.G9 U4.J1 U4.J2 U4.J8 U4.J9 U4.L1 U4.L9 U4.R1 U4.T9 U5.A1 U5.A9 U5.B3 U5.B9 U5.C1 U5.D1 U5.D9 U5.F2 U5.F8 U5.G1 U5.G7 U5.G9 U5.J1 U5.J2 U5.J8 U5.J9 U5.L1 U5.L9 U5.R1 U5.T9 U6.BR41 U6.BR43 U6.BR45 U6.BR47 U6.BR49 U6.BR51 U6.BR53 U6.BR55 U6.CA41 U6.CA43 U6.CA45 U6.CA47 U6.CA49 U6.CA51 U6.CA53 U6.CA55 U6.HV56 U7.A1 U7.A9 U7.B3 U7.B9 U7.C1 U7.D1 U7.D9 U7.F2 U7.F8 U7.G1 U7.G7 U7.G9 U7.J1 U7.J2 U7.J8 U7.J9 U7.L1 U7.L9 U7.R1 U7.T9 U8.A1 U8.A9 U8.B3 U8.B9 U8.C1 U8.D1 U8.D9 U8.F2 U8.F8 U8.G1 U8.G7 U8.G9 U8.J1 U8.J2 U8.J8 U8.J9 U8.L1 U8.L9 U8.R1 U8.T9 U9.A1 U9.A9 U9.B3 U9.B9 U9.C1 U9.D1 U9.D9 U9.F2 U9.F8 U9.G1 U9.G7 U9.G9 U9.J1 U9.J2 U9.J8 U9.J9 U9.L1 U9.L9 U9.R1 U9.T9 U10.A1 U10.A9 U10.B3 U10.B9 U10.C1 U10.D1 U10.D9 U10.F2 U10.F8 U10.G1 U10.G7 U10.G9 U10.J1 U10.J2 U10.J8 U10.J9 U10.L1 U10.L9 U10.R1 U10.T9 U11.A1 U11.A9 U11.B3 U11.B9 U11.C1 U11.D1 U11.D9 U11.F2 U11.F8 U11.G1 U11.G7 U11.G9 U11.J1 U11.J2 U11.J8 U11.J9 U11.L1 U11.L9 U11.R1 U11.T9 U18.1(VL) U18.8 U28.1(VL) U30.1(VL) U31.1(VL) U31.8 U32.1(VL) U32.8 U40.2(VL) U42.2(VL) U84.2 U105.2(VL) U106.2(VL) U138.A1 U138.A2 U138.A3 U138.C1 U138.D1 U138.D2 U138.F1 U138.G1 U138.G2 U138.J1 U138.K1 U138.K2(VOUT4_3)
1P2V_DDR4_CH01_AGND: C1966.1 C7721.2 R6081.1 ST25.1 U138.F7
1P2V_DDR4_CH1_EN: R6080.2 R6244.1
1P2V_DDR4_CH01_PG: R6045.1 U34.E10 U138.C3
1P2V_DDR4_CH2: C199.1 C200.1 C201.1 C202.1 C203.1 C204.1 C205.1 C206.1 C207.1 C208.1 C209.1 C210.1 C211.1 C216.2 C217.2 C218.1 C219.1 C220.1 C221.1 C222.1 C225.1 C233.1 C234.1 C235.1 C236.1 C237.1 C238.1 C239.1 C240.1 C241.1 C242.1 C243.1 C244.1 C245.1 C252.2 C253.2 C254.1 C255.1 C256.1 C257.1 C258.1 C259.1 C309.1 C993.1 C994.1 C1186.1 C1187.1 C1188.1 C1189.2 C1190.1 C1191.1 C1192.1 C1193.1 C1194.2 C1195.1 C1196.1 C1197.1 C1198.1 C1199.2 C1200.1 C1201.1 C1202.1 C1203.1 C1204.2 C1205.1 C1255.2 C1256.2 C7429.1 C7430.1 C7609.1 C7610.2 C7611.2 C7612.2 C7716.1 J1.59 J1.61 J1.64 J1.67 J1.70 J1.73 J1.76 J1.80 J1.83 J1.85 J1.88 J1.90 J1.92 J1.204 J1.206 J1.209 J1.212 J1.215 J1.217 J1.220 J1.223 J1.226 J1.229 J1.231 J1.233 J1.236 J2.59 J2.61 J2.64 J2.67 J2.70 J2.73 J2.76 J2.80 J2.83 J2.85 J2.88 J2.90 J2.92 J2.204 J2.206 J2.209 J2.212 J2.215 J2.217 J2.220 J2.223 J2.226 J2.229 J2.231 J2.233 J2.236 R80.2 R81.2 R87.2 R91.2 R157.1 R825.2 R999.1 R1047.2 R1049.2 R2783.2 TP988.1 U6.JL39 U6.JL41 U6.JL43 U6.JL45 U6.JL47 U6.JL49 U6.JL51 U6.JL53 U6.JU39 U6.JU41 U6.JU43 U6.JU45 U6.JU47 U6.JU49 U6.JU51 U6.JU53 U12.1(VL) U12.8 U13.1(VL) U13.8 U15.1(VL) U15.8 U85.2 U108.2 U139.A1 U139.A2 U139.A3 U139.C1 U139.D1 U139.D2 U139.F1 U139.G1 U139.G2 U139.J1 U139.K1 U139.K2(VOUT4_3)
1P2V_DDR4_CH2_AGND: C7614.1 C7722.2 R6086.1 ST26.1 U139.F7
1P2V_DDR4_CH2_EN: R6085.2 R6245.1
1P2V_DDR4_CH2_PG: R6090.1 U34.R2 U139.C3
1P2V_PRE: C513.1 C514.1 C515.1 C516.1 C517.1 C518.1 C519.1 C520.1 C521.1 C522.1 C7523.2 C7524.2 C7707.2 C7708.2 L13.1 L14.1 TP984.1 U34.G7 U34.G9 U34.H8 U34.H9 U34.H10 U34.J7 U34.J8 U34.J9 U34.K8 U34.K10 U128.C1 U128.D1 U128.D2 U128.E1 U128.E2(VOUT5)
1P8V: C1232.2 C1233.2 C1234.2 C1235.2 C1236.2 C1237.2 C1238.2 C1239.1 C1240.1 C1241.1 C1242.1 C1243.1 C7619.1 C7620.2 C7621.2 C7622.2 C7717.1 FB30.2 FB31.2 FB32.2 FB33.2 FB41.2 TP981.1 U6.CR44 U6.CR46 U6.CR48 U6.CR50 U6.HV44 U6.HV46 U6.HV48 U6.HV50 U114.A1 U114.A2 U114.A3 U114.C1 U114.D1 U114.D2 U114.F1 U114.G1 U114.G2 U114.J1 U114.K1 U114.K2(VOUT4_3)
1P8V_AGND: C7624.1 C7720.2 R6093.1 ST18.1 U114.F7
1P8V_EN: R6092.2 R6238.1
1P8V_FLTR: C404.1 C405.2 C406.1 C1257.2 C1258.2 C1259.2 C1260.2 C1261.2 C1262.2 FB31.1 U6.BM38 U6.BR39 U6.HY59 U6.JE59 U6.JL59 U6.JU59
1P8V_MAIN_I2C_SCL: R6057.1 U6.N17 U34.J14 U141.2
1P8V_MAIN_I2C_SDA: R6058.1 U6.AD26 U34.J12 U141.3
1P8V_PG: R6097.1 U34.C9 U114.C3
1P8V_PRE: C390.1 C391.1 C547.1 C548.1 C549.1 C7192.2 C7394.1 C7395.1 C7396.1 C7397.1 C7398.1 C7638.2 C7639.2 C7706.2 C7709.2 R211.2 R212.2 R2637.1 R2653.1 R2654.1 R2699.2 R2700.2 R6192.1 TP983.1 U34.F13 U34.G13 U34.H13 U34.J13 U34.K13 U34.L13 U34.M13 U34.N10 U34.N11 U36.B4 U103.B4 U103.D1 U103.E4 U104.B4 U142.C1 U142.D1 U142.D2 U142.E1 U142.E2(VOUT5)
1P8V_SI52204: C456.1 C457.1 C458.1 C459.1 C460.1 C461.1 C462.1 C463.1 FB9.1 U23.5 U23.6 U23.15 U23.19 U23.24 U23.29 U23.31
1P8V_VCCCLK_GXF: C413.1 C414.1 C415.2 C1272.2 C1273.2 FB33.1 R145.2 R856.1 U6.HC65 U6.HF64
1P8V_VCCH_GXR: C410.1 C411.1 C412.2 C1111.1 C1112.1 C1113.1 C1325.1 FB32.1 U6.CG63 U6.CG65 U6.CK64 U6.CN65 U6.CR64 U6.CU63 U6.CU65 U6.EU29 U6.EU31 U6.EY30 U6.FC29 U6.FF30 U6.FJ29 U6.FJ31
2P5V: C3.1 C4.1 C5.2 C6.1 C7.1 C8.2 C49.1 C50.1 C51.2 C52.1 C53.1 C54.2 C94.1 C95.1 C96.2 C101.1 C102.1 C103.2 C104.1 C105.1 C106.2 C147.1 C148.1 C149.2 C150.1 C151.1 C152.2 C192.1 C193.2 C194.1 C197.1 C198.1 C227.2 C228.1 C229.1 C230.1 C231.1 C232.1 C261.2 C262.1 C263.1 C264.1 C483.1 C7653.2 C7666.2 C7725.2 FB6.2 FB13.2 J1.142 J1.143 J1.284 J1.286 J1.287 J2.142 J2.143 J2.284 J2.286 J2.287 R82.2 R83.2 R94.1 R98.2 R99.2 R100.2 R107.1 R291.2 R292.2 R293.2 R303.2 R329.2 R330.2 R994.2 R1068.2 R1069.2 TP1008.1 U1.B1 U1.R9 U2.B1 U2.R9 U3.B1 U3.R9 U4.B1 U4.R9 U5.B1 U5.R9 U7.B1 U7.R9 U8.B1 U8.R9 U9.B1 U9.R9 U10.B1 U10.R9 U11.B1 U11.R9 U12.14 U13.14 U29.1(VL) U29.8 U134.C1 U134.D1 U134.D2 U134.E1 U134.E2(VOUT5)
2P5V_AGND: C7652.2 R2785.1 ST27.1
2P5V_EN: R6172.2 R6241.1
2P5V_PG: R2788.1 U34.L8 U134.C2
2P5V_PRE: C7634.2 C7647.2 C7701.2 C7702.2 L11.1 L12.1 TP970.1 U124.C1 U124.D1 U124.D2 U124.E1 U124.E2(VOUT5)
2P5V_SI53254_2: C471.1 C472.1 C1395.1 C1396.1 C1397.1 C1398.1 FB13.1 U25.1(VDD_DIG) U25.4 U25.9 U25.15 U25.18 U25.25
3P3V: C977.2 C986.2 C7422.2 C7558.2 C7561.2 C7564.2 C7771.1 C7772.1 C7773.1 C7774.1 C7775.1 C7776.1 L30.2 R815.1 R816.1 R821.1 R822.1 R835.1 R838.2 R853.1 R918.2 R920.2 R2779.1 R2780.1 R5839.2 R5840.2 R5841.2 R5842.2 R5845.2 R5877.2 R5878.2 R5929.2 R5930.2 R5931.2 R5934.2 R5936.2 R5956.1 R5957.1 R5958.1 R5959.1 R6003.1 R6024.2 R6025.2 R6036.2 R6044.2 R6045.2 R6079.2 R6084.2 R6089.2 R6090.2 R6091.2 R6096.2 R6097.2 R6145.2 R6146.2 R6147.2 R6163.1 R6164.1 R6166.2 R6171.1 R6174.1 R6175.1 R6176.1 R6271.1 R6283.2 R6289.1 R6290.1 R6292.2 TP971.1 U84.10 U85.10 U87.5 U88.3 U108.10 U129.A3 U130.1 U130.2 U130.3 U130.15 U130.16 U131.1 U131.2 U131.3 U131.15 U131.16
3P3V_AGND: C7761.2 C7780.2 C7781.2 R6263.2 ST3.1
3P3V_EN: R6228.2 R6265.1 R6267.2 U137.2
3P3V_PG: R6261.1 U34.A3 U137.26
3P3V_STBY: C340.1 C500.1 C501.1 C512.1 C529.1 C530.1 C531.1 C532.1 C533.1 C534.1 C535.1 C536.1 C537.1 C538.1 C539.1 C540.1 C550.1 C551.1 C552.1 C553.1 C554.1 C555.1 C556.1 C558.1 C559.1 C560.1 C565.1 C570.1 C7400.1 C7402.1 C7403.1 C7404.1 C7575.2 C7632.2 C7641.2 C7698.2 C7699.2 EU1.1(VDD) EU2.1(VDD) FB16.2 J10.4 R147.2 R148.2 R158.1 R170.2 R171.2 R172.2 R173.2 R287.1 R362.2 R365.2 R366.2 R367.2 R384.2 R408.2 R409.2 R412.1 R415.2 R416.2 R423.2 R429.1 R430.1 R431.1 R435.1 R445.1 R453.2 R465.2 R481.1 R494.2 R498.2 R499.2 R2725.1 R2726.1 R2727.1 R2741.2 R2742.2 R6059.2 R6060.2 R6061.2 R6107.2 R6184.1 R6185.2 R6186.2 R6188.2 R6189.2 R6191.2 R6209.2 R6210.1 R6211.1 R6215.1 R6218.2 TP969.1 U16.8 U34.C7 U34.D7 U34.D8 U34.D10 U34.D11 U34.G4 U34.H4 U34.J4 U34.K4 U34.L4 U34.N6 U34.N7 U34.N8 U38.14(V+) U39.5(VCC) U40.19 U41.5(VCC) U105.19 U106.19 U107.21(VCC) U123.C1 U123.D1 U123.D2 U123.E1 U123.E2(VOUT5) U141.8(VCCB) Y4.4(VCC)
3P3V_USBPHY: C495.2 C502.1 C503.1 C504.1 C505.1 C506.1 C507.1 C508.1 C509.1 C510.1 FB16.1 R376.2 R377.2 R381.1 U33.4(VCC) U143.3 U143.7 U143.11 U143.17 U143.27 U143.32 U143.43 U143.55
24M_XTALIN: C497.1 U143.5 Y3.1
24M_XTALOUT: C7676.1 U143.4(XTALOUT) Y3.3
6301_AGND: C7567.2 C7569.2 C7718.2 R6049.1 ST28.2
ADC_VREF: C7405.1 C7406.1 TP1.1(TP) U34.E4
AVST8_CLK: R391.2 U6.MD64
AVST8_CLK_R: R391.1 U34.D14
AVST8_DATA0: U6.LN62 U34.C15
AVST8_DATA1: U6.KR63 U34.F16
AVST8_DATA2: U6.LR63 U34.D16
AVST8_DATA3: U6.MA64 U34.D15
AVST8_DATA4: U6.LW63 U34.B15
AVST8_DATA5: U6.MA62 U34.E15
AVST8_DATA6: U6.KW63 U34.E14
AVST8_DATA7: U6.KU62 U34.C14
AVST8_READY: U6.KJ63 U34.C16
AVST8_VALID_HPS_RSTN: R6280.2 U6.MC65 U34.B16
B_M10_CRC_ERROR: U6.J37 U105.8
BMC_BUF_TCK: R446.1 U34.A8
BMC_BUF_TDI: R447.1 U34.B6
BMC_BUF_TDO: U34.A7 U39.3
BMC_BUF_TMS: R440.1 U34.C6
BUF1_CLK0_N: C466.2 R986.1 U24.3
BUF1_CLK0_P: C465.2 R985.1 U24.2
BUF1_CLK1_N: C468.2 R988.1 U24.8
BUF1_CLK1_P: C467.2 R987.1 U24.7
BUF1_Q0_N: R929.2 U24.13
BUF1_Q0_P: R928.2 U24.14
BUF1_Q1_N: R931.2 U24.16
BUF1_Q1_P: R930.2 U24.17
BUF1_Q3_N: R6321.1 U24.23
BUF1_Q3_P: R6320.1 U24.24
BUF2_CLK0_N: C474.2 R996.1 U25.3
BUF2_CLK0_P: C473.2 R993.1 U25.2
BUF2_CLK1_N: C476.2 R998.1 U25.8
BUF2_CLK1_P: C475.2 R997.1 U25.7
BUF2_Q0_N: R933.2 U25.13
BUF2_Q0_P: R932.2 U25.14
BUF2_Q1_N: R935.2 U25.16
BUF2_Q1_P: R934.2 U25.17
BUF2_Q2_N: R6318.1 U25.21
BUF2_Q2_P: R6317.1 U25.22
BUFF1_IMP_SEL: R267.1 R268.1 U24.19
BUFF1_OE0N: R269.1 R270.1 U24.31
BUFF1_OE1N: R271.1 R272.1 U24.32
BUFF1_OE2N: R983.1 U24.36
BUFF1_OE3N: R984.1 U24.37
BUFF2_IMP_SEL: R994.1 R995.1 U25.19
BUFF2_OE0N: R293.1 R294.1 U25.31
BUFF2_OE1N: R303.1 R304.1 U25.32
BUFF2_OE2N: R291.1 U25.36
BUFF2_OE3N: R292.1 U25.37
CH01_RUN: C1966.2 R6079.1 R6080.1 R6081.2 U138.C6 U138.F6 U138.J6 U138.K7
CH02_RUN: C7614.2 R6084.1 R6085.1 R6086.2 U139.C6 U139.F6 U139.J6 U139.K7
CH23_RUN: C7624.2 R6091.1 R6092.1 R6093.2 U114.C6 U114.F6 U114.J6 U114.K7
CLK_100M_CXL_CONN_C_N: J6.B12 R186.1
CLK_100M_CXL_CONN_C_P: J6.B11 R185.1
CLK_CXL_CONN_N: C474.1 R186.2
CLK_CXL_CONN_P: C473.1 R185.2
CLK_DDR4_CH0_N: R230.1 R1050.1 U6.AK64
CLK_DDR4_CH0_P: R229.1 R1050.2 U6.AG63
CLK_DDR4_CH1_N: R1051.1 R1064.1 U6.AD32
CLK_DDR4_CH1_P: R1051.2 R1063.1 U6.AA31
CLK_DDR4_CH2_N: R232.1 R1052.1 U6.KR37
CLK_DDR4_CH2_P: R231.1 R1052.2 U6.KU36
CLK_DDR4_CH3_N: R1066.1 R1067.1 U6.LW43
CLK_DDR4_CH3_P: R1065.1 R1067.2 U6.MA44
CLK_MAX10_100M: R385.1 U34.P8
CLK_SYS_100M_N: R236.1 R1062.2 U6.L46
CLK_SYS_100M_P: R235.1 R1062.1 U6.N45
COMP_0P8: C7660.2 C7661.2 R5926.1 R6158.1 U136.H6
COMP_1P2: C2004.2 C7663.2 R5836.1 R6159.1 U118.H6
CORE_PMBUS_SCL: R308.1 R309.2 R313.2 R546.1 U26.2
CORE_PMBUS_SDA: R306.1 R310.2 R314.2 R547.1 U26.3
CPU_1V2_RESETN: U6.KW57 U42.6
CPU_RESETN: R365.1 R368.1 S1.2 U34.M8 U42.15
CXL_PERST1_N: J6.A29 R187.2
CXL_PERST2_N: J7.A11 R188.2
CXL_PERST3_N: J7.A29 R189.2
CXL_PERSTN: J6.A11 R187.1 R188.1 R189.1 R366.1 R370.1 R982.1 S3.2 U19.2
CXL_PRSNTX1_N: J6.A12 U18.13
CXL_PRSNTX4_N: J6.A30 U18.12
CXL_PRSNTX8_N: J7.A12 U18.11
CXL_PRSNTX16_N: J7.A30 U18.10
CXL_RX_N0: J6.A3 U6.AH10
CXL_RX_N1: J6.A6 U6.AU3
CXL_RX_N2: J6.A15 U6.BA10
CXL_RX_N3: J6.A18 U6.BK3
CXL_RX_N4: J6.A21 U6.BN10
CXL_RX_N5: J6.A24 U6.CB3
CXL_RX_N6: J6.A33 U6.CE10
CXL_RX_N7: J6.A36 U6.CP3
CXL_RX_N8: J7.A3 U6.CV10
CXL_RX_N9: J7.A6 U6.DG3
CXL_RX_N10: J7.A15 U6.DK10
CXL_RX_N11: J7.A18 U6.DW3
CXL_RX_N12: J7.A21 U6.EB10
CXL_RX_N13: J7.A24 U6.EM3
CXL_RX_N14: J7.A33 U6.ER10
CXL_RX_N15: J7.A36 U6.FD3
CXL_RX_P0: J6.A2 U6.AL8
CXL_RX_P1: J6.A5 U6.AP1
CXL_RX_P2: J6.A14 U6.BD8
CXL_RX_P3: J6.A17 U6.BG1
CXL_RX_P4: J6.A20 U6.BT8
CXL_RX_P5: J6.A23 U6.BW1
CXL_RX_P6: J6.A32 U6.CH8
CXL_RX_P7: J6.A35 U6.CL1
CXL_RX_P8: J7.A2 U6.DA8
CXL_RX_P9: J7.A5 U6.DD1
CXL_RX_P10: J7.A14 U6.DN8
CXL_RX_P11: J7.A17 U6.DT1
CXL_RX_P12: J7.A20 U6.EE8
CXL_RX_P13: J7.A23 U6.EH1
CXL_RX_P14: J7.A32 U6.EV8
CXL_RX_P15: J7.A35 U6.FA1
