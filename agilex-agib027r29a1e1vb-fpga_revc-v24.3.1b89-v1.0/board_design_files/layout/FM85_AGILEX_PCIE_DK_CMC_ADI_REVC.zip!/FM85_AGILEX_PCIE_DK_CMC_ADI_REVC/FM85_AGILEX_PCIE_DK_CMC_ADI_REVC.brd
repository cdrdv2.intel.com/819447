# Allegro board FM85_AGILEX_PCIE_DK_CMC_ADI_REVC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M10_1V2_VCCDPLL: length 0.3
  BOTTOM w0.381: v1(27.5,21.9) 27.31,21.72 C543.1
  vias: v1(26.5,29.9) v1(35.5,29.9) v1(35.5,20.9) v3(20.68,30.53) v3(21.29,30.53)
M10_CONF_DONE: length 107.1
  TOP w0.149: Q15.1 12.59,102.81 11.96,102.18 11.96,96.32 v1(10.83,95.19)
  L05_SIG2 w0.081: v1(29.5,28.9) 29,29.4 29,32.67 v1(27.76,33.9)
  L07_SIG3 w0.089: v1(27.76,33.9) 26.88,33.9 26.11,34.67 25.98,34.67 25.75,34.9 25.75,36.48 25.34,36.88 25.34,45.22 28.05,47.94 28.05,49.9 26.76,51.19 26.76,62.64 22.83,66.57 11.06,66.57 10.76,66.27 3.45,66.27 2.05,67.67 2.05,72.12 5.18,75.24 5.18,92.2 8.21,95.24 10.78,95.24 v1(10.83,95.19)
  vias: v1(13.83,103.32) v1(13.81,102.83)
M10_CRC_ERROR: length 129.6
  L03_SIG1 w0.081: v2(27.5,30.9) 27.9,30.5 27.9,27.28 28.12,27.06 28.12,26.71 28.56,26.27 28.65,26.27 28.87,26.06 28.87,25.8 28.87,25.79 28.87,24.7 28.6,24.44 28.6,24.13 28.87,23.86 28.87,22.4 29.12,22.14 29.12,21.73 29.39,21.47 31.66,21.47 32.12,21 32.12,20.75 32.41,20.46 32.41,20.14 34.23,18.32 34.23,16.12 34.66,15.68 38.29,15.68 38.69,16.08 39.61,16.08 40.01,16.48 41.38,16.48 41.49,16.37 42.7,16.37 42.86,16.22 43.7,16.22 v1(44.94,17.46)
  L05_SIG2 w0.081: v1(44.94,17.46) 45.99,18.51 47.99,18.51 48.12,18.39 55.51,18.39 58.5,15.39 62.49,15.39 63.19,14.69 114.34,14.69 119.56,19.92 119.56,25.3 122.75,28.49 125.37,28.49 127.77,30.89 v1(127.77,32.24)
  BOTTOM w0.149: R6191.1 127.78,32.23 v1(127.77,32.24) 127.85,32.32 U105.13
M10_GPIO0: length 204.5
  L05_SIG2 w0.081: v1(196.04,20.67) 196.04,20.34 196.43,19.95 196.43,19.84 196.43,19.84 196.43,19.51 196.28,19.36 196.28,18.34 194.41,16.47 194,16.47 193.51,15.99 187.55,15.99 186.18,14.62 182.98,14.62 180.58,17.02 180.58,18.17 179.22,19.53 175.6,19.53 174.91,18.83 166.95,18.83 166.11,18 166.11,17.51 165.9,17.29 165.4,17.29 164.63,16.52 164.65,16.5 164.65,16.21 164.45,16.01 164.12,16.01 164.08,15.97 117.39,15.97 115.03,13.6 62.04,13.6 61.28,14.36 60.87,14.36 60.63,14.6 60.11,14.6 59.87,14.36 58.51,14.36 57.76,15.11 57.76,15.21 54.82,18.15 48.03,18.15 47.9,18.28 46.49,18.28 45.3,17.09 44.79,17.09 44.2,17.68 44.2,18.19 44.89,18.88 44.89,19.9 44.5,20.3 44.5,22.08 43.9,22.67 43.9,25.16 45.05,26.31 45.05,29.81 45.98,30.74 46.06,30.74 47.06,31.74 47.06,42.74 46.25,43.55 46.25,43.87 45.78,44.33 44.99,44.33 43.52,45.8 43.52,49.48 v1(40.75,52.25)
M10_GPIO1: length 210.1
  L05_SIG2 w0.081: v1(40.77,50.5) 40.2,51.07 40.2,51.46 40.42,51.68 40.72,51.68 43.29,49.11 43.29,45.71 44.9,44.1 45.08,44.1 45.46,43.72 45.46,41.57 45.94,41.09 45.94,34.04 46.18,33.8 46.18,31.98 45.94,31.74 45.94,31.37 44.82,30.25 44.82,26.97 44.59,26.74 44.36,26.74 43.67,26.05 43.67,26.03 43.56,25.91 43.56,23.55 42.95,22.94 42.95,22.69 43.17,22.47 43.17,22.14 42.95,21.91 42.95,21.51 44.66,19.81 44.66,18.97 43.96,18.28 43.96,17.59 44.69,16.86 45.4,16.86 46.58,18.05 47.8,18.05 47.93,17.91 arc(47.94,17.91) 47.95,17.9 53.91,17.9 arc(53.93,17.9) 53.94,17.9 56.77,15.06 arc(56.82,15.02) 56.87,14.99 arc(56.97,14.92) 57.04,14.82 arc(57.07,14.77) 57.11,14.72 57.65,14.18 arc(57.68,14.15) 57.72,14.13 arc(57.72,14.12) 57.73,14.12 59.94,14.12 arc(59.95,14.12) 59.96,14.12 60.21,14.37 60.53,14.37 60.77,14.13 61.19,14.13 61.94,13.37 115.16,13.37 117.17,15.39 130.76,15.39 131.02,15.13 162.56,15.13 163.21,15.78 165.06,15.78 165.78,16.49 165.9,16.49 166.11,16.71 166.11,16.83 167.32,18.03 170,18.03 170.52,18.55 175.04,18.55 175.78,19.3 179.12,19.3 180.38,18.04 180.38,16.89 182.88,14.39 186.28,14.39 187.58,15.69 194.33,15.69 196.66,18.02 196.66,18.7 196.94,18.99 196.94,19.65 197.44,20.15 197.44,20.57 v1(196.69,21.32)
  BOTTOM w0.149: v1(40.77,50.5) 41.4,51.12 U40.12
M10_IBUS_CLK0: length 127.9
  L03_SIG1 w0.081: v1(118.71,41.91) 118.71,41.72 117.89,40.9 117.76,40.9 117.3,40.44 116.96,40.44 116.5,39.98 116.17,39.98 115.95,39.76 115.95,36.72 118.36,34.31 118.36,32.07 118.9,31.53 118.9,31.53 118.97,31.45 118.97,30.36 119.02,30.31 119.02,30.26 119.4,29.89 119.4,26.61 119.18,26.39 119.18,19.31 119.44,19.05 119.44,18.85 v1(120.09,18.2)
  L16_SIG6 w0.081: v1(120.09,18.2) 119.34,17.44 119.34,16.33 119.94,15.73 123.07,15.73 123.42,15.39 126.69,15.39 128.27,13.8 128.27,13.22 128.55,12.94 128.55,10.83 126.92,9.21 79.18,9.21 78.8,9.59 61.82,9.59 60.36,11.05 56.58,11.05 55.8,11.84 55.32,11.84 51.33,15.83 51.32,15.83 49.5,17.65 v1(47.23,17.65)
M10_IBUS_CLK1: length 21.1
  L03_SIG1 w0.081: v1(133.08,37.16) 133.41,37.49 133.41,38.38 133.01,38.78 132.9,38.78 132.44,39.24 132.1,39.24 131.83,39.51 131.83,40.22 131.61,40.44 131.35,40.44 130.71,41.08 130.51,41.08 130.05,41.54 129.51,41.54 129.22,41.82 128.89,41.82 128.43,42.28 128.09,42.28 127.63,42.74 127.37,42.74 126.91,43.2 126.44,43.2 125.99,43.66 125.52,43.66 125.24,43.38 124.93,43.38 124.65,43.66 123.93,43.66 123.65,43.38 123.34,43.38 123.06,43.66 122.33,43.66 122.05,43.38 121.77,43.38 121.15,42.75 120.79,42.75 120.3,42.26 v1(120.3,41.91)
  BOTTOM w0.149: v1(133.08,37.16) 133.37,36.87 U105.1
M10_IBUS_CS0_N: length 101.2
  L07_SIG3 w0.089: v1(46.78,15.77) 46.78,16.39 48.2,17.81 53.76,17.81 55.23,19.28 57.26,19.28 59.43,21.45 62.89,21.45 69.16,15.18 115.67,15.18 115.76,15.27 115.8,15.27 117.08,16.55 117.08,29.94 118.1,30.96 118.1,32.12 118.34,32.36 v1(118.34,35.72)
  BOTTOM w0.149: v1(118.34,35.72) 119.1,36.49 119.1,38.05 119.12,38.06 119.12,38.39 119.1,38.41 119.1,38.97 119.12,38.98 119.12,39.31 119.1,39.33 119.1,39.77 119.51,40.18 v1(119.51,40.53)
M10_IBUS_CS1_N: length 26.1
  L14_SIG5 w0.081: v1(122.78,30.65) 122.7,30.73 122.7,31.26 122.46,31.51 122.46,32.01 122.7,32.26 122.7,35.21 122.27,35.63 122.27,39.07 122.27,39.07 122.27,39.3 122.05,39.52 121.82,39.52 121.1,40.24 v1(121.1,40.53)
  BOTTOM w0.149: U105.5 134.49,34.27 133.86,33.64 133.86,32.78 131.32,30.24 123.72,30.24 123.33,30.64 122.79,30.64 v1(122.78,30.65)
M10_MISO_0: length 100.3
  L07_SIG3 w0.089: v1(47.39,16.42) 47.71,16.74 49.03,16.74 49.46,17.17 53.47,17.17 54.64,18.35 57.57,18.35 58.43,19.2 58.43,19.73 58.43,20.11 59.53,21.21 62.79,21.21 69.03,14.97 115.76,14.97 115.85,15.06 115.89,15.06 117.29,16.46 117.29,29.72 118.37,30.8 118.37,32.05 118.58,32.26 118.58,32.46 118.58,34.64 118.93,34.99 118.93,35.3 118.71,35.52 118.71,35.56 118.71,35.57 118.71,35.88 118.71,35.88 118.71,37.07 118.33,37.46 118.33,39.68 v1(118.71,40.07)
M10_MISO_1: length 26.7
  L14_SIG5 w0.081: v1(122.1,30.65) 121.92,30.83 121.92,31.28 121.86,31.34 121.86,35.51 121.46,35.91 121.46,37.6 121.47,37.61 121.47,38.9 121.14,39.24 120.95,39.24 120.73,39.45 120.73,39.64 v1(120.3,40.07)
  BOTTOM w0.149: U105.4 134.38,34.92 133.33,33.86 133.33,32.67 131.21,30.56 124.38,30.56 123.86,31.08 122.54,31.08 v1(122.1,30.65)
M10_MOSI_0: length 126.1
  L14_SIG5 w0.081: v1(119.51,41.45) 119.51,41.05 119.94,40.63 119.94,40.22 119.93,40.22 119.93,34.9 120.32,34.51 120.32,21.8 120.19,21.67 120.19,20.59 120.32,20.46 120.32,19.2 v1(120.24,19.12)
  L16_SIG6 w0.081: v1(120.24,19.12) 120.49,18.87 120.49,18.09 120.22,17.82 120.04,17.82 119.82,17.6 119.82,17.55 119.73,17.46 119.73,17.15 120.97,15.92 123.23,15.92 123.54,15.61 126.8,15.61 128.52,13.88 128.52,13.3 128.78,13.04 128.78,10.74 127.02,8.98 78.78,8.98 78.55,9.21 60.55,9.21 58.95,10.82 55.93,10.82 55.8,10.95 55.51,10.95 55.24,11.22 55.24,11.53 53.89,12.88 53.02,12.88 52.27,13.63 52.27,14.53 51.94,14.85 51.62,14.85 51.54,14.78 50.95,14.78 48.89,16.83 46.97,16.83 46.74,17.06 v1(46.22,17.06)
M10_MOSI_1: length 32.8
  L07_SIG3 w0.089: v1(137.47,36.39) 137.22,36.39 137,36.61 136.96,36.61 135.98,37.59 135.98,37.77 135.6,38.14 135.51,38.14 135.07,38.59 135.07,41.06 135.67,41.66 135.67,42.46 134.34,43.79 134.34,44.24 133.53,45.04 133.09,45.04 132.46,45.67 132.1,45.67 131.85,45.93 131.85,46.65 131.62,46.88 131.3,46.88 130.63,47.55 130.52,47.55 130.25,47.82 129.48,47.82 129.21,47.55 128.93,47.55 128.66,47.82 128.14,47.82 127.66,47.34 127.35,47.34 126.89,47.8 126.52,47.8 126.03,47.3 125.44,47.3 124.77,46.63 124.15,46.63 123.65,46.13 123.43,46.13 122.8,45.5 122.38,45.5 121.92,45.04 121.74,45.04 121.36,44.66 121.03,44.66 120.73,44.36 120.73,41.82 v1(121.1,41.45)
  BOTTOM w0.149: U105.3 136.81,35.57 137.42,36.17 137.42,36.39 137.47,36.39 137.47,36.39 v1(137.47,36.39)
M10_VCCINT: length 1.1
  BOTTOM w0.381: v1(28.5,27.9) 29.5,27.9 L14.2
MAIN_I2C_SCL: length 355.2
  TOP w0.149: R258.1 44.04,33.42 v1(44.02,33.43) ; v1(235.95,20.8) 236.03,20.71 R621.1 ; v1(43.49,21.86) 43.66,21.69 U141.7 ; v1(58.62,18.75) 58.24,19.13 U22.16
  TOP w0.225: R309.1 v1(18.51,102.88)
  L03_SIG1 w0.081: v1(43.49,21.86) 43.9,22.27 43.9,23 44.13,23.23 44.13,23.23 44.83,23.93 44.83,28.74 42.46,31.11 42.46,33.05 43.11,33.7 43.76,33.7 v1(44.02,33.43)
  L07_SIG3 w0.089: v1(208.87,29.56) 208.74,29.68 207.08,29.68 204.48,27.08 192.84,27.08 192.57,26.81 177.08,26.81 170.71,20.44 170.39,20.44 170.17,20.22 170.17,19.9 169.48,19.21 169.48,19.11 169.26,18.89 169,18.89 168.73,18.62 168.73,18.19 167.01,16.47 165.45,16.47 165.13,16.8 164.12,16.8 163.63,16.31 162.75,16.31 162.19,15.74 138.29,15.74 138.02,16.01 137.67,16.01 132.89,16.01 132.37,16.53 131.22,16.53 129.54,14.86 129.54,13.37 128.83,12.66 127.27,12.66 125.77,11.16 125.77,10.96 125.15,10.34 123.74,10.34 122.79,11.29 122.78,11.29 122.43,11.64 121.91,11.64 121.56,11.29 120.68,11.29 120.4,11.56 97.79,11.56 97.39,11.96 94.65,11.96 94.24,11.56 74.44,11.56 73.48,10.6 72.99,10.6 72.03,11.56 62.46,11.56 61.01,13.01 61.01,14.01 60.32,14.7 60.32,17.05 v1(58.62,18.75)
  L12_SIG4 w0.089: v1(58.62,18.75) 58.27,18.4 57.61,18.4 57.56,18.35 57.55,18.35 57.36,18.15 48.09,18.15 47.62,18.62 45.56,18.62 44.96,19.22 44.96,19.53 43.49,21 v1(43.49,21.86) ; v1(208.87,29.56) 209.44,29.56 209.65,29.77 219.71,29.77 221.73,31.79 231.51,31.79 234.6,28.7 234.6,22.14 v1(235.95,20.8)
  L16_SIG6 w0.081: v1(29.85,95.33) 29.39,95.79 28.23,95.79 20.62,103.4 19.64,103.4 19.64,103.4 19.09,103.4 18.57,102.88 v1(18.51,102.88) 18.12,102.49 18.12,99.93 17.29,99.1 16.35,99.1 16.12,98.87 16.12,97.93 10.06,91.87 10.06,57.35 10.3,57.11 10.3,57.1 13.57,53.83 15,53.83 15.69,53.15 29.1,53.15 30.09,52.15 30.09,51.8 30.32,51.56 30.72,51.56 37.11,45.18 38.32,45.18 39.48,44.03 v1(39.48,43.36)
  BOTTOM w0.149: v1(39.48,43.36) 39.94,42.9 39.94,42.49 40.26,42.17 40.28,42.17 41.85,40.61 41.85,36.44 42.02,36.27 42.02,35.13 43.03,34.12 43.34,34.12 v1(44.02,33.43) ; R324.2 v1(29.85,95.33) ; U27.7 v1(18.51,102.88)
MAIN_I2C_SDA: length 363.7
  TOP w0.149: v1(59.69,20.83) 59.68,20.83 U22.18 ; U141.6 44.31,21.45 44.45,21.6 44.86,21.6 v1(45.1,21.84) ; R622.1 240.61,20.71 v1(240.62,20.71) ; v1(41.57,35.82) 41.85,35.53 41.85,35.36 42.69,34.52 42.69,33.61 42.89,33.42 R261.1
  TOP w0.225: R310.1 v1(19.78,102.88)
  L07_SIG3 w0.089: v1(41.57,35.82) 41.22,35.47 41.22,34.73 41.39,34.55 41.39,33.47 42.45,32.41 42.45,29.88 41.77,29.2 41.77,27.63 42.36,27.03 42.36,26.2 43.01,25.55 43.24,25.55 45.64,23.15 45.64,22.38 v1(45.1,21.84) ; v1(209.35,30) 207.02,30 204.34,27.32 192.74,27.32 192.51,27.09 176.73,27.09 169.28,19.64 168.95,19.64 168.73,19.42 168.73,19.11 168.74,19.1 168.05,18.41 168.05,18.3 167.78,18.04 167.52,18.04 167.3,17.82 167.3,17.66 166.92,17.28 162.89,17.28 161.58,15.97 138.38,15.97 138.15,16.21 138.12,16.21 138.1,16.23 137.58,16.23 133,16.23 132.48,16.74 131.1,16.74 129.3,14.94 129.3,13.47 128.77,12.94 127.21,12.94 125.53,11.26 125.53,11.12 124.99,10.58 123.9,10.58 122.6,11.88 121.81,11.88 121.5,11.57 120.73,11.57 120.5,11.8 97.89,11.8 97.49,12.2 94.53,12.2 94.17,11.84 63.57,11.84 60.6,14.82 60.6,19.92 v1(59.69,20.83)
  L12_SIG4 w0.089: v1(45.1,21.84) 45.8,21.14 51.31,21.14 51.82,21.65 58.87,21.65 v1(59.69,20.83) ; v1(240.62,20.71) 240.62,19.26 240.22,18.85 235.96,18.85 234.21,20.61 234.21,28.75 231.41,31.55 222.08,31.55 220.14,29.61 220.14,29.02 219.74,28.62 209.14,28.62 208.38,29.38 208.38,29.73 208.65,30 v1(209.35,30)
  L16_SIG6 w0.081: v1(39.35,42.67) 39.87,43.2 39.87,44.17 38.48,45.56 37.26,45.56 30.88,51.94 30.88,52.21 29.71,53.38 15.79,53.38 15.1,54.07 13.66,54.07 10.53,57.2 10.53,67.32 10.97,67.76 10.97,89.43 10.53,89.88 10.53,91.93 18.91,100.31 18.91,102.01 v1(19.78,102.88) 20.5,102.88 28.06,95.33 v1(28.84,95.33)
  BOTTOM w0.149: v1(41.57,35.82) 41.57,36.22 41.44,36.35 41.44,40.58 40.16,41.87 40.13,41.87 39.35,42.65 v1(39.35,42.67) ; U27.6 18.91,103.75 v1(19.78,102.88) ; R325.2 v1(28.84,95.33)
MAIN_PMBUS_EN: length 102.4
  L03_SIG1 w0.127: v1(14.17,58.63) 13.7,59.1 13.7,62.78 14.32,63.4 19.96,63.4 21.85,65.29 21.85,76.02 24.43,78.6 24.43,86.55 24.14,86.84 24.14,91.56 24.86,92.27 24.86,101.67 22.5,104.03 20.61,104.03 v1(20.41,104.23)
  L07_SIG3 w0.127: v1(24.95,39.99) 24,39.99 23.37,40.63 23.37,49.42 15.47,57.32 15.47,57.78 15.23,58.03 14.77,58.03 v1(14.17,58.63)
  L14_SIG5 w0.127: v1(37.5,32.9) 36.21,34.19 35.84,34.19 35.47,34.56 35.47,35 34.7,35.78 34.7,38.28 34.32,38.65 28.47,38.65 27.91,38.09 26.13,38.09 25.52,38.69 25.52,39.42 v1(24.95,39.99)
  BOTTOM w0.127: v1(14.17,58.63) 13.53,59.26 SW4.3 ; U27.5 19.08,104.23 v1(20.41,104.23)
MAX10_VCCA_2.5V:
  vias: v1(27.5,29.9) v1(27.5,22.9) v1(34.5,28.9) v1(34.5,21.9) v3(23.15,35.26) v3(23.15,34.62)
MAX10_VCCA_ADC_2.5V: length 7.9
  BOTTOM w0.254: v1(27.5,28.9) 27.01,29.39 24.19,29.39 23.96,29.62 L12.2
MAX_SDA: length 17.6
  TOP w0.149: v1(30.09,18.37) 31.03,18.37 U34.T9
  BOTTOM w0.149: v1(19.95,21.99) 19.95,18.88 20.31,18.51 22.22,18.51 24.29,16.44 28.58,16.44 28.9,16.76 28.9,18.24 29.08,18.43 30,18.43 30.06,18.37 v1(30.09,18.37)
MSEL0: length 123.9
  L14_SIG5 w0.081: v1(3.25,80.34) 3.85,80.95 3.85,85.66 7.25,89.05 16.21,89.05 16.81,89.65 18,89.65 18.33,89.32 27.36,89.32 27.72,88.97 33.67,88.97 35.74,91.04 38.57,91.04 39.05,91.52 56.42,91.52 58.51,89.43 61.52,89.43 65.83,85.12 68.42,85.12 69.36,86.05 89.88,86.05 94.3,81.63 98.34,81.63 98.75,81.21 98.75,81.14 100.54,79.36 100.54,77.74 100.62,77.66 101.79,77.66 101.83,77.7 102.14,77.7 102.18,77.66 102.43,77.66 102.64,77.46 102.71,77.46 103.24,76.93 103.9,76.93 104.22,77.24 104.52,77.24 104.84,76.93 105.28,76.93 105.58,76.62 105.58,76.13 105.38,75.93 105.13,75.93 104.37,75.17 v1(104.37,75.03)
  BOTTOM w0.149: v1(3.25,80.34) R199.1 3.82,81.93 3.82,82.12 4.45,82.76 SW2.1
MSEL1: length 122.3
  L12_SIG4 w0.089: v1(102.78,80.55) 100.91,80.55 100.45,81.02 99.94,81.02 99.48,80.55 99.18,80.55 97.56,82.17 88.19,82.17 83.55,86.81 77.52,86.81 75.87,88.46 75.4,88.46 75.17,88.69 75.17,89.17 73.84,90.49 70.98,90.49 66.59,94.88 66.59,96.59 64.92,98.26 61.53,98.26 59.39,96.12 44.3,96.12 44.11,95.92 42.83,95.92 42.63,96.12 35.37,96.12 35.03,95.78 35.03,95.78 34.76,95.51 34.76,95.51 33.46,94.21 33.46,91.42 31.6,89.56 28.12,89.56 27.15,90.53 22.6,90.53 21.28,89.21 12.21,89.21 8.3,85.3 3.34,85.3 2.85,84.8 2.85,82.92 3.25,82.52 v1(3.25,82.5)
  BOTTOM w0.149: v1(3.25,82.5) R200.1 3.75,84.03 SW2.2
MSEL2: length 2.6
  BOTTOM w0.149: SW2.3 4.45,85.55 R201.1 v1(3.25,84.53)
MSEL2_FPGA_NCATTRIP: length 209.5
  L03_SIG1 w0.081: v1(30.49,79.3) 30.06,78.87 30.06,78.42 30.28,78.2 32.95,78.2 38.73,72.42 38.73,63.06 37.71,62.04 37.71,52.71 40.33,50.09 40.33,49.65 39.32,48.64 39.32,46.57 38.54,45.79 38.54,44.27 38.17,43.89 38.17,36.22 37.04,35.08 37.04,27.89 37.87,27.06 37.87,26.98 38.5,26.35 v2(38.5,24.9)
  L12_SIG4 w0.089: v1(2.36,84.53) 1.96,84.14 1.96,83.35 2.19,83.12 2.3,83.12 2.75,82.67 2.75,82.34 3.28,81.81 7.87,81.81 11.02,84.96 15.4,84.96 15.75,84.61 26.25,84.61 26.76,84.09 26.76,83.43 27.72,82.47 28.73,82.47 29.07,82.12 29.07,80.64 30.42,79.3 v1(30.49,79.3)
  L14_SIG5 w0.081: v1(101.98,78.25) 101.35,78.88 101.35,80.28 99.25,82.38 94.11,82.38 90.2,86.29 69.26,86.29 68.32,85.35 65.92,85.35 61.61,89.66 59.11,89.66 56.93,91.84 39.05,91.84 38.48,91.27 35.56,91.27 33.49,89.2 27.81,89.2 27.46,89.56 18.85,89.56 18.31,90.1 14.61,90.1 13.79,89.29 6.94,89.29 2.36,84.7 v1(2.36,84.53)
Net_46:
  vias: v1(119.51,37.77)
Net_47:
  vias: v1(122.7,39.61)
Net_48:
  vias: v1(109.15,75.95)
Net_61:
  vias: v1(32.5,32.9)
Net_62:
  vias: v1(133.05,39.15)
Net_63:
  vias: v1(125.09,44.67)
Net_64:
  vias: v1(137.84,39.15)
Net_65:
  vias: v1(127.48,46.05)
Net_66:
  vias: v1(35.5,32.9)
Net_138: length 1.7
  BOTTOM w0.149: v1(14.05,54.46) 14.03,54.49 12.33,54.49
Net_245:
  vias: v1(34.5,26.9)
Net_532:
  vias: v1(105.96,43.75)
Net_533:
  vias: v1(104.37,38.23)
Net_534:
  vias: v1(105.96,46.51)
Net_535:
  vias: v1(103.57,39.61)
Net_536:
  vias: v1(108.35,37.77)
Net_537:
  vias: v1(109.95,39.61)
Net_538:
  vias: v1(116.32,37.77)
Net_539:
  vias: v1(115.52,38.23)
Net_545:
  vias: v1(114.73,40.53)
Net_546:
  vias: v1(115.52,40.07)
Net_547:
  vias: v1(113.13,40.53)
Net_548:
  vias: v1(116.32,41.45)
Net_549:
  vias: v1(112.34,40.07)
Net_550:
  vias: v1(113.93,40.07)
Net_551:
  vias: v1(114.73,41.45)
Net_552:
  vias: v1(112.34,41.91)
Net_553:
  vias: v1(113.13,41.45)
Net_554:
  vias: v1(115.52,41.91)
Net_555:
  vias: v1(113.93,41.91)
Net_556:
  vias: v1(116.32,40.53)
Net_571:
  vias: v1(123.49,41.91)
Net_572:
  vias: v1(125.09,43.75)
Net_576:
  vias: v1(128.27,39.15)
Net_577:
  vias: v1(105.96,74.11)
Net_579:
  vias: v1(108.35,72.73)
Net_580:
  vias: v1(113.14,78.25)
Net_581:
  vias: v1(112.34,78.71)
Net_582:
  vias: v1(111.54,78.25)
Net_583:
  vias: v1(113.93,76.87)
Net_584:
  vias: v1(114.73,77.33)
Net_826:
  vias: v1(90.63,61.14)
Net_827:
  vias: v1(89.76,60.64)
Net_828:
  vias: v1(90.63,59.14)
Net_829:
  vias: v1(89.76,58.64)
Net_830:
  vias: v1(90.63,57.14)
Net_831:
  vias: v1(89.76,56.64)
Net_832:
  vias: v1(90.63,55.14)
Net_833:
  vias: v1(89.76,54.64)
Net_835:
  vias: v1(132.26,55.25)
Net_836:
  vias: v1(133.05,54.79)
Net_838:
  vias: v1(132.26,66.29)
Net_839:
  vias: v1(133.05,65.83)
Net_1819:
  vias: v1(101.98,73.65)
Net_1820:
  vias: v1(101.18,74.11)
Net_1821:
  vias: v1(101.98,74.57)
Net_1822:
  vias: v1(101.98,72.73)
Net_1823:
  vias: v1(129.07,69.97)
Net_1824:
  vias: v1(129.07,72.73)
Net_1825:
  vias: v1(133.05,72.27)
Net_1826:
  vias: v1(129.87,71.35)
Net_1827:
  vias: v1(129.07,71.81)
Net_1828:
  vias: v1(130.68,69.98)
Net_1829:
  vias: v1(131.46,70.44)
Net_1830:
  vias: v1(132.26,73.65)
Net_1831:
  vias: v1(133.05,74.11)
Net_1832:
  vias: v1(131.46,74.11)
Net_1833:
  vias: v1(129.07,73.65)
Net_1834:
  vias: v1(129.87,74.11)
Net_1835:
  vias: v1(130.66,72.73)
Net_1836:
  vias: v1(131.46,72.27)
Net_1837:
  vias: v1(131.46,71.35)
Net_1838:
  vias: v1(129.87,70.43)
Net_1839:
  vias: v1(109.15,75.03)
Net_1840:
  vias: v1(108.35,73.65)
Net_1841:
  vias: v1(107.56,72.27)
Net_1842:
  vias: v1(105.17,73.65)
Net_1843:
  vias: v1(108.35,76.41)
Net_1844:
  vias: v1(107.56,74.11)
Net_1845:
  vias: v1(109.15,72.27)
Net_1846:
  vias: v1(121.9,38.23)
Net_1847:
  vias: v1(117.91,41.45)
Net_1848:
  vias: v1(110.74,39.15)
Net_1849:
  vias: v1(111.54,39.61)
Net_1850:
  vias: v1(110.74,43.75)
Net_1851:
  vias: v1(110.74,46.51)
Net_1852:
  vias: v1(107.56,39.15)
Net_1853:
  vias: v1(108.35,39.61)
Net_1854:
  vias: v1(115.52,46.51)
Net_1855:
  vias: v1(109.15,39.15)
Net_1856:
  vias: v1(112.34,39.15)
Net_1857:
  vias: v1(113.13,39.61)
Net_1858:
  vias: v1(113.93,39.15)
Net_1859:
  vias: v1(107.56,38.23)
Net_1860:
  vias: v1(109.15,38.23)
Net_1861:
  vias: v1(109.95,37.77)
Net_1862:
  vias: v1(110.74,38.23)
Net_1863:
  vias: v1(111.54,37.77)
Net_1864:
  vias: v1(112.34,38.23)
Net_1865:
  vias: v1(113.13,37.77)
Net_1866:
  vias: v1(115.52,43.75)
Net_1867:
  vias: v1(113.93,38.23)
Net_1868:
  vias: v1(114.73,37.77)
Net_1869:
  vias: v1(116.32,39.61)
Net_1870:
  vias: v1(104.37,39.15)
Net_1871:
  vias: v1(109.15,41.91)
Net_1872:
  vias: v1(101.18,47.43)
Net_1873:
  vias: v1(126.68,48.35)
Net_1874:
  vias: v1(127.48,48.81)
Net_1875:
  vias: v1(126.68,47.43)
Net_1876:
  vias: v1(142.66,43.1)
Net_1877:
  vias: v1(131.46,48.35)
Net_1878:
  vias: v1(143.53,42.6)
Net_1879:
  vias: v1(130.66,48.81)
Net_1880:
  vias: v1(132.26,50.65)
Net_1881:
  vias: v1(129.87,48.35)
Net_1882:
  vias: v1(132.26,49.73)
Net_1883:
  vias: v1(129.07,48.81)
Net_1884:
  vias: v1(141.84,39.6)
Net_1885:
  vias: v1(128.27,48.35)
Net_1886:
  vias: v1(136.6,42.6)
Net_1887:
  vias: v1(133.05,49.27)
Net_1888:
  vias: v1(133.05,48.35)
Net_1890:
  vias: v1(131.46,47.43)
Net_1892:
  vias: v1(127.48,46.97)
Net_1893:
  vias: v1(137.47,43.1)
Net_1894:
  vias: v1(133.05,47.43)
Net_1895:
  vias: v1(138.33,42.6)
Net_1896:
  vias: v1(131.46,49.27)
Net_1897:
  vias: v1(141.8,42.6)
Net_1898:
  vias: v1(132.26,48.81)
Net_1899:
  vias: v1(132.26,46.97)
Net_1900:
  vias: v1(131.46,40.07)
Net_1901:
  vias: v1(135.44,40.53)
Net_1902:
  vias: v1(132.26,40.53)
Net_1903:
  vias: v1(134.65,40.07)
Net_1904:
  vias: v1(132.26,41.45)
Net_1905:
  vias: v1(133.05,41.91)
Net_1906:
  vias: v1(131.46,41.91)
Net_1907:
  vias: v1(138.63,40.53)
Net_1908:
  vias: v1(128.27,47.43)
Net_1909:
  vias: v1(133.85,40.53)
Net_1910:
  vias: v1(129.07,46.97)
Net_1911:
  vias: v1(133.05,40.07)
Net_1912:
  vias: v1(133.05,44.67)
Net_1913:
  vias: v1(137.04,41.45)
Net_1916:
  vias: v1(98.42,60.64)
Net_1918:
  vias: v1(100.39,65.37)
Net_1919:
  vias: v1(99.59,65.83)
Net_1920:
  vias: v1(98.42,61.64)
Net_1921:
  vias: v1(100.39,69.05)
Net_1922:
  vias: v1(99.59,68.59)
Net_1923:
  vias: v1(100.39,67.21)
Net_1924:
  vias: v1(100.39,68.13)
Net_1925:
  vias: v1(99.59,63.99)
Net_1926:
  vias: v1(99.59,64.91)
Net_1927:
  vias: v1(97.56,60.14)
Net_1928:
  vias: v1(97.56,59.14)
Net_1929:
  vias: v1(99.59,60.31)
Net_1930:
  vias: v1(99.59,61.23)
Net_1931:
  vias: v1(97.56,55.14)
Net_1932:
  vias: v1(96.69,55.64)
Net_1933:
  vias: v1(106.76,49.73)
Net_1936:
  vias: v1(108.35,49.73)
Net_1937:
  vias: v1(109.15,49.27)
Net_1938:
  vias: v1(99.59,49.27)
Net_1939:
  vias: v1(100.38,49.73)
Net_1940:
  vias: v1(102.77,48.35)
Net_1941:
  vias: v1(99.59,48.35)
Net_1942:
  vias: v1(103.57,47.89)
Net_1943:
  vias: v1(101.98,47.89)
Net_1944:
  vias: v1(130.66,68.99)
Net_1945:
  vias: v1(133.05,63.99)
Net_1946:
  vias: v1(132.26,64.45)
Net_1947:
  vias: v1(129.06,69.02)
Net_1948:
  vias: v1(129.07,68.13)
Net_1949:
  vias: v1(132.26,62.61)
Net_1950:
  vias: v1(133.05,62.15)
Net_1951:
  vias: v1(126.68,68.58)
Net_1952:
  vias: v1(127.49,69.03)
Net_1953:
  vias: v1(131.46,68.59)
Net_1954:
  vias: v1(128.27,68.59)
Net_1955:
  vias: v1(140.06,59.6)
Net_1956:
  vias: v1(140.93,60.1)
Net_1957:
  vias: v1(140.06,69.6)
Net_1958:
  vias: v1(140.93,70.1)
Net_1959:
  vias: v1(142.66,71.1)
Net_1960:
  vias: v1(143.53,70.6)
Net_1961:
  vias: v1(140.06,71.6)
Net_1962:
  vias: v1(140.93,72.1)
Net_1963:
  vias: v1(142.66,73.1)
Net_1964:
  vias: v1(143.53,72.6)
Net_1965:
  vias: v1(140.06,73.6)
Net_1966:
  vias: v1(140.93,74.1)
Net_1967:
  vias: v1(142.66,75.1)
Net_1968:
  vias: v1(143.53,74.6)
Net_1969:
  vias: v1(142.66,61.1)
Net_1970:
  vias: v1(143.53,60.6)
Net_1971:
  vias: v1(140.06,61.6)
Net_1972:
  vias: v1(140.93,62.1)
Net_1974:
  vias: v1(143.53,62.6)
Net_1975:
  vias: v1(140.06,63.6)
Net_1976:
  vias: v1(140.93,64.1)
Net_1977:
  vias: v1(142.66,65.1)
Net_1978:
  vias: v1(143.53,64.6)
Net_1979:
  vias: v1(140.06,65.6)
Net_1980:
  vias: v1(140.93,66.1)
Net_1981:
  vias: v1(142.66,67.1)
Net_1982:
  vias: v1(143.53,66.6)
Net_1983:
  vias: v1(140.06,67.6)
Net_1984:
  vias: v1(140.93,68.1)
Net_1985:
  vias: v1(142.66,69.1)
Net_1986:
  vias: v1(143.53,68.6)
Net_1987:
  vias: v1(134.87,59.6)
Net_1988:
  vias: v1(135.73,60.1)
Net_1989:
  vias: v1(134.87,69.6)
Net_1990:
  vias: v1(135.73,70.1)
Net_1991:
  vias: v1(137.47,71.1)
Net_1992:
  vias: v1(138.33,70.6)
Net_1993:
  vias: v1(134.87,71.6)
Net_1994:
  vias: v1(135.73,72.1)
Net_1995:
  vias: v1(137.47,73.1)
Net_1996:
  vias: v1(138.33,72.6)
Net_1997:
  vias: v1(134.87,73.6)
Net_1998:
  vias: v1(135.73,74.1)
Net_1999:
  vias: v1(137.47,75.1)
Net_2000:
  vias: v1(138.33,74.6)
Net_2001:
  vias: v1(137.47,61.1)
Net_2002:
  vias: v1(138.33,60.6)
Net_2003:
  vias: v1(134.87,61.6)
Net_2004:
  vias: v1(135.73,62.1)
Net_2005:
  vias: v1(137.47,63.1)
Net_2006:
  vias: v1(138.33,62.6)
Net_2007:
  vias: v1(134.87,63.6)
Net_2008:
  vias: v1(135.73,64.1)
Net_2009:
  vias: v1(137.47,65.1)
Net_2010:
  vias: v1(138.33,64.6)
Net_2011:
  vias: v1(134.87,65.6)
Net_2012:
  vias: v1(135.73,66.1)
Net_2013:
  vias: v1(137.47,67.1)
Net_2014:
  vias: v1(138.33,66.6)
Net_2015:
  vias: v1(134.87,67.6)
Net_2016:
  vias: v1(135.73,68.1)
Net_2017:
  vias: v1(137.47,69.1)
Net_2018:
  vias: v1(138.33,68.6)
Net_2019:
  vias: v1(127.48,68.13)
Net_2020:
  vias: v1(133.05,61.23)
Net_2021:
  vias: v1(132.26,61.69)
Net_2022:
  vias: v1(132.26,65.37)
Net_2023:
  vias: v1(133.05,64.91)
Net_2024:
  vias: v1(132.26,51.57)
Net_2025:
  vias: v1(133.05,56.63)
Net_2026:
  vias: v1(132.26,57.09)
Net_2027:
  vias: v1(130.66,50.65)
Net_2028:
  vias: v1(130.66,52.49)
Net_2029:
  vias: v1(133.05,52.03)
Net_2030:
  vias: v1(132.26,52.49)
Net_2031:
  vias: v1(131.46,52.95)
Net_2032:
  vias: v1(127.48,49.73)
Net_2033:
  vias: v1(132.26,54.33)
Net_2034:
  vias: v1(131.46,52.03)
Net_2035:
  vias: v1(125.09,51.11)
Net_2036:
  vias: v1(125.88,52.49)
Net_2037:
  vias: v1(128.27,49.27)
Net_2038:
  vias: v1(107.56,66.75)
Net_2039:
  vias: v1(108.35,50.65)
Net_2040:
  vias: v1(125.88,69)
Net_2041:
  vias: v1(125.09,52.03)
Net_2043:
  vias: v1(104.37,72.27)
Net_2044:
  vias: v1(105.96,71.35)
Net_2048:
  vias: v1(105.96,67.67)
Net_2049:
  vias: v1(105.17,66.29)
Net_2050:
  vias: v1(100.39,71.81)
Net_2051:
  vias: v1(99.59,72.27)
Net_2052:
  vias: v1(104.37,71.35)
Net_2053:
  vias: v1(103.57,70.89)
Net_2054:
  vias: v1(102.77,68.59)
Net_2056:
  vias: v1(101.18,71.35)
Net_2057:
  vias: v1(102.77,72.27)
Net_2058:
  vias: v1(103.57,69.97)
Net_2061:
  vias: v1(101.18,70.43)
Net_2062:
  vias: v1(105.17,67.21)
Net_2063:
  vias: v1(104.37,67.67)
Net_2064:
  vias: v1(101.98,69.97)
Net_2065:
  vias: v1(101.98,70.89)
Net_2066:
  vias: v1(103.57,69.05)
Net_2067:
  vias: v1(104.37,68.59)
Net_2068:
  vias: v1(105.17,68.13)
Net_2069:
  vias: v1(107.55,65.84)
Net_2071:
  vias: v1(132.26,53.41)
Net_2073:
  vias: v1(109.15,50.19)
Net_2074:
  vias: v1(129.07,51.57)
Net_2075:
  vias: v1(129.87,49.27)
Net_2076:
  vias: v1(125.88,49.73)
Net_2077:
  vias: v1(127.48,51.57)
Net_2078:
  vias: v1(128.27,51.11)
Net_2079:
  vias: v1(127.48,50.65)
Net_2080:
  vias: v1(126.68,52.03)
Net_2081:
  vias: v1(126.68,49.27)
Net_2082:
  vias: v1(125.88,48.81)
Net_2083:
  vias: v1(133.05,53.87)
Net_2084:
  vias: v1(125.88,68.13)
Net_2085:
  vias: v1(126.68,51.11)
Net_2086:
  vias: v1(125.88,51.57)
Net_2087:
  vias: v1(125.88,50.65)
Net_2088:
  vias: v1(133.05,52.95)
Net_2090:
  vias: v1(133.05,51.11)
Net_2091:
  vias: v1(130.66,49.73)
Net_2092:
  vias: v1(129.87,51.11)
Net_2093:
  vias: v1(129.07,49.73)
Net_2094:
  vias: v1(129.07,50.65)
Net_2095:
  vias: v1(90.63,81.14)
Net_2097:
  vias: v1(143.41,80.09)
Net_2098:
  vias: v1(134,76.02)
Net_2099:
  vias: v1(135.73,76.02)
Net_2100:
  vias: v1(134.87,75.6)
Net_2101:
  vias: v1(140.06,75.6)
Net_2102:
  vias: v1(128.27,67.67)
Net_2587:
  vias: v1(5.93,37.65)
Net_2594:
  vias: v1(29.06,39.19)
Net_2595:
  vias: v1(29.06,37.92)
Net_2596:
  vias: v1(17.18,39.09)
Net_2597:
  vias: v1(17.18,37.82)
Net_2624:
  vias: v1(68.76,74.44)
Net_2625:
  vias: v1(67.49,74.44)
Net_2627:
  vias: v1(64.95,74.44)
Net_2636:
  vias: v1(216.67,101.84)
Net_2643:
  vias: v1(74.54,54.42)
Net_2644:
  vias: v1(70.73,54.42)
Net_2646:
  vias: v1(74.54,55.69)
NIOS_UART_RX: length 67.8
  L05_SIG2 w0.081: v1(39.48,37.31) 39.48,34.88 38.83,34.23 38.83,33.25 38.45,32.87 38.45,31.47 38.87,31.06 38.87,30.63 38.62,30.39 37.22,30.39 37.12,30.3 37.12,28.75 36.83,28.46 35.05,28.46 v1(34.5,27.9)
  L16_SIG6 w0.081: J14.2 4.04,41.83 4.04,45.8 6.1,47.86 9.21,47.86 12.96,44.11 22.81,44.11 25.71,41.21 25.71,39.13 26.73,38.11 27.9,38.11 28.57,38.78 38.74,38.78 39.48,38.04 v1(39.48,37.31)
  BOTTOM w0.149: J14.2 1.31,39.1 1.31,35.92 R6211.2
NIOS_UART_TX: length 61
  L16_SIG6 w0.081: v1(36.49,32.9) 36.93,32.46 38.22,32.46 38.88,31.8 v1(39.4,31.8) 39.91,32.31 39.91,35.26 36.62,38.55 34.64,38.55 28.86,38.55 28.16,37.86 26.61,37.86 25.45,39.02 25.45,41.04 22.61,43.87 12.83,43.87 9.13,47.57 6.24,47.57 4.34,45.66 4.34,39.67 2.42,37.75 J14.1
  BOTTOM w0.149: J14.1 2.47,37.62 R6210.2
OVERTEMPN: length 85.8
  L14_SIG5 w0.081: v1(196.04,19.67) 196.04,17.98 195.89,17.83 195.89,16.26 197.08,15.08 200.97,15.08 201.47,14.57 203.21,14.57 203.84,15.19 207.06,15.19 208.83,13.42 215.05,13.42 215.43,13.81 241.39,13.81 251.6,24.01 251.6,37.71 251.29,38.02 251.29,38.34 251.6,38.65 251.6,40.75 251.29,41.06 251.29,41.39 251.6,41.7 251.6,43.9 v1(251.72,44.02)
PCIE_1V2_CLKREQN: length 20.8
  BOTTOM w0.149: R157.2 98.29,33.15 U15.5 101.4,33.15 103.55,35.29 108.8,35.29 109.04,35.06 112.26,35.06 114.09,36.88 114.09,37.7 114.43,38.04 114.43,38.41 114.32,38.52 114.32,38.85 114.73,39.26 v1(114.73,39.61)
PCIE_CLK_LOS: length 49.6
  TOP w0.149: v1(31.5,21.9) 31.99,22.4 36.78,22.4 36.97,22.21 36.97,19.58 37.16,19.39 38.7,19.39 v1(39.21,19.9) ; U24.10 60.42,36.34 60.57,36.19 v1(60.7,36.19)
  L03_SIG1 w0.081: v1(42.87,34.93) 42.87,34.42 41.29,32.84 41.29,30.97 41.92,30.35 41.92,27.86 42.35,27.43 42.35,26.56 43.1,25.82 43.1,24.47 42.42,23.79 42,23.79 41.22,23.01 41.22,21.91 v1(39.21,19.9)
  BOTTOM w0.149: v1(39.21,19.9) 39.21,19.39 R2740.1 ; v1(42.87,34.93) 43.18,34.61 53.29,34.61 54.61,35.94 55.97,35.94 56.55,35.36 59.96,35.36 60.41,35.82 60.41,35.91 v1(60.7,36.19)
PCIE_CLKREQN: length 74.8
  TOP w0.149: 58.83,9.37 58.17,10.03 C319.1 57.77,10.56 57.59,10.74 57.59,11.11 v1(56.93,11.77)
  TOP w0.17: 58.83,9.37 58.83,6.58 58.65,6.4 J5.B12
  L05_SIG2 w0.081: v1(59.98,19.48) 61.89,21.39 65.22,21.39 65.55,21.07 66.57,21.07 66.86,21.36 71.58,21.36 73.29,23.07 73.53,23.07 73.64,22.96 77.23,22.96 78.83,24.57 80.68,24.57 81.02,24.91 81.33,24.91 81.67,24.57 96.31,24.57 97.53,25.78 97.53,30.64 99.21,32.32 v1(103.19,32.32)
  L16_SIG6 w0.081: v1(59.98,19.48) 59.86,19.36 59.86,18.57 58.79,17.5 58.32,17.5 57.11,16.29 57.11,11.94 v1(56.93,11.77)
  BOTTOM w0.149: v1(56.93,11.77) 56.93,11.32 57.69,10.56 C319.1 ; U15.10 104.29,33.15 103.46,32.32 v1(103.19,32.32)
PCIE_EP_3P3V:
  vias: v4(52.33,8.33) v4(52.33,7.44) v4(53.09,8.33) v4(53.09,7.44) v4(53.09,6.43)
PCIE_EP_3V3_WAKEN: length 70
  TOP w0.149: v1(55.52,12.4) 55.14,12.02 55.14,11.84 R152.2
  L05_SIG2 w0.081: v1(58.83,19.57) 59.41,19.57 61.47,21.63 64.15,21.63 65.77,23.25 68.55,23.25 68.84,22.96 72.36,22.96 73.42,24.03 73.42,24.29 73.64,24.5 78.22,24.5 79.02,25.31 79.31,25.31 79.4,25.4 79.79,25.4 79.82,25.37 81.63,25.37 82.23,24.78 82.53,24.78 83.13,25.37 91.79,25.37 92.39,24.78 92.69,24.78 93.29,25.37 96.1,25.37 96.56,25.83 96.56,30.1 99.37,32.91 v1(106.73,32.91)
  L16_SIG6 w0.081: v1(58.83,19.57) 58.78,19.57 55.56,16.35 55.56,13.66 55.9,13.32 55.9,12.78 v1(55.52,12.4)
  BOTTOM w0.149: v1(55.52,12.4) 55.08,11.96 55.08,11.91 R155.2 ; U15.11 106.32,32.5 v1(106.73,32.91)
PCIE_EP_12V: length 1.3
  BOTTOM w0.225: v1(244.36,69.55) 244.29,69.61 R503.2
  BOTTOM w0.381: R487.1 v1(216.14,88.6)
  vias: v4(46.49,8.71) v4(46.49,8.08) v4(46.49,7.44) v4(46.49,6.81) v4(46.49,6.17) v4(47.12,8.71) v4(47.12,8.08) v4(47.12,7.44) v4(47.12,6.81) v4(47.12,6.17) v4(47.76,8.71) v4(47.76,8.08) v4(47.76,7.44) v4(47.76,6.81) v4(47.76,6.17) v4(48.39,8.71) v4(48.39,8.08) v4(48.39,7.44) v4(241.1,32.95) v7(207.93,73.51) v7(207.93,72.55) v7(208.19,71.49) v7(208.85,71.03) v7(208.9,73.51) v7(208.9,72.55) v7(209.47,71.64) v7(209.81,71.04)
PCIE_EP_JTAG_TCK: length 12.4
  BOTTOM w0.149: R451.1 46.74,10.68 v1(47.25,10.68) 47.25,9.63 47.38,9.5 47.65,9.5 47.8,9.65 47.8,10.14 47.93,10.26 48.23,10.26 48.36,10.14 48.36,10.12 48.51,9.97 50.16,9.97 50.32,9.81 50.32,9.45 50.15,9.27 49.56,9.27 49.38,9.1 49.38,8.59 49.65,8.32 49.65,7.77 49.38,7.5 49.38,7.04 49.65,6.77 J5.A5
PCIE_EP_JTAG_TDI: length 11.4
  L14_SIG5 w0.081: v1(51.7,10.56) 51.12,9.98 49.86,9.98 49.17,10.68 v1(48.55,10.68)
  BOTTOM w0.149: v1(51.7,10.56) 51.04,9.9 51.04,9.44 50.45,8.85 50.45,5.95 50.65,5.74 J5.A6 ; v1(48.55,10.68) 49.04,10.68 R445.2
PCIE_EP_JTAG_TDO: length 12.5
  BOTTOM w0.149: v1(50.88,14.35) 50.82,14.33 arc(50.79,14.31) 50.77,14.3 arc(50.62,14.14) 50.52,13.95 50.37,13.6 arc(50.35,13.53) 50.34,13.45 50.34,12.69 50.67,12.36 51.72,12.36 52.2,11.88 52.2,9.98 51.53,9.31 51.53,8.52 51.06,8.05 51.06,5.97 51.65,5.38 J5.A7
PCIE_EP_JTAG_TMS: length 12.6
  L14_SIG5 w0.081: v1(54.56,13.16) 54.9,12.81 54.9,11.03 54.43,10.56 v1(52.71,10.56)
  BOTTOM w0.149: R435.2 54.56,12.64 v1(54.56,13.16) ; J5.A8 52.48,4.27 52.48,6.17 51.7,6.96 51.7,8.26 51.83,8.39 51.83,8.94 52.71,9.82 v1(52.71,10.56)
PCIE_EP_PERSTN: length 164
  L12_SIG4 w0.089: v1(196.75,14.07) 196.43,13.75 193.43,13.75 192.03,15.15 190.42,15.15 190.08,14.8 186.13,14.8 185.46,14.13 179.16,14.13 178.37,14.92 177.79,14.92 177.11,14.25 136.02,14.25 134.83,13.05 132.71,13.05 131.05,11.39 127.81,11.39 125.76,9.35 80.33,9.35 79.67,10 79.34,10 79.26,9.92 56.27,9.92 v1(55.63,10.56)
  BOTTOM w0.149: R1000.1 56.83,12.4 56.42,11.99 56.42,10.9 56.07,10.56 v1(55.63,10.56) 55.46,10.38 55.46,4.3 J5.A11 ; v1(196.75,14.07) 196.23,14.59 196.23,16.04 194.47,17.8 194.47,20.09 194.67,20.29 195.38,20.29 195.49,20.17 U107.11
PCIE_EP_PRSNT_N: length 149.7
  L05_SIG2 w0.081: v1(176.89,14.82) 175.53,13.45 134.72,13.45 133.27,12 133.27,10.58 132.86,10.17 132.58,10.17 132.25,9.84 129.65,9.84 126.42,6.61 60.28,6.61 57.83,9.07 57.57,9.24 49.94,9.24 48.97,10.21 v1(45.94,10.21)
  BOTTOM w0.149: v1(176.89,14.82) 176.48,15.23 SW1.3 ; SW1.3 SW1.2 SW1.1 ; SW1.3 SW1.4 ; v1(45.94,10.21) 45.94,9.69 45.8,9.55 45.8,4.25 J5.A1
PCIE_EP_PRSNT_NX1: length 135.9
  TOP w0.17: v1(61.48,10.49) 63.65,8.31 J5.B17
  L07_SIG3 w0.089: v1(177.09,23.65) 174.91,23.65 171.76,20.5 171.24,20.5 170.97,20.23 170.97,19.91 170.67,19.61 170.39,19.61 169.53,18.76 169.53,18.36 169.26,18.09 169,18.09 167.13,16.21 164.69,16.21 164.46,15.98 164.15,15.98 164.04,16.09 162.83,16.09 162.28,15.53 138.2,15.53 137.93,15.8 137.76,15.8 132.6,15.8 132.3,16.1 131.94,16.1 131.45,15.61 131.45,14.88 131.42,14.85 131.38,14.85 130.47,13.94 130.47,13.94 129.64,13.12 129.64,13.07 128.53,11.96 127.76,11.96 125.86,10.05 123.67,10.05 122.33,11.39 122.01,11.39 121.45,10.84 120.56,10.84 120.32,10.6 97.86,10.6 96.76,11.69 94.94,11.69 93.41,10.16 80.36,10.16 79.57,10.95 78.58,10.95 77.79,10.16 61.81,10.16 v1(61.48,10.49)
  BOTTOM w0.149: v1(177.09,23.65) 177.09,23.66 175.8,23.66 175.21,24.24 SW1.5
PCIE_EP_PRSNT_NX4: length 118.8
  TOP w0.17: C331.1 v1(79.51,9.6) 77.65,7.75 J5.B31
  L07_SIG3 w0.089: v1(177.03,24.31) 177.13,24.31 177.5,23.93 177.5,23.51 177.07,23.07 174.97,23.07 172.11,20.21 172.11,16.99 171.11,15.98 169.7,15.98 169.48,16.2 169.48,16.51 169.26,16.73 168.95,16.73 168.73,16.51 168.73,16.2 168.52,15.98 164.84,15.98 164.6,15.75 164.05,15.75 163.92,15.88 162.92,15.88 162.36,15.32 138.11,15.32 137.84,15.59 133.14,15.59 132.6,15.59 132.58,15.57 132.49,15.57 131.76,14.85 131.72,14.85 130.57,13.69 130.57,13.69 129.89,13.02 129.89,12.97 128.55,11.64 127.89,11.64 126.07,9.81 123.22,9.81 122.44,10.6 122.34,10.6 122.33,10.6 122.01,10.6 122,10.6 121.56,10.6 120.56,9.6 98.51,9.6 96.72,11.39 94.99,11.39 93.2,9.6 v1(79.51,9.6)
  BOTTOM w0.149: v1(177.03,24.31) 176.7,24.31 176.48,24.53 SW1.6
PCIE_EP_PRSNT_NX8: length 101.5
  TOP w0.17: J5.B48 94.65,9.45 v1(95.77,10.56)
  L07_SIG3 w0.089: v1(178.28,24.34) 178.28,23.95 177.13,22.79 175.03,22.79 173.26,21.02 173.26,16.2 172.83,15.77 164.92,15.77 164.69,15.54 163.9,15.54 163.8,15.64 163.43,15.64 162.98,15.64 162.45,15.11 138.03,15.11 137.76,15.38 132.68,15.38 132.66,15.36 132.62,15.36 132.1,14.85 132.06,14.85 130.67,13.45 130.67,13.45 130.13,12.92 130.13,12.87 128.65,11.39 127.99,11.39 126.17,9.57 123.04,9.57 122.33,10.28 121.58,10.28 120.63,9.33 96.99,9.33 v1(95.77,10.56)
  BOTTOM w0.149: SW1.7 177.75,24.51 177.93,24.34 v1(178.28,24.34)
PCIE_EP_PRSNT_NX16: length 78.7
  TOP w0.17: J5.B81 127.65,7.43 125.74,9.35 122.82,9.35 122.32,9.84 v1(121.85,9.84) 121.85,10.32 121.61,10.56 C335.1
  L07_SIG3 w0.089: v1(121.85,9.84) 122.32,9.84 122.84,9.33 127.35,9.33 127.78,9.77 127.78,9.78 128.4,10.39 128.74,10.73 128.75,10.73 130.37,12.35 130.37,12.82 130.77,13.21 130.77,13.21 132.42,14.87 132.46,14.87 132.75,15.15 132.75,15.15 132.77,15.17 132.96,15.17 137.67,15.17 137.8,15.04 137.8,15.02 137.92,14.9 162.54,14.9 163.07,15.43 163.71,15.43 163.81,15.33 164.78,15.33 165.01,15.56 172.92,15.56 173.61,16.26 173.61,20.42 173.61,20.42 173.61,20.45 175.62,22.46 177.31,22.46 v1(179.02,24.17)
  BOTTOM w0.149: SW1.8 v1(179.02,24.17)
PCIE_EP_RX_CN0: length 6.6
  BOTTOM w0.116: C307.2 63.35,10.32 arc(63.31,10.27) 63.29,10.21 63.29,10.2 63.29,10.15 63.29,10.14 63.29,6.57 arc(63.29,6.54) 63.29,6.5 arc(63.31,6.44) 63.35,6.39
  BOTTOM w0.17: 63.35,6.39 63.57,6.17 arc(63.63,6.07) 63.65,5.96 J5.A17
PCIE_EP_RX_CN1: length 6.6
  BOTTOM w0.116: C312.2 68.28,10.25 arc(68.25,10.21) 68.24,10.16 68.24,6.64 arc(68.27,6.5) 68.35,6.39
  BOTTOM w0.17: J5.A22 68.65,5.96 arc(68.63,6.07) 68.57,6.17 68.35,6.39
PCIE_EP_RX_CN2: length 6.6
  BOTTOM w0.116: C314.2 72.35,10.32 arc(72.3,10.25) 72.28,10.18 arc(72.28,10.17) 72.28,10.16 72.28,6.55 arc(72.28,6.54) 72.28,6.53 arc(72.3,6.45) 72.35,6.39
  BOTTOM w0.17: J5.A26 72.65,5.96 arc(72.63,6.07) 72.57,6.17 72.35,6.39
PCIE_EP_RX_CN3: length 6.6
  BOTTOM w0.116: C316.2 76.35,10.32 arc(76.32,10.28) 76.3,10.24 arc(76.31,10.15) 76.32,10.07 76.32,6.64 arc(76.31,6.56) 76.3,6.47 arc(76.32,6.43) 76.35,6.39
  BOTTOM w0.17: J5.A30 76.65,5.96 arc(76.63,6.07) 76.57,6.17 76.35,6.39
PCIE_EP_RX_CN4: length 6.6
  BOTTOM w0.116: C318.2 82.35,10.32 arc(82.3,10.25) 82.28,10.16 82.28,6.59 arc(82.3,6.51) 82.34,6.44
  BOTTOM w0.17: 82.34,6.44 82.54,6.25 arc(82.62,6.12) 82.65,5.96 J5.A36
PCIE_EP_RX_CN5: length 6.6
  BOTTOM w0.116: C322.2 86.35,10.32 arc(86.3,10.25) 86.28,10.16 86.28,6.55 arc(86.3,6.46) 86.35,6.39
  BOTTOM w0.17: J5.A40 86.65,5.96 arc(86.63,6.07) 86.57,6.17 86.35,6.39
PCIE_EP_RX_CN6: length 6.6
  BOTTOM w0.116: C328.2 90.35,10.32 arc(90.3,10.25) 90.28,10.16 90.28,6.55 arc(90.3,6.46) 90.35,6.39
  BOTTOM w0.17: 90.35,6.39 90.57,6.17 arc(90.63,6.07) 90.65,5.96 J5.A44
PCIE_EP_RX_CN7: length 6.6
  BOTTOM w0.116: C334.2 94.35,10.32 arc(94.3,10.25) 94.28,10.16 94.28,6.55 arc(94.3,6.46) 94.35,6.39
  BOTTOM w0.17: J5.A48 94.65,5.96 arc(94.63,6.07) 94.57,6.17 94.35,6.39
PCIE_EP_RX_CN8: length 6.6
  BOTTOM w0.116: C337.2 99.35,10.32 arc(99.3,10.25) 99.28,10.16 99.28,6.55 arc(99.3,6.46) 99.35,6.39
  BOTTOM w0.17: J5.A53 99.65,5.96 arc(99.63,6.07) 99.57,6.17 99.35,6.39
PCIE_EP_RX_CN9: length 6.6
  BOTTOM w0.116: C339.2 103.35,10.32 arc(103.3,10.25) 103.28,10.16 103.28,6.55 arc(103.3,6.46) 103.35,6.39
  BOTTOM w0.17: J5.A57 103.65,5.96 arc(103.63,6.07) 103.57,6.17 103.35,6.39
PCIE_EP_RX_CN10: length 6.6
  BOTTOM w0.116: C342.2 107.35,10.32 arc(107.3,10.25) 107.28,10.16 107.28,6.55 arc(107.3,6.46) 107.35,6.39
  BOTTOM w0.17: 107.35,6.39 107.57,6.17 arc(107.63,6.07) 107.65,5.96 J5.A61
PCIE_EP_RX_CN11: length 6.6
  BOTTOM w0.116: C344.2 111.35,10.32 arc(111.3,10.25) 111.28,10.16 111.28,6.55 arc(111.3,6.46) 111.35,6.39
  BOTTOM w0.17: J5.A65 111.65,5.96 arc(111.63,6.07) 111.57,6.17 111.35,6.39
PCIE_EP_RX_CN12: length 6.6
  BOTTOM w0.116: C346.2 115.35,10.32 arc(115.3,10.25) 115.28,10.16 115.28,6.55 arc(115.3,6.46) 115.35,6.39
  BOTTOM w0.17: 115.35,6.39 115.57,6.17 arc(115.63,6.07) 115.65,5.96 J5.A69
PCIE_EP_RX_CN13: length 6.6
  BOTTOM w0.116: C348.2 119.35,10.32 arc(119.3,10.25) 119.28,10.16 119.28,6.55 arc(119.3,6.46) 119.35,6.39
  BOTTOM w0.17: J5.A73 119.65,5.96 arc(119.63,6.07) 119.57,6.17 119.35,6.39
PCIE_EP_RX_CN14: length 6.6
  BOTTOM w0.116: C350.2 123.35,10.32 arc(123.3,10.25) 123.28,10.16 123.28,6.55 arc(123.3,6.46) 123.35,6.39
  BOTTOM w0.17: J5.A77 123.65,5.96 arc(123.63,6.07) 123.57,6.17 123.35,6.39
PCIE_EP_RX_CN15: length 6.6
  BOTTOM w0.116: C352.2 127.35,10.32 arc(127.3,10.25) 127.28,10.16 127.28,6.55 arc(127.3,6.46) 127.35,6.39
  BOTTOM w0.17: J5.A81 127.65,5.96 arc(127.63,6.07) 127.57,6.17 127.35,6.39
PCIE_EP_RX_CP0: length 6.6
  BOTTOM w0.116: C306.2 62.98,10.32 63.05,10.18 63.05,10.14 63.05,10.04 63.05,6.57 arc(63.03,6.47) 62.97,6.39
  BOTTOM w0.17: J5.A16 62.65,5.95 arc(62.68,6.06) 62.74,6.15 62.97,6.39
PCIE_EP_RX_CP1: length 6.6
  BOTTOM w0.116: C311.2 67.96,10.33 arc(67.99,10.29) 68,10.23 68,6.48 arc(67.99,6.42) 67.96,6.37
  BOTTOM w0.17: 67.96,6.37 67.74,6.15 arc(67.68,6.06) 67.65,5.95 J5.A21
PCIE_EP_RX_CP2: length 6.6
  BOTTOM w0.116: C313.2 71.98,10.32 arc(72.02,10.25) 72.04,10.16 72.04,6.55 arc(72.02,6.46) 71.97,6.39
  BOTTOM w0.17: 71.97,6.39 71.74,6.15 arc(71.68,6.06) 71.65,5.95 J5.A25
PCIE_EP_RX_CP3: length 6.6
  BOTTOM w0.116: C315.2 75.98,10.32 arc(76.05,10.2) 76.08,10.07 76.08,6.64 arc(76.05,6.51) 75.97,6.39
  BOTTOM w0.17: J5.A29 75.65,5.95 arc(75.68,6.06) 75.74,6.15 75.97,6.39
PCIE_EP_RX_CP4: length 6.6
  BOTTOM w0.116: C317.2 81.98,10.32 arc(82.02,10.25) 82.04,10.16 82.04,6.62 arc(82.03,6.55) 81.99,6.5
  BOTTOM w0.17: J5.A35 81.65,6.04 arc(81.68,6.15) 81.74,6.24 81.99,6.5
PCIE_EP_RX_CP5: length 6.6
  BOTTOM w0.116: C320.2 85.98,10.32 arc(86.02,10.25) 86.04,10.16 86.04,6.55 arc(86.02,6.46) 85.97,6.39
  BOTTOM w0.17: 85.97,6.39 85.74,6.16 arc(85.7,6.09) 85.68,6.01 85.68,4.13 J5.A39
PCIE_EP_RX_CP6: length 6.6
  BOTTOM w0.116: C326.2 89.98,10.32 arc(90.02,10.25) 90.04,10.16 90.04,6.55 arc(90.02,6.46) 89.97,6.39
  BOTTOM w0.17: 89.97,6.39 89.74,6.15 arc(89.67,6.05) 89.64,5.93 89.64,4.11 J5.A43
PCIE_EP_RX_CP7: length 6.6
  BOTTOM w0.116: C332.2 93.98,10.32 arc(94.02,10.25) 94.04,10.16 94.04,6.55 arc(94.02,6.46) 93.97,6.39
  BOTTOM w0.17: 93.97,6.39 93.75,6.16 arc(93.7,6.09) 93.68,6.01 93.68,4.13 J5.A47
PCIE_EP_RX_CP8: length 6.6
  BOTTOM w0.116: C336.2 98.98,10.32 arc(99.02,10.25) 99.04,10.16 99.04,6.55 arc(99.02,6.46) 98.97,6.39
  BOTTOM w0.17: 98.97,6.39 98.74,6.15 arc(98.66,6.04) 98.64,5.9 98.64,4.12 J5.A52
PCIE_EP_RX_CP9: length 6.6
  BOTTOM w0.116: C338.2 102.98,10.32 arc(103.02,10.25) 103.04,10.16 103.04,6.55 arc(103.02,6.46) 102.97,6.39
  BOTTOM w0.17: 102.97,6.39 102.74,6.15 arc(102.69,6.08) 102.67,6 102.67,4.14 arc(102.67,4.12) J5.A56
PCIE_EP_RX_CP10: length 6.6
  BOTTOM w0.116: C341.2 106.98,10.32 arc(107.02,10.25) 107.04,10.16 107.04,6.55 arc(107.02,6.46) 106.97,6.39
  BOTTOM w0.17: J5.A60 106.71,4.16 106.71,6.04 arc(106.73,6.12) 106.78,6.19 106.97,6.39
PCIE_EP_RX_CP11: length 6.6
  BOTTOM w0.116: C343.2 110.98,10.32 arc(111.02,10.25) 111.04,10.16 111.04,6.55 arc(111.02,6.46) 110.97,6.39
  BOTTOM w0.17: 110.97,6.39 110.74,6.15 arc(110.69,6.08) 110.67,6 110.67,4.12 J5.A64
PCIE_EP_RX_CP12: length 6.6
  BOTTOM w0.116: C345.2 114.98,10.32 arc(115.02,10.25) 115.04,10.16 115.04,6.55 arc(115.02,6.46) 114.97,6.39
  BOTTOM w0.17: 114.97,6.39 114.74,6.15 arc(114.66,6.04) 114.64,5.91 114.64,4.12 J5.A68
PCIE_EP_RX_CP13: length 6.6
  BOTTOM w0.116: C347.2 118.98,10.32 arc(119.02,10.25) 119.04,10.16 119.04,6.55 arc(119.02,6.46) 118.97,6.39
  BOTTOM w0.17: 118.97,6.39 118.74,6.15 arc(118.69,6.08) 118.68,6 118.68,4.12 J5.A72
PCIE_EP_RX_CP14: length 6.6
  BOTTOM w0.116: C349.2 122.98,10.32 arc(123.02,10.25) 123.04,10.16 123.04,6.55 arc(123.02,6.46) 122.97,6.39
  BOTTOM w0.17: J5.A76 122.64,4.12 122.64,5.91 arc(122.66,6.04) 122.74,6.15 122.97,6.39
PCIE_EP_RX_CP15: length 6.6
  BOTTOM w0.116: C351.2 126.98,10.32 arc(127.02,10.25) 127.04,10.16 127.04,6.55 arc(127.02,6.46) 126.97,6.39
  BOTTOM w0.17: J5.A80 126.68,4.12 126.68,6 arc(126.69,6.08) 126.74,6.15 126.97,6.39
PCIE_EP_RX_N0: length 64.4
  L16_SIG6 w0.085: v1(97.56,53.14) 97.3,53.29 arc(97.22,53.3) 97.16,53.25 97.1,53.14 arc(96.98,53.02) 96.81,52.97 96.62,52.97 arc(96.35,53.05) 96.15,53.25 96.08,53.37 arc(95.99,53.46) 95.87,53.49 95.73,53.49 arc(95.65,53.48) 95.59,53.43 95.4,53.24 arc(95.24,53.14) 95.06,53.1 94.85,53.1 arc(94.71,53.06) 94.61,52.96 94.56,52.87 arc(94.36,52.67) 94.09,52.6 93.96,52.6 arc(93.84,52.57) 93.76,52.48 93.64,52.28 arc(93.46,52.1) 93.22,52.04 93.12,52.04 arc(93.03,52.02) 92.96,51.97 92.71,51.73 arc(92.45,51.54) 92.14,51.44 92.08,51.44 arc(91.74,51.33) 91.45,51.13 91.02,50.69 arc(90.85,50.58) 90.66,50.54 90.64,50.54 arc(90.58,50.54) 90.52,50.52 89.69,50.04 87.92,50.04 87.18,49.73 86.99,49.54 86.99,49.37 86.81,49.19 86.64,49.19 85.21,47.75 84.79,46.76 84.79,46.02 84.67,45.73 84.33,45.39 83.97,45.24 83.45,45.24 arc(83.01,45.15) 82.63,44.9 80.4,42.67 arc(79.97,42.38) 79.47,42.28 arc(78.24,42.04) 77.2,41.34 76.8,40.95 arc(76.02,39.78) 75.75,38.41 75.75,35.95 arc(75.49,34.64) 74.75,33.53 72.57,31.35 arc(72.08,30.62) 71.91,29.75 71.91,18.65 arc(71.52,16.71) 70.42,15.06 arc(69.88,14.7) 69.25,14.57 65.38,14.57 arc(64.96,14.39) 64.78,13.97 64.78,13.52 arc(64.54,12.87) 63.93,12.52 arc(63.84,12.5) 63.75,12.46 arc(63.48,12.24) 63.28,11.96 arc(63.27,11.92) 63.26,11.87 63.26,11.43 arc(63.3,11.24) 63.41,11.08 v5(63.41,11.01)
PCIE_EP_RX_N1: length 58.5
  L16_SIG6 w0.085: v5(68.49,11) 68.34,11.15 arc(68.28,11.23) 68.26,11.33 68.26,11.96 arc(68.63,12.85) 69.51,13.21 71.01,13.21 arc(72.69,13.91) 73.38,15.58 73.38,28.75 arc(73.62,29.95) 74.3,30.96 76.08,32.74 76.68,33.35 arc(76.89,33.66) 76.97,34.04 76.97,38.92 arc(77.09,39.54) 77.44,40.07 arc(78.7,40.91) 80.18,41.2 82.63,41.2 84.21,41.86 85.13,42.78 85.67,44.07 85.67,46.31 86.14,47.45 86.4,47.71 86.61,47.8 87.14,47.8 87.41,47.91 arc(87.62,47.98) 87.84,48.03 arc(88.2,48.1) 88.54,48.22 89.14,48.47 arc(89.6,48.71) 90.01,49.05 90.36,49.4 arc(90.51,49.5) 90.69,49.54 90.69,49.54 arc(91.14,49.62) 91.52,49.88 92.38,50.74 arc(92.71,50.96) 93.09,51.04 93.27,51.04 arc(93.44,51.07) 93.57,51.16 93.76,51.35 arc(93.9,51.44) 94.06,51.47 94.12,51.47 arc(94.43,51.55) 94.65,51.78 94.71,51.89 arc(94.76,52.07) 94.71,52.26 94.69,52.3 arc(94.68,52.38) 94.72,52.44 v1(94.96,52.64)
PCIE_EP_RX_N2: length 57.6
  L16_SIG6 w0.085: v5(72.49,11) 72.33,11.16 arc(72.28,11.23) 72.26,11.32 72.26,11.69 arc(72.35,11.9) 72.57,11.99 74.1,11.99 arc(74.71,12.11) 75.23,12.46 75.52,12.75 arc(76.65,14.44) 77.05,16.43 77.05,29.18 arc(77.21,30) 77.67,30.69 arc(78.87,31.5) 80.29,31.78 82.38,31.78 arc(83.48,32) 84.41,32.62 85.67,33.88 86.5,35.87 86.5,45.45 86.74,46.03 86.98,46.27 87.16,46.27 87.34,46.45 87.34,46.63 87.54,46.83 88.04,47.04 arc(88.24,47.08) 88.41,47.19 88.6,47.38 arc(88.66,47.43) 88.73,47.48 90.52,48.51 arc(90.58,48.54) 90.64,48.54 90.66,48.54 arc(90.85,48.58) 91.02,48.69 91.3,48.98 arc(91.59,49.18) 91.93,49.29 91.98,49.29 arc(92.3,49.39) 92.56,49.57 92.96,49.97 arc(93.03,50.02) 93.12,50.04 93.22,50.04 arc(93.46,50.1) 93.64,50.28 93.71,50.41 arc(93.85,50.55) 94.04,50.6 94.09,50.6 arc(94.36,50.67) 94.56,50.87 94.57,50.89 arc(94.72,51.04) 94.93,51.1 95.09,51.1 arc(95.24,51.13) 95.37,51.21 95.59,51.43 arc(95.65,51.47) 95.73,51.49 95.87,51.49 arc(95.99,51.46) 96.08,51.37 96.15,51.25 arc(96.35,51.05) 96.62,50.97 96.81,50.97 arc(96.98,51.02) 97.1,51.14 97.16,51.25 arc(97.22,51.3) 97.3,51.29 v1(97.56,51.14)
PCIE_EP_RX_N3: length 51.7
  L16_SIG6 w0.085: v1(94.96,50.64) 94.72,50.44 arc(94.68,50.38) 94.69,50.3 94.71,50.26 arc(94.76,50.07) 94.71,49.89 94.65,49.78 arc(94.43,49.55) 94.12,49.47 94.04,49.47 arc(93.9,49.44) 93.78,49.37 93.57,49.16 arc(93.44,49.07) 93.27,49.04 93.25,49.04 arc(92.73,48.93) 92.29,48.64 91.53,47.88 arc(91.15,47.62) 90.7,47.54 90.67,47.54 arc(90.51,47.5) 90.37,47.41 90.19,47.23 arc(90.15,47.19) 90.1,47.16 89.64,46.89 88.33,46.14 arc(88.17,46.07) 88.01,46.05 87.95,46.05 87.89,46.03 87.44,45.58 87.44,36 86.36,33.4 arc(86.35,33.36) 86.33,33.31 arc(86.31,33.25) 86.29,33.19 arc(86.24,33.09) 86.18,32.99 arc(86.14,32.93) 86.1,32.87 85.05,31.83 arc(83.73,30.94) 82.18,30.64 80.12,30.64 arc(79.08,30.2) 78.65,29.16 78.65,13.06 arc(78.55,12.58) 78.28,12.18 arc(78.05,12.02) 77.77,11.97 76.74,11.97 arc(76.4,11.83) 76.26,11.49 76.26,11.31 arc(76.28,11.23) 76.32,11.17 v5(76.49,11)
PCIE_EP_RX_N4: length 47.9
  L16_SIG6 w0.085: v5(82.49,11) 82.32,11.17 arc(82.28,11.23) 82.26,11.31 82.26,12.93 arc(82.26,12.98) 82.27,13.02 arc(82.38,13.41) 82.58,13.78 arc(82.88,14.42) 82.98,15.11 82.98,29.15 arc(83.17,29.61) 83.63,29.8 83.95,29.8 arc(84.34,29.87) 84.66,30.09 85.49,30.91 arc(85.64,31.06) 85.8,31.21 arc(86.81,32.3) 87.53,33.59 88.17,35.13 arc(88.27,35.45) 88.34,35.77 arc(88.35,35.83) 88.35,35.88 88.35,43.97 88.48,44.1 88.48,44.31 88.35,44.44 88.35,44.78 arc(88.38,44.98) 88.47,45.17 arc(88.5,45.23) 88.53,45.3 arc(88.58,45.38) 88.65,45.43 90.48,46.49 arc(90.58,46.53) 90.69,46.54 90.76,46.54 arc(90.9,46.57) 91.03,46.66 91.24,46.87 arc(91.4,46.99) 91.59,47.06 arc(91.79,47.14) 91.96,47.28 92.16,47.48 arc(92.25,47.54) 92.36,47.56 92.36,47.56 arc(92.58,47.6) 92.77,47.73 93.01,47.97 arc(93.08,48.02) 93.17,48.04 93.22,48.04 arc(93.46,48.1) 93.64,48.28 93.71,48.41 arc(93.85,48.55) 94.04,48.6 94.09,48.6 arc(94.36,48.67) 94.56,48.87 94.56,48.87 arc(94.73,49.04) 94.95,49.1 95.09,49.1 arc(95.24,49.13) 95.37,49.21 95.59,49.43 arc(95.65,49.47) 95.73,49.49 95.87,49.49 arc(95.99,49.46) 96.08,49.37 96.15,49.24 arc(96.35,49.05) 96.62,48.97 96.81,48.97 arc(96.98,49.02) 97.1,49.14 97.16,49.25 arc(97.22,49.3) 97.3,49.29 v1(97.56,49.14)
PCIE_EP_RX_N5: length 42.3
  L16_SIG6 w0.085: v5(86.49,11) 86.32,11.17 arc(86.28,11.23) 86.26,11.31 86.26,29.31 arc(86.39,29.97) 86.76,30.52 86.91,30.67 arc(86.93,30.69) 86.94,30.7 87.01,30.76 arc(87.63,31.5) 88.1,32.34 89.36,35.39 89.36,37.67 arc(89.38,37.76) 89.43,37.83 89.45,37.85 arc(89.56,38.13) 89.45,38.42 89.37,38.49 arc(89.31,38.64) 89.37,38.79 89.46,38.88 arc(89.57,39.14) 89.46,39.4 89.38,39.48 arc(89.33,39.55) 89.31,39.64 89.31,39.82 arc(89.34,40.02) 89.42,40.19 arc(89.54,40.45) 89.6,40.74 89.6,40.99 arc(89.55,41.24) 89.41,41.45 89.39,41.47 arc(89.32,41.57) 89.3,41.68 89.3,41.97 arc(89.33,42.18) 89.42,42.37 arc(89.5,42.58) 89.53,42.8 89.53,43.12 arc(89.51,43.3) 89.45,43.48 arc(89.42,43.56) 89.41,43.65 89.41,44.16 arc(89.47,44.47) 89.65,44.74 90.12,45.2 arc(90.47,45.47) 90.89,45.62 arc(91.31,45.77) 91.66,46.03 92.35,46.72 arc(92.7,46.95) 93.12,47.04 93.27,47.04 arc(93.44,47.07) 93.57,47.16 93.78,47.37 arc(93.9,47.44) 94.04,47.47 94.12,47.47 arc(94.43,47.55) 94.65,47.78 94.71,47.88 arc(94.76,48.07) 94.71,48.27 94.69,48.3 arc(94.68,48.38) 94.72,48.44 v1(94.96,48.64)
PCIE_EP_RX_N6: length 44.6
  L16_SIG6 w0.085: v5(90.49,11) 90.36,11.13 arc(90.29,11.23) 90.26,11.36 arc(90.13,12) 89.77,12.54 88.2,14.12 arc(87.72,14.82) 87.56,15.66 87.56,28.68 arc(87.84,30.1) 88.64,31.3 88.93,31.59 arc(89.86,32.97) 90.18,34.6 90.18,35 90.29,35.12 90.29,35.37 90.18,35.48 90.18,36.55 arc(90.21,36.81) 90.29,37.06 arc(90.37,37.31) 90.4,37.57 90.4,37.65 arc(90.37,37.81) 90.28,37.95 90.25,37.98 arc(90.18,38.13) 90.25,38.29 90.25,38.29 arc(90.39,38.62) 90.25,38.96 90.23,38.98 arc(90.16,39.14) 90.23,39.29 90.31,39.37 arc(90.42,39.64) 90.31,39.91 90.3,39.92 arc(90.26,39.98) 90.25,40.05 90.25,41.11 arc(90.25,41.21) 90.28,41.29 arc(90.34,41.67) 90.22,42.03 arc(90.18,42.13) 90.16,42.24 90.16,43 arc(90.17,43.11) 90.21,43.22 arc(90.24,43.28) 90.28,43.33 arc(90.4,43.64) 90.28,43.95 arc(90.22,44.05) 90.19,44.16 arc(90.31,44.43) 90.57,44.54 90.7,44.54 arc(90.89,44.58) 91.06,44.69 91.53,45.17 arc(91.76,45.32) 92.03,45.39 arc(92.43,45.5) 92.78,45.74 93.01,45.97 arc(93.08,46.02) 93.17,46.04 93.22,46.04 arc(93.46,46.1) 93.64,46.28 93.72,46.41 arc(93.85,46.55) 94.04,46.6 94.09,46.6 arc(94.37,46.67) 94.57,46.87 94.58,46.89 arc(94.73,47.04) 94.93,47.1 95.09,47.1 arc(95.24,47.13) 95.37,47.21 95.59,47.43 arc(95.65,47.47) 95.73,47.49 95.87,47.49 arc(95.99,47.46) 96.08,47.37 96.15,47.24 arc(96.35,47.05) 96.62,46.97 96.81,46.97 arc(96.98,47.02) 97.1,47.14 97.16,47.25 arc(97.22,47.3) 97.3,47.29 v1(97.56,47.14)
