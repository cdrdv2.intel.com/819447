# Allegro board FM85_AGILEX_PCIE_DK_CMC_ADI_REVC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_DDIMM_DQS_P6: length 83.7
  L16_SIG6 w0.076: 131.07,78.99 131.05,78.97 131.05,78.97 131.01,78.94 131.01,78.94 131,78.93 arc(130.95,78.81) 130.98,78.7 arc(130.99,78.69) 131,78.68 arc(131.2,78.34) 131.12,77.95 arc(131.09,77.86) 131.11,77.76 131.16,77.66 arc(131.16,77.66) 131.16,77.65 arc(131.22,77.35) 131.14,77.05 arc(131.1,76.82) 131.19,76.61 arc(131.25,76.52) 131.27,76.41 arc(131.26,76.37) 131.25,76.33 131.23,76.26 arc(131.23,76.13) 131.31,76.03 131.46,75.95 v1(131.46,75.95)
  L16_SIG6 w0.081: v1(86.97,101.74) 87.17,101.94 87.17,102.16 87.53,102.51 94,102.51 95.18,101.33 95.63,101.33 95.82,101.52 97.78,101.52 97.91,101.39 98.18,101.39 98.31,101.52 102.52,101.52 102.85,101.19 102.85,100.42 103.62,99.65 103.89,99.65 105.12,100.88 105.39,100.88 105.62,100.66 105.62,100.39 104.46,99.24 104.46,99.12 104.58,99 104.7,99 106.38,100.68 106.66,100.68 106.88,100.46 106.88,100.19 105.87,99.18 105.87,99.07 105.9,99.03 105.91,99.03 106.21,98.73 106.21,98.73 106.57,98.36 107.16,97.77 107.28,97.77 107.73,98.22 108,98.22 108.22,97.99 108.22,97.72 107.78,97.28 107.78,97.16 107.9,97.04 108.01,97.04 109.26,98.28 109.53,98.28 109.76,98.06 109.76,97.79 107.88,95.91 107.88,95.8 108,95.68 108.12,95.68 109.3,96.86 109.59,96.86 109.81,96.64 109.81,96.37 108.95,95.51 108.95,95.26 109.2,95.01 111.79,95.01 111.87,95.09 111.87,95.75 112.04,95.92 112.38,95.92 112.57,95.73 112.57,95.09 112.65,95.01 113.73,95.01 113.81,95.09 113.81,95.71 114,95.9 114.33,95.9 114.51,95.71 114.51,95.09 114.59,95.01 119.53,95.01 119.58,94.96 119.59,94.96 123.77,90.78 124.7,90.78 128.13,90.78 130,88.92 130,87.66 131.56,86.1 arc(131.67,85.94) 131.71,85.75 131.71,82.14 131.31,81.52 131.34,81.4 131.23,81.22 131.22,81.13 131.22,79.32 131.22,79.15 131.07,78.99
DDR4_DDIMM_DQS_P7: length 75.4
  L16_SIG6 w0.076: v1(126.68,75.95) 126.42,76.1 arc(126.37,76.1) 126.32,76.07 126.3,76.03 arc(126.25,75.97) 126.19,75.92 arc(126.07,75.85) 125.93,75.83 125.85,75.83 arc(125.68,75.86) 125.53,75.93 arc(125.45,76) 125.4,76.09 arc(125.38,76.12) 125.36,76.16 arc(125.28,76.4) 125.37,76.63 arc(125.45,76.85) 125.39,77.08 arc(125.31,77.3) 125.37,77.52 arc(125.37,77.53) 125.37,77.53 arc(125.38,77.54) 125.38,77.55 arc(125.39,77.56) 125.4,77.58 arc(125.42,77.62) 125.44,77.65 arc(125.44,77.65) 125.45,77.66 arc(125.47,77.69) 125.5,77.71 125.5,77.72 arc(125.51,77.74) 125.53,77.76 arc(125.53,77.81) 125.51,77.85 arc(125.37,78.08) 125.35,78.34 arc(125.35,78.36) 125.35,78.37 arc(125.37,78.45) 125.4,78.52 arc(125.45,78.67) 125.44,78.83 arc(125.43,78.85) 125.42,78.87 arc(125.42,78.89) 125.41,78.9 arc(125.34,79.18) 125.41,79.45 arc(125.46,79.63) 125.4,79.82 arc(125.37,79.9) 125.35,80 125.35,80.18 arc(125.38,80.31) 125.45,80.42 arc(125.5,80.53) 125.47,80.65 arc(125.4,80.74) 125.35,80.84 125.24,81.12 arc(125.21,81.21) 125.2,81.32 125.2,82.45 arc(125.11,82.93) 124.85,83.35 124.85,83.35 124.81,83.39 124.81,83.39 124.8,83.41
  L16_SIG6 w0.081: 124.8,83.41 121.63,86.57 arc(121.6,86.6) 121.56,86.6 119.73,86.6 arc(119.62,86.63) 119.53,86.69 119.12,87.09 arc(118.87,87.26) 118.57,87.32 107.26,87.32 arc(107.2,87.33) 107.14,87.34 106.11,87.57 arc(106.05,87.59) 105.99,87.61 104.78,88.26 arc(104.73,88.29) 104.69,88.32 arc(104.52,88.44) 104.36,88.57 arc(104.32,88.6) 104.28,88.64 100.98,91.94 arc(100.56,92.41) 100.2,92.92 arc(99.94,93.35) 99.73,93.81 99.64,94.02 arc(99.63,94.06) 99.6,94.09 arc(98.98,94.76) 98.31,95.39 arc(98.14,95.53) 97.95,95.66 arc(97.85,95.72) 97.76,95.78 arc(97.67,95.86) 97.62,95.97 arc(97.29,96.46) 96.81,96.8 96.17,97.08 arc(96.13,97.09) 96.09,97.1 95.06,97.09 arc(95.02,97.09) 94.97,97.1 94.33,97.13 arc(94.25,97.14) 94.18,97.17 93.06,97.7 arc(93.02,97.71) 92.98,97.72 90.56,97.72 arc(90.48,97.7) 90.41,97.66 arc(90.09,97.44) 89.71,97.37 89.56,97.37 89.48,97.28 89.48,96.04 89.29,95.85 88.97,95.85 88.78,96.04 88.78,97.3 88.7,97.38 88.53,97.38 88.45,97.3 88.45,96.04 88.26,95.85 87.93,95.85 87.74,96.04 87.74,97.41 87.66,97.49 87.49,97.49 87.41,97.41 87.41,96.04 87.22,95.85 86.9,95.85 86.71,96.04 86.71,97.28 86.63,97.37 82.49,97.37 arc(82.26,97.41) 82.06,97.54 81.46,98.15 arc(81.42,98.2) 81.38,98.25 arc(81.27,98.67) 81.38,99.08 arc(81.41,99.13) 81.44,99.18 arc(81.53,99.43) 81.42,99.67 arc(81.33,99.8) 81.3,99.96 81.3,101.38 80.94,101.74 79.9,101.74 79.35,101.19 78.26,101.19 77.88,101.57 77.88,102.1 77.75,102.24 v1(77.66,102.24)
DDR4_DDIMM_DQS_P8: length 44.4
  L03_SIG1 w0.081: v1(151.59,100.96) 151.66,100.9 151.92,100.9 152.01,100.99 152.01,101.39 151.84,101.56 151.47,101.56 150.95,102.09 150.95,104.06 150.73,104.28 150.37,104.28 150.23,104.14 150.23,100.64 150.5,100.37 151.29,100.37 151.47,100.18 151.47,99.85 151.29,99.67 150.5,99.67 150.42,99.58 150.42,99.06 150.47,99.01 150.47,98.41 150.13,98.07 149.74,98.07 146.23,94.55 145.46,94.55 145.08,94.18 145.08,93.45 142.78,91.16 135.92,91.16 134.85,90.09 134.35,90.09 132.38,88.12 132.38,86.93 131.75,86.3 131.75,84.8 130.19,83.24 130.19,82.4 129.69,81.89 129.69,81.36 129.75,81.29 129.75,81.09 129.59,80.8 129.6,80.69 129.74,80.56 v2(129.85,80.56)
DDR4_DDIMM_EVENT_N: length 27.4
  BOTTOM w0.149: U13.13 101.74,104.82 v1(101.8,104.88) 101.8,106.45 102.87,107.53 124.68,107.53 v1(125.24,106.96)
DDR4_DDIMM_ODT0: length 70.9
  L05_SIG2 w0.081: v1(121.9,74.11) 121.5,74.8 arc(121.33,74.97) 121.11,75.03 121.1,75.03 arc(120.88,75.09) 120.71,75.25 120.7,75.27 arc(120.53,75.43) 120.31,75.49 arc(120.08,75.55) 119.92,75.7 119.91,75.72 arc(119.85,75.95) 119.91,76.18 119.92,76.19 arc(119.97,76.42) 119.91,76.64 arc(119.85,76.86) 119.9,77.08 119.91,77.1 arc(119.97,77.33) 119.91,77.56 119.91,77.56 arc(119.85,77.79) 119.91,78.02 arc(119.97,78.25) 119.91,78.48 arc(119.85,78.71) 119.91,78.94 arc(119.97,79.17) 119.91,79.4 119.91,79.4 arc(119.85,79.63) 119.91,79.86 arc(119.97,80.09) 119.91,80.31 119.89,80.35 arc(119.88,80.38) 119.88,80.4 119.94,80.46 119.94,80.7 120.42,81.19 120.42,81.55 120.72,81.85 120.92,81.85 121.04,81.97 121.04,82.98 121.49,83.42 121.49,84.23 120.68,85.03 120.68,86.78 119.69,87.77 119.69,90.06 119.69,90.44 120.24,90.99 122.03,90.99 122.47,91.43 122.47,92.38 121.9,92.95 119.92,92.95 119.62,93.25 119.23,93.25 118.34,94.15 118.34,98.71 118.81,99.19 118.81,99.5 118.55,99.76 116.25,99.76 115.49,100.52 115.49,103.44 115.2,103.73 113.74,103.73 113.38,103.37 113.07,103.37 112.58,103.86 106.82,103.86 106.55,104.12 106.55,106.03 106.88,106.36 107,106.36 107.09,106.28 107.09,105.86 107.17,105.78 107.34,105.78 107.42,105.86 107.42,106.28 107.5,106.36 107.66,106.36 107.8,106.22 107.8,106.02 108.06,105.76 112.5,105.76 113.04,106.3 114.5,106.3 114.58,106.22 114.58,105.76 114.88,105.46 115.41,105.46 115.63,105.68 115.63,105.95 114.82,106.77 114.82,106.88 114.93,107 115.12,107 116.05,106.07 116.16,106.07 116.38,106.29 116.38,106.48 116.46,106.56 117.01,106.56 117.09,106.64 117.09,106.82 117.01,106.9 116.46,106.9 116.38,106.98 116.38,107.31 116.52,107.45 117.46,107.45 117.59,107.32 v1(117.59,106.96)
DDR4_DDIMM_ODT1: length 70.7
  L05_SIG2 w0.081: v1(121.1,73.65) 120.7,74.34 arc(120.54,74.5) 120.32,74.57 120.31,74.57 arc(120.08,74.63) 119.91,74.8 arc(119.74,74.97) 119.51,75.03 119.51,75.03 arc(119.41,75.01) 119.33,74.96 119.12,74.74 arc(118.77,74.6) 118.42,74.74 118.28,74.88 arc(118.11,74.99) 117.92,75.03 arc(117.69,75.09) 117.52,75.25 117.51,75.27 arc(117.35,75.43) 117.12,75.49 arc(116.9,75.55) 116.73,75.7 116.71,75.74 arc(116.54,75.89) 116.32,75.95 116.3,75.95 arc(116.08,76.02) 115.92,76.18 arc(115.76,76.34) 115.54,76.41 115.52,76.41 arc(115.29,76.47) 115.13,76.64 115.13,77.32 115.26,77.46 115.7,77.46 115.94,77.7 115.94,79.01 115.54,79.41 115.54,81.25 115.55,81.26 115.55,81.58 115.54,81.59 115.54,86.15 116.83,87.44 116.83,90.26 115.95,91.13 114.94,91.13 114.44,91.64 114.01,91.64 113.47,92.18 113.47,92.81 113.26,93.02 112.63,93.02 111.57,94.09 111.57,95.44 111.86,95.73 112.6,95.73 113.76,96.9 113.76,98.72 112.49,99.99 106.43,99.99 106.15,100.27 106.15,100.36 106.07,100.44 105.61,100.44 105.53,100.52 105.53,100.69 105.61,100.78 106.07,100.78 106.15,100.86 106.15,101.4 105.95,101.6 105.64,101.6 105.48,101.76 105.48,102.99 105.62,103.13 105.97,103.13 106.05,103.21 106.05,103.38 105.97,103.46 105.62,103.46 105.54,103.54 105.54,103.72 105.62,103.8 105.97,103.8 106.06,103.9 106.06,104.03 105.97,104.13 105.62,104.13 105.54,104.21 105.54,104.39 105.62,104.47 106.14,104.47 106.22,104.55 106.22,104.71 106.13,104.8 105.62,104.8 105.54,104.88 105.54,105.06 105.62,105.14 106.16,105.14 106.25,105.23 106.25,105.39 106.17,105.47 105.62,105.47 105.54,105.56 105.54,105.73 105.62,105.81 105.97,105.81 106.05,105.89 106.05,106.49 106.14,106.59 106.71,106.59 106.85,106.73 107.05,106.73 107.18,106.59 107.92,106.59 108,106.67 108,107.12 108.08,107.2 108.25,107.2 108.33,107.12 108.33,106.67 108.49,106.52 108.92,106.52 109,106.44 109,106.13 109.08,106.05 109.25,106.05 109.33,106.13 109.33,106.68 109.42,106.77 109.59,106.77 109.67,106.69 109.67,106.13 109.75,106.05 109.92,106.05 110.01,106.13 110.01,106.5 110.09,106.58 110.25,106.58 110.34,106.49 110.34,106.13 110.42,106.05 110.59,106.05 110.68,106.13 110.68,106.5 110.76,106.58 110.92,106.58 111.01,106.49 111.01,106.13 111.09,106.05 111.26,106.05 111.35,106.13 111.35,106.44 111.43,106.52 112.02,106.52 112.26,106.75 112.26,107.04 112.35,107.13 113.06,107.13 113.15,107.04 113.15,106.65 113.23,106.57 113.4,106.57 113.49,106.65 113.49,107.11 113.57,107.19 113.97,107.19 v1(114.19,106.96)
DDR4_DDIMM_PAR: length 71.3
  L05_SIG2 w0.081: v1(125.23,101.09) 123.1,101.09 122.73,101.46 122.73,101.75 122.35,102.14 122.35,102.52 122.43,102.6 122.71,102.6 122.8,102.68 122.8,102.86 122.71,102.94 122.43,102.94 122.35,103.02 122.35,103.75 122.43,103.83 122.72,103.83 122.8,103.91 122.8,104.08 122.72,104.16 122.43,104.16 122.35,104.24 122.35,104.48 122.26,104.57 122.09,104.57 122.01,104.49 122.01,102.55 121.93,102.46 121.76,102.46 121.68,102.55 121.68,104.48 121.59,104.57 121.42,104.57 121.34,104.49 121.34,102.55 121.26,102.46 121.09,102.46 121.01,102.55 121.01,104.48 120.92,104.57 120.75,104.57 120.67,104.49 120.67,102.55 120.59,102.46 120.42,102.46 120.34,102.55 120.34,104.4 120.26,104.48 120.08,104.48 120,104.4 120,104.21 119.92,104.13 118.86,104.13 118.76,104.02 118.76,103.88 118.84,103.8 119.92,103.8 120,103.71 120,103.54 119.92,103.46 118.88,103.46 118.8,103.38 118.8,103.22 118.89,103.12 119.92,103.12 120,103.04 120,102.55 119.92,102.46 118.54,102.46 118.43,102.35 118.43,101.75 118.57,101.61 118.9,101.61 118.98,101.53 118.98,100.45 119.69,99.75 119.69,99.07 119.77,98.98 119.91,98.98 120.02,98.87 120.02,98.76 119.91,98.65 119.77,98.65 119.69,98.57 119.69,97.98 119.58,97.86 119.26,97.86 119.16,97.76 119.16,97.55 119.24,97.47 119.6,97.47 119.68,97.39 119.68,97.22 119.6,97.14 119.24,97.14 119.16,97.06 119.16,96.88 119.24,96.8 119.6,96.8 119.68,96.72 119.68,96.55 119.6,96.47 119.24,96.47 119.16,96.39 119.16,96.21 119.24,96.13 119.6,96.13 119.69,96.04 119.69,94.58 120.22,94.05 120.44,94.05 120.72,93.77 121.11,93.77 121.19,93.85 121.19,93.95 121.27,94.04 121.44,94.04 121.53,93.95 121.53,93.85 121.61,93.77 122.11,93.77 122.19,93.85 122.19,94.03 122.27,94.11 122.45,94.11 122.53,94.03 122.53,93.85 122.61,93.77 123.15,93.77 123.27,93.65 123.27,91.09 122.37,90.19 120.57,90.19 120.49,90.11 120.49,88.1 120.74,87.85 121.18,87.85 121.92,87.11 121.92,84.96 122.37,84.51 122.37,83.08 121.88,82.59 121.88,81.26 121.6,80.98 arc(121.55,80.88) 121.5,80.78 arc(121.44,80.57) 121.49,80.35 121.5,80.31 arc(121.56,80.09) 121.5,79.86 arc(121.44,79.63) 121.5,79.4 121.5,79.4 arc(121.56,79.17) 121.5,78.94 arc(121.44,78.71) 121.5,78.48 arc(121.56,78.25) 121.5,78.02 arc(121.44,77.79) 121.5,77.56 121.5,77.56 arc(121.56,77.33) 121.5,77.1 121.49,77.08 arc(121.44,76.86) 121.5,76.64 arc(121.56,76.42) 121.51,76.19 121.5,76.18 arc(121.44,75.95) 121.5,75.72 121.5,75.72 arc(121.67,75.55) 121.9,75.49 arc(122.13,75.43) 122.29,75.27 122.3,75.26 arc(122.36,75.03) 122.3,74.8 122.29,74.78 arc(122.24,74.56) 122.3,74.34 arc(122.36,74.12) 122.3,73.89 122.3,73.88 arc(122.24,73.65) 122.3,73.42 v1(122.7,72.73)
DDR4_DDIMM_RESET_N: length 74.3
  L07_SIG3 w0.089: v1(147.34,106.96) 147.81,106.49 152.47,106.49 152.82,106.14 152.82,101.06 152.91,100.97 153.08,100.97 153.17,100.88 153.17,100.72 153.08,100.63 152.91,100.63 152.82,100.54 152.82,100.37 152.91,100.29 153.08,100.29 153.17,100.2 153.17,100.03 153.08,99.94 152.91,99.94 152.82,99.85 152.82,99.69 152.91,99.6 153.08,99.6 153.17,99.51 153.17,99.35 153.08,99.26 152.91,99.26 152.82,99.17 152.82,99 152.91,98.91 153.08,98.91 153.17,98.83 153.17,98.66 153.08,98.57 152.91,98.57 152.82,98.48 152.82,97.69 153.18,97.32 153.18,95.23 152.93,94.98 151.77,94.98 151.69,95.06 151.69,95.34 151.22,95.81 148.66,95.81 147.82,94.97 147.82,93.1 147.53,92.81 141.74,92.81 140.66,93.89 139.69,93.89 138.77,92.97 136.97,92.97 136.63,93.31 135.4,93.31 134.23,92.14 130.63,92.14 123.87,85.38 123.87,85.33 123.85,85.32 123.85,84.96 123.87,84.95 123.87,74.8 123.62,74.56 123.21,74.56 122.85,74.19 122.58,74.19 122.03,73.65 121.74,73.65 121.29,73.2 120.84,73.2 120.62,73.42 120.62,73.79 v1(120.31,74.11)
  BOTTOM w0.149: v1(147.34,106.96) 146.53,106.96 145.32,105.75 145.32,105.42 144.89,104.99 v1(144.79,104.99)
DDR4_DDIMM_RZQ: length 11.3
  BOTTOM w0.149: v1(124.29,72.73) 125.31,72.73 125.49,72.91 125.49,73.81 125.56,73.88 125.63,74.23 125.53,74.38 125.49,74.41 125.49,80.7 125.25,80.94 124.99,80.94 124.33,81.6 R75.1
DDR4_DDIMM_SA0: length 2.9
  BOTTOM w0.149: R100.1 71.44,104.99 72.33,105.88 v1(73.39,105.88)
DDR4_DDIMM_SA1:
  vias: v1(72.54,106.96)
DDR4_DDIMM_SA2: length 1.2
  BOTTOM w0.149: v1(111.64,100.96) 111.65,100.97 R102.2
DDR4_DDIMM_SAVE_N: length 23.5
  L03_SIG1 w0.081: v1(101.01,104.88) 101.57,105.44 111.15,105.44 111.77,106.06 112.96,106.06 113.18,106.28 113.71,106.28 114.57,105.42 116.67,105.42 118.08,104.01 118.08,103.21 118.44,102.85 v1(118.44,100.96)
  BOTTOM w0.149: v1(101.01,104.88) 101.09,104.8 U13.12
DDR4_DDIMM_TDQS_N9: length 101.5
  L03_SIG1 w0.081: v2(136.28,76.84) 136.3,76.85 136.3,76.87 136.48,76.97 136.52,77.11 136.35,77.27 136.12,77.27 135.83,76.97 135.83,76.71 136.33,76.21 136.74,76.21 137.27,75.69 137.77,75.69 138.19,75.27 138.53,75.27 138.94,74.86 138.94,74.76 139.07,74.63 139.47,74.63 139.83,74.27 140.2,74.27 140.62,74.68 141.2,74.68 141.64,74.23 141.98,74.23 142.41,74.67 142.92,74.67 143.44,74.15 143.75,74.15 143.99,73.9 160.52,73.9 161.32,74.7 161.32,74.82 160.61,75.53 160.61,75.79 160.84,76.02 161.11,76.02 161.82,75.31 161.93,75.31 162.06,75.44 162.06,75.55 161.35,76.26 161.35,76.53 161.58,76.76 161.84,76.76 162.55,76.05 162.67,76.05 162.79,76.17 162.79,76.28 162.08,76.99 162.08,77.26 162.31,77.49 162.58,77.49 163.28,76.78 163.4,76.78 163.52,76.9 163.52,77.02 162.81,77.73 162.81,77.99 163.04,78.22 163.31,78.22 164.02,77.51 164.13,77.51 167.15,80.54 168.57,80.54 168.82,80.78 168.82,81.08 168.67,81.23 168.06,81.23 167.88,81.42 167.88,81.74 168.06,81.93 168.32,81.93 168.4,82.01 168.4,82.19 168.32,82.27 168.06,82.27 167.88,82.46 167.88,82.78 168.06,82.97 168.32,82.97 168.4,83.05 168.4,85.11 171,87.71 171.27,87.71 171.75,87.23 171.87,87.23 171.99,87.35 171.99,87.46 171.41,88.04 171.41,88.71 172.89,90.19 175.55,90.19 175.81,89.93 175.81,88.92 175.9,88.84 176.07,88.84 176.15,88.92 176.15,89.56 176.34,89.75 176.66,89.75 176.85,89.56 176.85,88.92 176.93,88.84 177.27,88.84 177.71,89.28 177.71,91.3 179.38,92.97 180.77,92.97 181.02,93.22 181.02,93.95 180.83,94.15 180.83,94.94 181.72,95.83 182.82,95.83 183.44,96.44 183.91,96.44 184.1,96.26 184.1,95.91 184.18,95.83 184.35,95.83 184.43,95.91 184.43,96.26 184.62,96.44 187.28,96.44 187.47,96.26 187.47,95.85 187.55,95.77 187.73,95.77 187.81,95.85 187.81,96.26 188,96.44 188.2,96.44 188.36,96.6 188.54,96.6 188.69,96.44 188.87,96.44 189.03,96.6 189.21,96.6 189.36,96.44 189.5,96.44 190.06,97.01 190.06,97.23 190.19,97.35 190.41,97.35 190.72,97.66 190.72,98.06 190.58,98.2 190.58,98.4 190.72,98.54 190.72,98.8 191.58,99.66 191.58,100.07 191.22,100.44 191.22,101.77 191.07,101.92 190.87,101.92 190.74,102.05 190.74,102.25 190.6,102.39 190.4,102.39 190.26,102.53 190.26,102.72 190.18,102.81 190.18,103.28 190.05,103.41 190.05,103.62 190.18,103.74 190.18,103.95 190.05,104.08 190.05,104.29 190.18,104.41 190.18,104.62 190.13,104.67 190.13,105.04 190.18,105.08 190.18,105.23 v1(189.84,105.57)
DDR4_DDIMM_TDQS_N10: length 75.6
  L05_SIG2 w0.081: v1(133.85,79.17) 134.1,79.31 arc(134.12,79.33) 134.14,79.35 134.13,79.41 arc(134.13,79.42) 134.13,79.42 arc(134.12,79.43) 134.11,79.45 arc(134.11,79.45) 134.11,79.45 134.09,79.49 arc(134.09,79.49) 134.09,79.5 arc(134.09,79.5) 134.09,79.5 arc(134.04,79.67) 134.11,79.83 arc(134.12,79.84) 134.12,79.84 arc(134.12,79.84) 134.12,79.84 arc(134.15,79.87) 134.17,79.91 arc(134.21,79.96) 134.25,80.01 arc(134.3,80.06) 134.36,80.1 arc(134.5,80.16) 134.65,80.18 134.72,80.18 arc(134.83,80.2) 134.93,80.27 arc(135.01,80.42) 135,80.59 arc(134.99,80.62) 134.98,80.64 arc(134.97,80.67) 134.96,80.7 arc(134.93,80.78) 134.9,80.86 arc(134.89,80.92) 134.88,80.99 134.88,81.95 arc(134.87,82.01) 134.84,82.06 134.76,82.14 arc(134.6,82.38) 134.54,82.67 134.54,83.03 arc(134.51,83.29) 134.4,83.54 134.27,83.81 arc(134.25,83.85) 134.22,83.88 133.86,84.42 arc(133.82,84.51) 133.81,84.6 133.81,88.17 arc(133.93,88.76) 134.26,89.26 135.17,90.17 arc(135.67,90.51) 136.26,90.62 154.38,90.62 154.46,90.7 154.46,91.71 154.65,91.9 154.97,91.9 155.16,91.71 155.16,90.7 155.24,90.62 155.42,90.62 155.5,90.7 155.5,91.71 155.68,91.9 156.01,91.9 156.2,91.71 156.2,90.7 156.28,90.62 156.45,90.62 156.53,90.7 156.53,91.71 156.72,91.9 157.05,91.9 157.23,91.71 157.23,90.7 157.32,90.62 158.82,90.62 163.61,95.41 171.28,95.41 171.89,96.02 172.96,96.02 173.12,96.18 173.58,96.18 173.75,96.02 176.87,96.02 177.3,96.44 178.17,96.44 180.96,99.23 180.96,101.16 180.62,101.5 180.62,102.85 180.83,103.06 180.83,105.23 v1(180.49,105.57)
DDR4_DDIMM_TDQS_N11: length 55.1
  L16_SIG6 w0.076: v1(141.02,76.87) 141.29,77.02 141.32,77.11 arc(141.31,77.12) 141.31,77.13 arc(141.27,77.37) 141.34,77.6 141.34,77.6 arc(141.54,77.8) 141.81,77.88 141.82,77.88 arc(142,77.93) 142.14,78.06 142.16,78.1 arc(142.21,78.27) 142.17,78.44 arc(142.15,78.47) 142.13,78.49 arc(142.01,78.59) 141.86,78.62 arc(141.69,78.65) 141.54,78.73 arc(141.54,78.73) 141.53,78.74 arc(141.47,78.79) 141.41,78.85 arc(141.4,78.86) 141.39,78.87 arc(141.38,78.88) 141.37,78.89 141.31,78.95 arc(141.22,79.18) 141.31,79.4 141.31,79.41 141.68,79.78
  L16_SIG6 w0.081: v1(171.14,105.57) 171.45,105.26 171.45,101.31 171.61,101.16 171.61,100.06 171.44,99.9 170.91,99.9 170.59,99.57 170.59,98.93 170.78,98.74 171.42,98.74 171.5,98.66 171.5,98.49 171.42,98.4 170.78,98.4 170.59,98.22 170.59,97.89 170.78,97.7 171.42,97.7 171.5,97.62 171.5,97.45 171.42,97.37 170.78,97.37 170.59,97.18 170.59,96.71 170.33,96.46 169.47,96.46 169.18,96.17 169.18,94.94 165.64,91.39 163.08,91.39 161.01,89.32 148.88,89.32 144.92,85.36 144.92,83.58 142.1,80.76 142.1,80.2 141.68,79.78
DDR4_DDIMM_TDQS_N12: length 45.7
  L03_SIG1 w0.081: v1(161.79,105.57) 161.88,105.57 arc(162.07,105.48) 162.16,105.29 162.16,105.18 arc(162.09,105.03) 161.95,104.97 160.7,104.97 160.42,104.94 160.34,104.89 159.93,104.66 159.16,103.89 arc(158.97,103.6) 158.9,103.26 158.9,101.08 arc(158.88,100.96) 158.83,100.86 arc(158.74,100.66) 158.71,100.44 158.71,98.44 arc(158.74,98.32) 158.81,98.21 158.97,98.05 arc(159.21,97.69) 159.29,97.27 arc(159.29,97.23) 159.29,97.19 arc(159.04,96.23) 158.59,95.34 arc(158.32,94.88) 158.1,94.38 158.02,94.15 arc(157.99,94.09) 157.94,94.03 156.74,92.83 arc(156.62,92.74) 156.47,92.69 arc(156.22,92.6) 156.01,92.45 153.14,89.58 arc(152.65,89.25) 152.08,89.14 151.15,89.14 151.07,89.22 151.07,89.44 150.88,89.63 150.55,89.63 150.37,89.44 150.37,89.22 150.28,89.14 150.11,89.14 150.03,89.22 150.03,89.44 149.84,89.63 149.52,89.63 149.33,89.44 149.33,89.22 149.25,89.14 149.08,89.14 148.99,89.22 148.99,89.44 148.81,89.63 148.48,89.63 148.29,89.44 148.29,89.22 148.21,89.14 147.54,89.14 arc(147.44,89.12) 147.36,89.08 arc(147.31,89.05) 147.27,89.01 144.63,86.37 arc(144.44,86.08) 144.37,85.74 144.37,84.61 arc(144.35,84.49) 144.28,84.39 143.42,83.53 arc(142.93,83.2) 142.36,83.09 140.46,83.09 arc(139.49,82.92) 138.63,82.42 arc(138.52,82.35) 138.39,82.3 arc(138.1,82.13) 137.94,81.84 arc(137.93,81.77) 137.92,81.71 137.92,80.21 arc(137.95,80.08) 138.02,79.97 138.35,79.64 138.7,79.64 138.86,79.5 138.88,79.48 138.91,79.42 arc(138.92,79.36) 138.88,79.31 v2(138.63,79.17)
DDR4_DDIMM_TDQS_N13: length 68.2
  L14_SIG5 w0.076: 133.13,82.17 133.11,82.16 133.11,82.16 133.06,82.1 arc(132.85,81.8) 132.78,81.43 132.78,81.14 arc(132.78,81.09) 132.76,81.04 132.63,80.89 arc(132.5,80.63) 132.54,80.34 132.62,80.16 arc(132.64,80.12) 132.64,80.09 arc(132.63,80.04) 132.63,80 arc(132.62,79.98) 132.61,79.96 132.58,79.91 arc(132.53,79.82) 132.5,79.73 132.5,79.66 arc(132.5,79.63) 132.5,79.61 132.52,79.51 arc(132.53,79.47) 132.54,79.43 132.6,79.31 132.6,79.31 arc(132.63,79.16) 132.59,79.01 132.57,78.96 arc(132.51,78.7) 132.58,78.44 arc(132.58,78.07) 132.28,77.88 132.24,77.88 arc(131.98,77.81) 131.79,77.62 131.78,77.6 arc(131.71,77.37) 131.75,77.13 arc(131.75,77.12) 131.75,77.11 131.73,77.02 v1(131.46,76.87)
  L14_SIG5 w0.081: 133.13,82.17 133.21,82.26 133.28,82.37 133.28,89.28 128.89,93.67 128.89,98.09 122.01,104.98 121.49,104.98 121.41,104.89 121.41,103.75 121.22,103.56 120.9,103.56 120.71,103.75 120.71,105.1 120.6,105.21 120.46,105.21 120.38,105.13 120.38,103.75 120.19,103.56 119.86,103.56 119.68,103.75 119.68,105.1 119.56,105.21 119.42,105.21 119.34,105.13 119.34,103.75 119.15,103.56 118.83,103.56 118.64,103.75 118.64,105.1 118.53,105.21 116.44,105.21 116.36,105.13 116.36,103.91 116.17,103.72 115.84,103.72 115.66,103.91 115.66,105.13 115.57,105.21 115.4,105.21 115.32,105.13 115.32,103.91 115.13,103.72 114.81,103.72 114.62,103.91 114.62,105.13 114.54,105.21 112.33,105.21 112.14,105.4 112.14,105.83 112.06,105.92 111.89,105.92 111.8,105.83 111.8,105.4 111.62,105.21 111.29,105.21 111.1,105.4 111.1,105.83 111.02,105.92 110.85,105.92 110.77,105.83 110.77,105.4 110.58,105.21 110.26,105.21 110.07,105.4 110.07,105.83 109.99,105.92 109.81,105.92 109.73,105.83 109.73,105.4 109.35,105.02 107.26,105.02 106.87,105.41 106.87,106.64 v1(106.54,106.96)
DDR4_DDIMM_TDQS_N14: length 69
  L14_SIG5 w0.076: v1(126.68,76.87) 126.95,77.02 126.97,77.1 arc(126.85,77.2) 126.7,77.24 126.68,77.24 arc(126.42,77.31) 126.22,77.49 126.21,77.52 arc(126.13,77.79) 126.21,78.06 arc(126.26,78.25) 126.21,78.43 126.2,78.44 arc(126.2,78.45) 126.2,78.45 126.19,78.46 126.16,78.49 126.16,78.92 126.19,78.95 arc(126.19,78.95) 126.2,78.96 arc(126.22,78.99) 126.24,79.03 arc(126.25,79.07) 126.25,79.11 126.25,79.24 arc(126.25,79.26) 126.25,79.28 126.22,79.33 126.19,79.38 arc(126.13,79.63) 126.2,79.88 126.22,79.93 arc(126.25,80.09) 126.2,80.25 arc(126.12,80.44) 126.13,80.64 126.14,80.7 arc(126.15,80.7) 126.15,80.71 arc(126.16,80.74) 126.17,80.77 arc(126.2,80.82) 126.23,80.86 arc(126.3,81) 126.33,81.16 arc(126.33,81.16) 126.33,81.16 arc(126.33,81.23) 126.32,81.3 126.3,81.38 arc(126.28,81.42) 126.25,81.44 arc(126.21,81.46) 126.17,81.47 125.99,81.47 125.99,81.47 125.92,81.47
  L14_SIG5 w0.081: v1(97.19,105.59) 97.53,105.25 97.53,102.98 97.32,102.77 96.28,102.77 95.97,102.46 95.97,101.58 95.76,101.37 95.76,99.85 96.76,98.84 96.76,97.55 98.55,95.76 98.55,91.84 99.24,91.15 100.04,91.15 100.24,91.35 100.24,92.23 100.32,92.31 100.49,92.31 100.58,92.23 100.58,91.37 100.79,91.15 101.08,91.15 101.28,91.35 101.28,92.23 101.36,92.31 101.53,92.31 101.61,92.23 101.61,91.37 101.83,91.15 103.15,91.15 103.35,91.35 103.35,92.23 103.43,92.31 103.6,92.31 103.68,92.23 103.68,91.37 103.9,91.15 104.19,91.15 104.39,91.35 104.39,92.23 104.47,92.31 104.64,92.31 104.72,92.23 104.72,91.37 104.94,91.15 105.22,91.15 105.42,91.35 105.42,92.23 105.5,92.31 105.68,92.31 105.76,92.23 105.76,91.37 105.98,91.15 107.98,91.15 108.17,91.34 108.17,92.2 108.28,92.31 108.44,92.31 108.52,92.23 108.52,91.37 108.74,91.15 109.36,91.15 110.16,91.96 110.99,91.96 111.78,91.17 114.76,91.17 117.21,88.72 123.03,88.72 123.66,88.09 123.66,84.3 125.06,82.9 125.06,82.11 125.68,81.49 125.74,81.47 125.92,81.47
DDR4_DDIMM_TDQS_N15: length 84.9
  L16_SIG6 w0.076: v1(130.66,74.57) 130.92,74.72 arc(130.96,74.76) 130.95,74.82 130.92,74.87 130.92,74.88 130.89,74.91 arc(130.86,74.96) 130.85,75.02 130.84,75.04 arc(130.85,75.16) 130.92,75.26 131.15,75.49 arc(131.23,75.55) 131.34,75.57 131.51,75.57 arc(131.8,75.74) 131.81,76.08 131.79,76.12 131.79,76.12 arc(131.73,76.41) 131.79,76.69 131.82,76.76 arc(131.85,76.9) 131.8,77.03 arc(131.71,77.3) 131.78,77.59 arc(131.83,77.79) 131.77,77.99 arc(131.71,78.23) 131.75,78.47 arc(131.78,78.52) 131.81,78.57 arc(131.83,78.6) 131.84,78.63 arc(131.85,78.66) 131.85,78.68 arc(131.85,78.72) 131.84,78.75 131.8,78.86 arc(131.79,78.89) 131.77,78.91 131.76,78.95 arc(131.71,79.06) 131.68,79.18 131.67,79.2 arc(131.66,79.26) 131.66,79.31 131.66,81.01 131.69,81.05 131.72,81.2 131.86,81.43 131.92,81.49 132.12,81.69 arc(132.14,81.71) 132.16,81.74 132.28,82 132.28,82.01
  L16_SIG6 w0.081: v1(87.84,105.64) 87.88,105.64 88.16,105.36 88.16,104.75 88.08,104.67 87.27,104.67 87.08,104.48 87.08,104.16 87.27,103.97 88.08,103.97 88.16,103.89 88.16,103.51 88.66,103.01 94.15,103.01 95.03,102.13 97.58,102.13 97.77,102.32 97.77,102.67 97.85,102.75 98.03,102.75 98.11,102.67 98.11,102.32 98.3,102.13 98.62,102.13 98.81,102.32 98.81,102.67 98.89,102.75 99.06,102.75 99.14,102.67 99.14,102.32 99.33,102.13 99.66,102.13 99.84,102.32 99.84,102.67 99.93,102.75 100.1,102.75 100.18,102.67 100.18,102.32 100.37,102.13 100.69,102.13 100.88,102.32 100.88,102.67 100.96,102.75 101.13,102.75 101.22,102.67 101.22,102.32 101.4,102.13 101.73,102.13 101.92,102.32 101.92,102.47 102,102.55 102.17,102.55 102.25,102.47 102.25,102.32 102.44,102.13 106.46,102.13 106.88,101.72 106.88,101.51 108,100.39 108,100.27 107.48,99.74 107.48,99.48 107.7,99.25 107.97,99.25 108.5,99.78 108.61,99.78 108.76,99.63 109.3,99.63 110.28,98.66 110.28,97.91 111.04,97.15 111.04,97.03 110.56,96.56 110.56,96.29 110.79,96.06 111.06,96.06 111.53,96.54 111.65,96.54 111.8,96.38 116.74,96.38 116.82,96.3 116.82,95.78 117.02,95.58 117.33,95.58 117.52,95.77 117.52,96.3 117.6,96.38 117.77,96.38 117.85,96.3 117.85,95.65 118.04,95.47 118.37,95.47 118.55,95.65 118.55,96.3 118.64,96.38 118.81,96.38 118.89,96.3 118.89,95.9 119.08,95.71 119.4,95.71 119.59,95.9 119.59,96.3 119.67,96.38 120.07,96.38 120.78,95.67 120.78,94.42 123.96,91.24 124.89,91.24 128.45,91.24 131.16,88.54 131.16,88.42 130.69,87.95 130.69,87.68 130.92,87.45 131.18,87.45 131.65,87.93 131.77,87.93 131.89,87.81 131.89,87.69 131.42,87.22 131.42,86.95 131.65,86.72 131.92,86.72 132.39,87.19 132.5,87.19 132.67,87.02 132.67,84.55 132.5,84.37 132.5,84.37 132.36,84.23 arc(132.34,84.2) 132.34,84.16 132.34,82.22 132.28,82.01
DDR4_DDIMM_TDQS_N16: length 77.7
  L16_SIG6 w0.076: v1(125.88,74.57) 126.14,74.72 arc(126.17,74.76) 126.17,74.82 126.13,74.88 arc(126.13,74.89) 126.12,74.89 arc(126.03,74.95) 125.93,74.97 125.89,74.97 arc(125.78,74.95) 125.68,74.88 125.38,74.58 arc(125.08,74.46) 124.78,74.58 124.48,74.88 arc(124.39,74.95) 124.27,74.97 arc(124.1,75) 123.96,75.1 123.78,75.28 arc(123.64,75.37) 123.49,75.4 123.37,75.4 arc(123.29,75.41) 123.21,75.45 122.88,75.77 arc(122.82,75.82) 122.74,75.83 122.73,75.83 arc(122.67,75.84) 122.6,75.85 arc(122.57,75.86) 122.53,75.87 arc(122.53,75.87) 122.53,75.87 arc(122.4,75.94) 122.29,76.04 122.21,76.15 arc(122.16,76.23) 122.15,76.32 arc(122.14,76.37) 122.14,76.41 arc(122.15,76.46) 122.16,76.52 arc(122.17,76.59) 122.2,76.66 122.26,76.76 arc(122.29,76.89) 122.26,77.01 122.19,77.1 arc(122.13,77.31) 122.18,77.52 arc(122.18,77.53) 122.19,77.53 arc(122.19,77.54) 122.19,77.55 arc(122.2,77.56) 122.21,77.58 arc(122.23,77.62) 122.26,77.65 arc(122.26,77.65) 122.26,77.66 arc(122.28,77.69) 122.31,77.71 122.31,77.72 arc(122.33,77.74) 122.34,77.76 arc(122.35,77.81) 122.32,77.85 arc(122.18,78.08) 122.16,78.34 arc(122.16,78.36) 122.16,78.37 arc(122.18,78.45) 122.21,78.52 arc(122.27,78.67) 122.25,78.83 arc(122.24,78.85) 122.24,78.87 arc(122.23,78.89) 122.22,78.9 arc(122.15,79.18) 122.22,79.45 arc(122.27,79.63) 122.22,79.82 arc(122.18,79.9) 122.17,80 122.17,80.18 arc(122.18,80.28) 122.22,80.37 arc(122.24,80.4) 122.26,80.44 arc(122.27,80.53) 122.27,80.63 arc(122.26,80.66) 122.24,80.7 122.21,80.76 arc(122.2,80.78) 122.19,80.79 122.13,80.84 arc(122.05,80.97) 122.02,81.12 122.01,81.13 122.01,81.52
  L16_SIG6 w0.081: 122.01,81.52 122.01,81.78 arc(121.95,82.07) 121.79,82.32 121.75,82.36 arc(121.4,82.59) 120.99,82.67 108.96,82.67 108.63,83 105.73,83 arc(105.06,83.14) 104.49,83.52 95.4,92.6 85.07,92.6 arc(84.26,92.76) 83.57,93.22 83.14,93.65 arc(82.91,93.83) 82.65,93.95 arc(82.59,93.97) 82.53,93.99 81.93,94.24 arc(81.86,94.27) 81.8,94.32 81.64,94.48 arc(81.61,94.51) 81.58,94.53 arc(81.4,94.63) 81.21,94.69 arc(81.17,94.69) 81.13,94.69 arc(80.59,94.81) 80.14,95.12 75.25,100 arc(75.22,100.04) 75.18,100.08 arc(74.98,100.44) 74.89,100.83 arc(74.8,101.31) 74.53,101.71 74.39,101.85 arc(73.91,102.57) 73.74,103.42 73.74,105.43 arc(73.74,105.46) 73.73,105.48 arc(73.76,105.74) 73.9,105.96 arc(73.93,105.98) 73.95,106 arc(73.97,106.03) 73.99,106.04 74.14,106.2 arc(74.67,106.55) 75.29,106.67 76.01,106.67 arc(76.7,106.53) 77.29,106.14 77.56,105.87 77.67,105.79 77.7,105.77 77.71,105.76 77.72,105.76 77.75,105.74 77.78,105.74 78.49,105.74 arc(78.6,105.76) 78.68,105.81 78.77,105.9 arc(78.79,105.93) 78.79,105.96 78.79,106.08 78.61,106.26 v1(78.49,106.26)
DDR4_DDIMM_TDQS_N17: length 45.4
  L03_SIG1 w0.076: 131.34,82.3 131.33,82.29 131.33,82.29 130.85,81.8 130.61,81.8 130.14,81.33 130.14,80.8 130.24,80.7 130.24,80.5 arc(130.23,80.46) 130.23,80.43 arc(130.21,80.38) 130.19,80.34 arc(130.16,80.31) 130.14,80.28 130.08,80.24 arc(130.06,80.22) 130.03,80.2 arc(130.03,80.2) 130.03,80.2 arc(130.02,80.2) 130.01,80.19 arc(130,80.19) 129.99,80.19 129.81,80.19 arc(129.69,80.18) 129.57,80.14 arc(129.53,80.13) 129.49,80.11 arc(129.41,80.07) 129.35,80.01 arc(129.29,79.89) 129.25,79.75 arc(129.25,79.66) 129.28,79.57 129.32,79.5 arc(129.33,79.48) 129.33,79.46 arc(129.33,79.44) 129.33,79.42 129.29,79.28 129.09,79.17 v2(129.09,79.16)
  L03_SIG1 w0.081: v1(152.44,105.57) 152.52,105.57 152.72,105.36 152.72,104.4 152.58,104.25 151.89,104.25 151.7,104.06 151.7,103.74 151.89,103.55 152.85,103.55 152.93,103.47 152.93,103.3 152.85,103.21 151.92,103.21 151.73,103.03 151.73,102.7 151.92,102.51 152.58,102.51 152.66,102.43 152.66,101.42 152.91,101.18 152.91,100.47 151.57,99.13 151.36,99.13 150.93,98.7 150.93,98.21 150.32,97.6 149.93,97.6 142.98,90.66 142.18,90.66 142.18,90.66 136.25,90.66 135.2,89.61 134.58,89.61 132.87,87.91 132.87,85.09 131.34,83.56 131.34,82.3
DDR4_DIMM2_CK_N0: length 85.4
  L07_SIG3 w0.076: v1(114.73,76.41) 114.98,76.27 arc(115.01,76.21) 114.99,76.15 114.93,76.08 arc(114.92,76.08) 114.92,76.07 arc(114.86,76.04) 114.8,76.03 114.79,76.03 arc(114.66,76.04) 114.55,76.09 arc(114.46,76.16) 114.4,76.24 arc(114.39,76.27) 114.38,76.29 arc(114.35,76.36) 114.34,76.44 arc(114.35,76.49) 114.37,76.55 arc(114.48,76.87) 114.37,77.19 arc(114.35,77.24) 114.34,77.3 114.34,77.43 arc(114.34,77.48) 114.36,77.52 arc(114.44,77.76) 114.39,78.01 arc(114.35,78.12) 114.34,78.24 arc(114.35,78.33) 114.39,78.41 arc(114.48,78.72) 114.37,79.03 arc(114.35,79.08) 114.34,79.14 114.34,80.64 114.34,80.64 114.34,80.66
  L07_SIG3 w0.089: 114.34,80.66 114.34,80.81 114.06,81.1 114.06,86.96 113.21,87.8 108.69,87.8 108.6,87.89 108.6,91.28 108.4,91.48 108.08,91.48 107.88,91.28 107.88,87.89 107.79,87.8 107.63,87.8 107.54,87.89 107.54,91.28 107.34,91.48 107.01,91.48 106.81,91.28 106.81,87.89 106.72,87.8 106.56,87.8 106.47,87.89 106.47,91.28 106.27,91.48 105.95,91.48 105.75,91.28 105.75,87.89 105.66,87.8 105.42,87.8 105.23,87.99 105.23,93.63 106.04,94.44 106.04,98.07 106.26,98.28 106.26,98.75 106,99.01 106,99.45 108.01,101.46 108.57,101.46 108.86,101.16 109.33,101.16 109.81,101.65 115.14,101.65 116.53,100.26 129.53,100.26 arc(129.59,100.23) 129.61,100.17 arc(129.64,100.11) 129.7,100.09 129.79,100.09 arc(129.85,100.11) 129.88,100.17 arc(129.9,100.23) 129.96,100.26 130.06,100.26 arc(130.12,100.23) 130.15,100.17 arc(130.17,100.11) 130.23,100.09 130.33,100.09 arc(130.39,100.11) 130.41,100.17 arc(130.44,100.23) 130.5,100.26 130.59,100.26 arc(130.65,100.23) 130.68,100.17 arc(130.7,100.11) 130.76,100.09 130.86,100.09 arc(130.92,100.11) 130.95,100.17 arc(130.97,100.23) 131.03,100.26 131.13,100.26 arc(131.19,100.23) 131.21,100.17 arc(131.24,100.11) 131.3,100.09 131.39,100.09 arc(131.45,100.11) 131.48,100.17 arc(131.5,100.23) 131.56,100.26 131.66,100.26 arc(131.72,100.23) 131.75,100.17 arc(131.77,100.11) 131.83,100.09 131.93,100.09 arc(131.99,100.11) 132.01,100.17 arc(132.04,100.23) 132.1,100.26 132.19,100.26 arc(132.25,100.23) 132.28,100.17 arc(132.3,100.11) 132.36,100.09 132.46,100.09 arc(132.52,100.11) 132.55,100.17 arc(132.57,100.23) 132.63,100.26 132.8,100.26 133.22,99.83 133.22,99.55 133.01,99.34 v1(132.89,99.34)
DDR4_DIMM2_CK_N1: length 88.8
  BOTTOM w0.149: v1(132.9,94.67) 133.05,94.67 133.2,94.52 133.2,93.28 132.73,92.81 128.28,92.81 128.08,93.01 128.08,93.83 127.82,94.1 127.44,94.1 127.18,93.83 127.18,92.9 127.06,92.78 126.89,92.78 126.78,92.9 126.78,93.83 126.51,94.1 126.14,94.1 125.87,93.83 125.87,92.9 125.76,92.78 125.59,92.78 125.47,92.9 125.47,93.83 125.21,94.1 124.83,94.1 124.57,93.83 124.57,92.9 124.45,92.78 119.6,92.78 118.43,91.61 115.75,91.61 115.67,91.53 111.87,91.53 110.89,90.54 106.27,90.54 105.01,91.81 102.65,91.81 102.36,91.51 102.36,90.44 102.65,90.15 103.51,90.15 104.7,88.95 108.75,88.95 109.33,88.37 109.75,88.37 110.02,88.64 110.02,89.24 110.14,89.36 110.3,89.36 110.42,89.24 110.42,88.64 110.68,88.37 111.06,88.37 111.32,88.64 111.32,89.24 111.44,89.36 111.61,89.36 111.73,89.24 111.73,88.64 112,88.37 112.74,88.37 113.01,88.64 113.01,89.91 113.13,90.02 113.3,90.02 113.42,89.91 113.42,88.64 113.68,88.37 114.22,88.37 116.5,90.65 116.92,90.65 117.08,90.49 117.08,90.28 114.68,87.88 114.68,87.5 115.29,86.89 115.29,84.94 115.64,84.59 115.64,84.3 115.52,84.18 115.09,84.18 114.83,83.92 114.83,83.54 115.09,83.28 115.52,83.28 115.64,83.16 115.64,83 115.52,82.88 115.09,82.88 114.83,82.61 114.83,82.24 115.09,81.97 115.52,81.97 115.64,81.86 115.64,81.65 115.49,81.5 113.95,81.5 113.69,81.23 113.69,80.86 113.95,80.59 115.32,80.59 115.55,80.37 115.55,79.68 115.4,79.53 113.5,79.53 113.08,79.11 112.17,79.11 111.77,78.72 111.44,78.72 111.14,78.42 111.14,78.08 111.23,77.99 111.23,77.65 110.74,77.16 v1(110.74,76.87)
DDR4_DIMM2_CK_P0: length 85.3
  L07_SIG3 w0.076: v1(115.52,75.95) 115.27,76.1 arc(115.21,76.1) 115.17,76.07 arc(115.16,76.07) 115.16,76.07 115.16,76.07 115.06,75.96 arc(115.05,75.95) 115.04,75.94 arc(114.93,75.87) 114.8,75.85 114.79,75.85 arc(114.62,75.87) 114.46,75.94 arc(114.4,75.98) 114.34,76.03 arc(114.29,76.09) 114.24,76.16 arc(114.23,76.18) 114.23,76.2 arc(114.18,76.31) 114.16,76.44 arc(114.18,76.55) 114.23,76.65 arc(114.3,76.87) 114.23,77.09 arc(114.18,77.19) 114.16,77.3 114.16,77.43 arc(114.17,77.53) 114.21,77.61 arc(114.26,77.77) 114.23,77.93 arc(114.18,78.08) 114.16,78.24 arc(114.18,78.38) 114.24,78.51 arc(114.3,78.72) 114.23,78.93 arc(114.18,79.03) 114.16,79.14 114.16,80.64 114.15,80.64 114.15,80.66
  L07_SIG3 w0.089: 114.15,80.66 114.15,80.73 113.87,81.02 113.87,86.88 113.14,87.61 108.61,87.61 108.41,87.81 108.41,91.2 108.32,91.29 108.16,91.29 108.07,91.2 108.07,87.81 107.87,87.61 107.55,87.61 107.35,87.81 107.35,91.2 107.26,91.29 107.09,91.29 107,91.2 107,87.81 106.8,87.61 106.48,87.61 106.28,87.81 106.28,91.2 106.19,91.29 106.03,91.29 105.94,91.2 105.94,87.81 105.74,87.61 105.35,87.61 105.04,87.91 105.04,93.71 105.85,94.52 105.85,98.15 106.07,98.36 106.07,98.67 105.81,98.93 105.81,99.53 107.93,101.65 108.64,101.65 108.94,101.35 109.25,101.35 109.73,101.84 115.22,101.84 116.61,100.45 132.88,100.45 133.41,99.91 133.41,99.56 133.63,99.34 v1(133.74,99.34)
DDR4_DIMM2_CK_P1: length 88.8
  BOTTOM w0.149: v1(133.74,94.67) 133.6,94.67 133.45,94.52 133.45,93.17 132.84,92.56 128.18,92.56 127.83,92.91 127.83,93.73 127.71,93.85 127.55,93.85 127.43,93.73 127.43,92.79 127.16,92.53 126.79,92.53 126.53,92.79 126.53,93.73 126.41,93.85 126.24,93.85 126.12,93.73 126.12,92.79 125.86,92.53 125.49,92.53 125.22,92.79 125.22,93.73 125.1,93.85 124.94,93.85 124.82,93.73 124.82,92.79 124.55,92.53 119.7,92.53 118.54,91.36 115.86,91.36 115.77,91.28 111.98,91.28 110.99,90.29 108.42,90.29 108.3,90.18 108.3,89.96 108.18,89.85 108.01,89.85 107.9,89.96 107.9,90.18 107.78,90.29 107.61,90.29 107.49,90.18 107.49,89.96 107.38,89.85 107.21,89.85 107.09,89.96 107.09,90.18 106.97,90.29 106.16,90.29 104.9,91.56 102.75,91.56 102.61,91.41 102.61,90.55 102.75,90.4 103.61,90.4 104.8,89.21 108.85,89.21 109.43,88.62 109.65,88.62 109.77,88.74 109.77,89.34 110.03,89.61 110.41,89.61 110.67,89.34 110.67,88.74 110.79,88.62 110.95,88.62 111.07,88.74 111.07,89.34 111.34,89.61 111.71,89.61 111.98,89.34 111.98,88.74 112.1,88.62 112.64,88.62 112.76,88.74 112.76,90.01 113.03,90.27 113.4,90.27 113.67,90.01 113.67,88.74 113.79,88.62 114.11,88.62 116.39,90.91 117.02,90.91 117.33,90.6 117.33,90.18 114.93,87.77 114.93,87.61 115.54,87 115.54,85.04 115.89,84.69 115.89,84.2 115.62,83.93 115.19,83.93 115.08,83.82 115.08,83.65 115.19,83.53 115.62,83.53 115.89,83.27 115.89,82.89 115.62,82.63 115.19,82.63 115.08,82.51 115.08,82.34 115.19,82.22 115.62,82.22 115.89,81.96 115.89,81.54 115.59,81.25 114.05,81.25 113.94,81.13 113.94,80.96 114.05,80.85 115.43,80.85 115.8,80.48 115.8,79.58 115.5,79.28 113.6,79.28 112.55,78.23 112.1,78.23 111.93,78.07 111.93,77.72 v1(111.54,77.33)
DDR4_DIMM2_CKE0: length 90.3
  BOTTOM w0.149: v1(117.12,75.03) 117.52,75.72 arc(117.58,75.95) 117.52,76.18 arc(117.46,76.4) 117.51,76.62 117.53,76.66 arc(117.58,76.88) 117.52,77.1 arc(117.46,77.33) 117.52,77.56 117.52,77.56 arc(117.58,77.79) 117.52,78.02 arc(117.46,78.25) 117.52,78.48 117.52,78.48 arc(117.58,78.71) 117.52,78.94 arc(117.47,79.05) 117.46,79.17 117.3,79.32 117.3,88.12 119.94,90.76 133.47,90.76 133.49,90.78 133.5,90.78 135.02,92.3 135.69,92.3 135.92,92.54 135.92,93.2 137.01,94.29 137.01,95.37 137.16,95.51 137.45,95.51 137.6,95.37 137.6,94.21 137.75,94.06 138.08,94.06 138.74,93.4 138.98,93.4 139.79,92.59 141.05,92.59 141.2,92.73 141.2,93.62 141.35,93.77 141.64,93.77 141.79,93.62 141.79,92.73 141.94,92.59 142.24,92.59 142.39,92.73 142.39,93.62 142.54,93.77 142.83,93.77 142.98,93.62 142.98,92.73 143.13,92.59 144.23,92.59 145.01,91.8 145.01,91.59 144.6,91.19 144.6,90.98 144.81,90.77 145.02,90.77 145.43,91.17 145.64,91.17 146.53,90.28 146.74,90.28 146.95,90.49 146.95,90.7 144.23,93.42 144.23,93.63 145.64,95.04 145.64,96.05 145.49,96.19 145.22,96.19 145.07,96.05 145.07,95.65 144.92,95.5 144.62,95.5 144.47,95.65 144.47,96.05 144.33,96.19 141.71,96.19 141.56,96.34 141.56,98.69 141.9,99.03 141.9,99.6 141.01,100.48 140.45,100.48 140.14,100.8 140.14,101.36 139.55,101.94 139.55,104.69 139.91,105.05 140.29,105.05 141.66,106.42 142.68,106.42 143.21,105.89 143.21,101.3 145.13,99.38 R89.2
  vias: v1(145.64,99.34)
DDR4_DIMM2_CKE1: length 82.8
  L14_SIG5 w0.081: v1(146.49,93.34) 146.49,91.44 arc(146.49,91.4) 146.46,91.36 146.34,91.24 146.23,91.24 144.47,93 144.35,93 144.23,92.88 144.23,92.76 145.99,91 145.99,90.89 145.87,90.77 145.75,90.77 143.99,92.52 143.88,92.52 143.76,92.4 143.76,92.29 145.51,90.53 145.51,90.41 145.39,90.29 145.28,90.29 143.52,92.05 143.4,92.05 143.28,91.93 143.28,91.81 145.04,90.06 145.04,89.94 144.92,89.82 144.8,89.82 143.04,91.58 142.93,91.58 142.81,91.45 142.81,91.34 144.57,89.58 144.57,89.47 144.44,89.34 144.33,89.34 142.57,91.1 142.46,91.1 142.33,90.98 142.33,90.87 144.09,89.11 144.09,88.99 143.97,88.87 143.85,88.87 142.1,90.63 141.98,90.63 141.86,90.51 141.86,90.39 143.62,88.63 143.62,88.52 143.5,88.4 143.38,88.4 141.62,90.15 141.51,90.15 141.38,90.03 141.38,89.92 143.14,88.16 143.14,88.04 142.72,87.62 arc(142.7,87.59) 142.69,87.55 142.69,86 142.43,85.74 142.06,85.74 141.8,85.48 141.8,85 141.29,84.49 140.38,84.49 137.99,82.1 137.99,81.48 138.17,81.29 138.17,76.7 137.87,76.41 137.19,76.41 136.84,76.05 136.41,76.05 136.17,75.81 arc(136.05,75.65) 135.88,75.56 135.73,75.56 135.5,75.56 135.06,76 134.65,76 134.17,75.52 arc(134.14,75.5) 134.11,75.49 133.06,75.49 arc(132.83,75.43) 132.66,75.26 arc(132.49,75.09) 132.26,75.03 132.26,75.03 arc(132.03,74.97) 131.86,74.81 131.86,74.8 arc(131.69,74.63) 131.46,74.57 131.45,74.57 arc(131.23,74.63) 131.06,74.8 arc(130.9,74.97) 130.67,75.03 130.66,75.03 arc(130.44,74.97) 130.27,74.81 130.26,74.8 arc(130.1,74.63) 129.87,74.57 129.86,74.57 arc(129.63,74.63) 129.47,74.8 arc(129.3,74.97) 129.08,75.03 129.07,75.03 arc(128.84,74.97) 128.68,74.81 128.67,74.8 arc(128.5,74.63) 128.27,74.57 128.27,74.57 arc(128.04,74.63) 127.88,74.8 arc(127.71,74.97) 127.48,75.03 127.48,75.03 arc(127.25,74.97) 127.08,74.81 127.08,74.8 arc(126.91,74.63) 126.68,74.57 126.67,74.57 arc(126.45,74.63) 126.28,74.8 arc(126.12,74.97) 125.89,75.03 125.88,75.03 arc(125.66,74.97) 125.49,74.81 125.48,74.8 arc(125.32,74.63) 125.09,74.57 125.08,74.57 arc(124.85,74.63) 124.69,74.8 arc(124.52,74.97) 124.29,75.03 124.29,75.03 arc(124.06,74.97) 123.9,74.81 123.89,74.8 arc(123.72,74.63) 123.49,74.57 123.48,74.57 arc(123.26,74.63) 123.09,74.8 arc(122.93,74.97) 122.7,75.03 122.7,75.03 arc(122.47,74.97) 122.3,74.81 122.3,74.8 arc(122.13,74.63) 121.9,74.57 121.89,74.57 arc(121.67,74.63) 121.5,74.8 arc(121.33,74.97) 121.11,75.03 121.1,75.03 arc(120.88,74.97) 120.71,74.81 120.7,74.8 arc(120.53,74.63) 120.31,74.57 120.3,74.57 arc(120.07,74.63) 119.91,74.8 arc(119.74,74.97) 119.51,75.03 119.51,75.03 arc(119.28,74.97) 119.11,74.81 119.11,74.8 arc(118.94,74.63) 118.71,74.57 118.7,74.57 arc(118.48,74.63) 118.31,74.8 arc(118.15,74.97) 117.92,75.03 117.92,75.03 arc(117.69,74.97) 117.52,74.81 117.52,74.8 arc(117.35,74.63) 117.12,74.57 v1(116.32,74.57)
DDR4_DIMM2_CS_N0: length 84.7
  L03_SIG1 w0.081: v1(120.14,99.34) 120.14,100.42 120.27,100.55 120.39,100.55 121.57,99.37 121.69,99.37 121.81,99.49 121.81,99.6 120.62,100.79 120.62,100.9 120.74,101.02 120.86,101.02 121.76,100.12 121.88,100.12 122,100.25 122,100.36 121.14,101.21 121.14,102.38 121.23,102.46 122.26,102.46 122.34,102.54 122.34,102.71 122.26,102.79 121.23,102.79 121.14,102.87 121.14,103.05 121.23,103.13 122.26,103.13 122.34,103.21 122.34,103.38 122.26,103.46 121.23,103.46 121.14,103.55 121.14,103.72 121.23,103.8 122.26,103.8 122.34,103.88 122.34,104.05 122.26,104.13 121.23,104.13 121.14,104.22 121.14,104.39 121.23,104.47 121.84,104.47 121.92,104.55 121.92,104.72 121.84,104.81 121.23,104.81 121.14,104.89 121.14,105.31 121.06,105.39 120.66,105.39 120.58,105.31 120.58,101.94 119.44,100.8 119.44,98.87 119.72,98.59 119.72,97.88 119.8,97.8 121.56,97.8 121.64,97.72 121.64,97.54 121.56,97.46 118.38,97.46 118.29,97.38 118.29,97.22 118.39,97.13 121.95,97.13 122.03,97.05 122.03,96.87 121.95,96.79 118.38,96.79 118.29,96.71 118.29,96.55 118.39,96.46 122.03,96.46 122.11,96.38 122.11,96.2 122.03,96.12 118.87,96.12 118.77,96.03 118.77,95.87 118.86,95.79 122.03,95.79 122.11,95.71 122.11,95.53 122.03,95.45 119.8,95.45 119.72,95.37 119.72,95.2 119.8,95.12 121.62,95.12 121.7,95.03 121.7,94.86 121.62,94.78 119.8,94.78 119.72,94.7 119.72,94.53 119.8,94.45 121.35,94.45 121.43,94.36 121.43,94.19 121.35,94.11 119.82,94.11 119.56,93.85 119.56,91.94 119.73,91.76 119.73,84.17 118.29,82.73 118.29,77.18 118.29,77.17 118.29,76.56 118.29,75.85 118.56,75.57 v1(118.71,75.03)
DDR4_DIMM2_CS_N1: length 87.2
  TOP w0.149: J1.89 115.89,99.71 115.12,100.48 113.15,100.48 113.01,100.34 v1(103.73,100.34)
  L07_SIG3 w0.089: v1(103.73,100.34) 102.85,100.34 102.76,100.43 102.76,100.83 102.85,100.92 103.51,100.92 103.6,101.01 103.6,101.18 103.51,101.27 102.85,101.27 102.76,101.36 102.76,102.47 102.85,102.55 103.46,102.55 103.55,102.64 103.55,102.81 103.46,102.9 102.85,102.9 102.76,102.99 102.76,103.15 102.85,103.24 103.46,103.24 103.55,103.33 103.55,103.49 103.46,103.58 102.85,103.58 102.76,103.67 102.76,103.85 102.67,103.93 101.21,103.93 101.01,103.74 101.01,103.5 101.1,103.41 102.26,103.41 102.35,103.32 102.35,103.15 102.26,103.06 101.1,103.06 101.01,102.97 101.01,102.81 101.1,102.72 102.26,102.72 102.35,102.63 102.35,102.47 102.26,102.38 101.1,102.38 101.01,102.29 101.01,102.12 101.1,102.03 102.26,102.03 102.35,101.95 102.35,101.78 102.26,101.69 101.1,101.69 101.01,101.6 101.01,100.67 101.1,100.58 102.27,100.58 102.36,100.49 102.36,100.33 102.27,100.24 102.05,100.24 101.96,100.15 101.96,99.75 101.87,99.66 101.71,99.66 101.62,99.75 101.62,100.15 101.53,100.24 101.1,100.24 101.01,100.15 101.01,97.29 100.7,96.98 100.7,96.67 101.01,96.36 101.01,92.15 101.1,92.06 102.44,92.06 102.53,91.97 102.53,91.81 102.44,91.72 101.08,91.72 100.99,91.63 100.99,91.47 101.08,91.38 102.44,91.38 102.53,91.29 102.53,91.12 102.44,91.03 101.08,91.03 100.99,90.95 100.99,90.78 101.08,90.69 102.44,90.69 102.53,90.6 102.53,90.44 102.44,90.35 101.08,90.35 100.99,90.26 100.99,90.1 101.08,90.01 102.44,90.01 102.53,89.92 102.53,89.75 102.44,89.66 101.08,89.66 100.99,89.57 100.99,89.15 103.54,86.6 106.06,86.6 106.08,86.61 106.43,86.61 106.44,86.6 111.75,86.6 112.71,85.64 112.71,75.8 112.7,75.78 112.7,75.17 112.89,74.98 113.38,74.98 113.79,74.57 v1(114.73,74.57)
DDR4_DIMM2_EVENT_N: length 39.4
  L03_SIG1 w0.081: v1(93.61,104.86) 93.83,105.08 98.21,105.08 98.81,105.67 110.98,105.67 112.12,106.81 113.68,106.81 114.05,106.44 118.83,106.44 119.44,107.05 120.96,107.05 124.83,103.18 124.83,99.85 v1(125.19,99.49)
  BOTTOM w0.149: v1(93.61,104.86) U12.13
DDR4_DIMM2_ODT0: length 87.4
  L05_SIG2 w0.081: v1(117.61,98.25) 117.61,99.05 117.48,99.17 117.16,99.17 117.07,99.09 117.07,98.73 116.99,98.65 116.82,98.65 116.74,98.73 116.74,99.09 116.66,99.17 116.37,99.17 115.87,98.67 115.87,97.89 115.95,97.81 117.96,97.81 118.05,97.73 118.05,97.57 117.95,97.47 115.11,97.47 115.01,97.37 115.01,97.24 115.11,97.14 117.96,97.14 118.05,97.06 118.05,96.89 117.95,96.8 115.12,96.8 115.02,96.7 115.02,96.57 115.12,96.47 115.34,96.47 115.42,96.39 115.42,96.22 115.5,96.14 115.67,96.14 115.75,96.22 115.75,96.39 115.84,96.47 117.96,96.47 118.05,96.39 118.05,96.22 117.95,96.13 117.9,96.13 117.82,96.05 117.82,95.83 117.74,95.75 117.57,95.75 117.49,95.83 117.49,96.05 117.41,96.13 116.41,96.13 116.33,96.05 116.33,95.71 116.42,95.62 117.08,95.62 117.16,95.54 117.16,95.36 117.08,95.28 115.1,95.28 115.02,95.2 115.02,94.99 115.11,94.91 117.04,94.91 117.16,94.79 117.16,94.4 117.08,94.32 117,94.32 116.92,94.24 116.92,93.99 116.84,93.91 116.67,93.91 116.59,93.99 116.59,94.24 116.5,94.32 116.35,94.32 116.06,94.03 115.8,94.03 115.67,93.9 115.67,93.56 115.88,93.34 116.88,93.34 116.96,93.26 116.96,93.06 117.04,92.98 117.22,92.98 117.3,93.06 117.3,93.44 117.38,93.53 117.5,93.53 117.59,93.62 117.59,93.73 117.53,93.79 117.53,93.91 117.65,94.03 117.77,94.03 117.83,93.97 117.95,93.97 117.98,94 118.1,94 118.22,93.88 118.22,93.76 117.69,93.23 117.69,93.12 117.88,92.92 119.44,92.92 119.69,92.68 121.83,92.68 122.24,92.27 122.24,91.66 121.9,91.32 121.78,91.32 121.7,91.4 121.7,91.61 121.62,91.69 121.44,91.69 121.36,91.61 121.36,91.4 121.28,91.32 120.24,91.32 119.46,90.54 119.46,89.96 119.46,87.68 119.73,87.41 119.73,87.29 119.57,87.13 119.57,87.02 119.7,86.9 119.81,86.9 119.97,87.05 120.08,87.05 120.36,86.77 120.36,86.61 120.28,86.53 119.49,86.53 119.38,86.41 119.38,86.27 119.46,86.19 120.28,86.19 120.36,86.11 120.36,85.94 120.28,85.86 119.32,85.86 119.23,85.77 119.23,85.6 119.32,85.52 120.28,85.52 120.36,85.44 120.36,85.27 120.28,85.19 119.49,85.19 119.41,85.1 119.41,84.93 119.49,84.85 120.42,84.85 120.5,84.77 120.5,84.6 120.42,84.52 118.69,84.52 118.61,84.6 118.61,84.93 118.53,85.01 118.36,85.01 118.28,84.93 118.28,84.6 118.2,84.52 117.91,84.52 117.82,84.42 117.82,84.28 117.92,84.18 121.09,84.18 121.19,84.09 121.19,83.93 121.1,83.84 118.77,83.84 118.69,83.76 118.69,83.59 118.77,83.51 120.16,83.51 120.22,83.44 120.22,83.23 120.16,83.16 118.93,83.16 118.85,83.08 118.85,82.91 118.93,82.83 120.28,82.83 120.36,82.75 120.36,82.6 120.25,82.49 118.98,82.49 118.9,82.41 118.9,82.24 118.98,82.16 120.16,82.16 120.24,82.08 120.24,81.87 120.14,81.77 119.89,81.77 119.81,81.69 119.81,81.49 119.72,81.4 119.55,81.4 119.47,81.49 119.47,81.69 119.39,81.77 119.13,81.77 119.05,81.69 119.05,81.01 arc(119.07,80.87) 119.13,80.75 arc(119.17,80.53) 119.11,80.32 119.11,80.31 arc(119.05,80.09) 119.11,79.86 arc(119.17,79.63) 119.11,79.4 119.11,79.4 arc(119.05,79.17) 119.11,78.94 arc(119.17,78.71) 119.11,78.48 119.11,78.48 arc(119.05,78.25) 119.11,78.02 arc(119.17,77.79) 119.11,77.56 119.11,77.56 arc(119.05,77.33) 119.11,77.1 arc(119.17,76.88) 119.12,76.66 119.11,76.63 119.07,76.6 arc(118.99,76.41) 119.07,76.22 119.13,76.15 arc(119.21,75.97) 119.13,75.79 118.89,75.55 arc(118.67,75.46) 118.45,75.55 118.2,75.81 arc(118.04,75.91) 117.85,75.95 v1(117.12,75.95)
DDR4_DIMM2_ODT1: length 90
  L07_SIG3 w0.089: v1(114.12,99.34) 113.53,99.34 113.13,99.74 113,99.74 112.91,99.83 112.91,100.24 112.82,100.33 112.65,100.33 112.56,100.24 112.56,99.83 112.48,99.74 112.31,99.74 112.22,99.83 112.22,100.24 112.13,100.33 111.97,100.33 111.88,100.24 111.88,99.83 111.79,99.74 111.62,99.74 111.54,99.83 111.54,100.24 111.45,100.33 111.28,100.33 111.19,100.24 111.19,99.83 111.1,99.74 110.94,99.74 110.85,99.83 110.85,100.24 110.76,100.33 110.6,100.33 110.51,100.24 110.51,99.83 110.42,99.74 110.25,99.74 110.16,99.83 110.16,100.24 110.08,100.33 109.91,100.33 109.82,100.24 109.82,99.83 109.73,99.74 109.57,99.74 109.48,99.83 109.48,100.24 109.39,100.33 109.22,100.33 109.14,100.24 109.14,99.83 109.05,99.74 108.88,99.74 108.79,99.83 108.79,100.24 108.7,100.33 108.54,100.33 108.45,100.24 108.45,99.83 108.36,99.74 108.25,99.74 108.13,99.62 108.13,99.33 108.62,98.83 108.62,98.7 108.71,98.61 109.43,98.61 109.51,98.52 109.51,98.36 109.43,98.27 108.71,98.27 108.62,98.18 108.62,98.02 108.71,97.93 109.43,97.93 109.51,97.84 109.51,97.67 109.43,97.58 108.71,97.58 108.62,97.5 108.62,97.33 108.71,97.24 109.43,97.24 109.51,97.15 109.51,96.99 109.43,96.9 108.71,96.9 108.62,96.81 108.62,96.64 108.71,96.56 109.43,96.56 109.51,96.47 109.51,96.3 109.43,96.21 108.71,96.21 108.62,96.12 108.62,95.96 108.71,95.87 109.43,95.87 109.51,95.78 109.51,95.62 109.43,95.53 108.71,95.53 108.62,95.44 108.62,95.27 108.71,95.18 109.43,95.18 109.51,95.1 109.51,94.93 109.43,94.84 108.71,94.84 108.62,94.75 108.62,94.59 108.71,94.5 109.43,94.5 109.51,94.41 109.51,94.24 109.43,94.16 108.71,94.16 108.62,94.07 108.62,93.91 108.45,93.73 107.61,93.73 107.21,93.34 107.21,92.9 107.37,92.75 109.17,92.75 109.26,92.66 109.26,88.61 109.4,88.46 109.97,88.46 110.06,88.55 110.06,90.53 110.15,90.62 110.31,90.62 110.4,90.53 110.4,88.55 110.49,88.46 110.66,88.46 110.75,88.55 110.75,90.53 110.84,90.62 111,90.62 111.09,90.53 111.09,88.55 111.18,88.46 111.34,88.46 111.43,88.55 111.43,90.53 111.52,90.62 111.69,90.62 111.78,90.53 111.78,88.55 111.86,88.46 112.03,88.46 112.12,88.55 112.12,90.53 112.21,90.62 112.37,90.62 112.46,90.53 112.46,88.55 112.55,88.46 112.72,88.46 112.8,88.55 112.8,90.53 112.89,90.62 113.06,90.62 113.15,90.53 113.15,88.55 113.24,88.46 113.4,88.46 113.49,88.55 113.49,90.53 113.58,90.62 113.74,90.62 113.83,90.53 113.83,88.55 113.92,88.46 114.09,88.46 114.18,88.55 114.18,90.53 114.26,90.62 114.43,90.62 114.52,90.53 114.52,88.55 114.61,88.46 114.77,88.46 114.86,88.55 114.86,90.53 114.95,90.62 115.12,90.62 115.2,90.53 115.2,88.55 115.29,88.46 115.6,88.46 115.69,88.37 115.69,80.43 115.63,80.37 arc(115.63,80.37) 115.63,80.36 115.63,79.29 arc(115.66,79.13) 115.76,79 arc(115.9,78.73) 115.8,78.45 arc(115.71,78.23) 115.78,78.01 arc(115.84,77.92) 115.86,77.81 arc(115.88,77.73) 115.93,77.65 arc(115.98,77.56) 115.97,77.46 arc(115.98,77.17) 116.19,76.98 arc(116.27,76.92) 116.31,76.83 arc(116.32,76.74) 116.32,76.66 v1(116.32,76.41)
