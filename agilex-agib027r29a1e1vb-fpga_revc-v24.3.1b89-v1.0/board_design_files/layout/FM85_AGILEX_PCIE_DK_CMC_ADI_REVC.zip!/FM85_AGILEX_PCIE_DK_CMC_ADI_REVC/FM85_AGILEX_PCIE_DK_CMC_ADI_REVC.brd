# Allegro board FM85_AGILEX_PCIE_DK_CMC_ADI_REVC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_DDIMM2_DQ16: length 99.8
  L14_SIG5 w0.081: v1(173.69,99.34) 173.31,99.34 172.84,99.81 arc(172.83,99.81) 172.82,99.82 171.01,99.82 arc(171,99.81) 170.99,99.81 170.76,99.58 arc(170.75,99.57) 170.75,99.55 170.75,98.61 arc(170.75,98.6) 170.74,98.59 170.56,98.41 arc(170.55,98.41) 170.54,98.4 170.37,98.4 arc(170.36,98.4) 170.35,98.39 170.26,98.3 170.26,98.13 170.34,98.05 170.57,98.05 170.65,97.96 170.65,97.79 170.57,97.71 170.34,97.71 170.26,97.63 170.26,97.46 170.34,97.37 170.57,97.37 170.65,97.29 170.65,97.12 170.57,97.04 170.34,97.04 170.26,96.96 170.26,96.79 170.34,96.7 170.57,96.7 170.65,96.62 170.65,96.14 170.42,95.9 170.42,94.42 168.36,92.36 163.7,92.36 163.53,92.2 161.28,92.2 161.2,92.12 161.2,91.6 161.12,91.51 160.94,91.51 160.86,91.6 160.86,92.12 160.78,92.2 160.61,92.2 160.53,92.12 160.53,91.6 160.45,91.51 160.27,91.51 160.19,91.6 160.19,92.12 160.11,92.2 159.94,92.2 159.86,92.12 159.86,91.6 159.78,91.51 159.6,91.51 159.52,91.6 159.52,92.12 159.44,92.2 159.27,92.2 159.19,92.12 159.19,91.6 159.11,91.51 158.93,91.51 158.85,91.6 158.85,92.12 158.77,92.2 158.6,92.2 158.52,92.12 158.52,91.6 158.44,91.51 158.26,91.51 158.18,91.6 158.18,92.12 158.1,92.2 157.93,92.2 157.85,92.12 157.85,91.6 157.76,91.51 157.59,91.51 157.51,91.6 157.51,92.12 157.43,92.2 157.26,92.2 157.18,92.12 157.18,91.6 157.09,91.51 156.92,91.51 156.84,91.6 156.84,92.12 156.76,92.2 156.59,92.2 156.5,92.12 156.5,91.6 156.42,91.51 156.25,91.51 156.17,91.6 156.17,92.12 156.09,92.2 155.92,92.2 155.83,92.12 155.83,91.6 155.75,91.51 155.58,91.51 155.5,91.6 155.5,92.12 155.42,92.2 150.39,92.2 144.54,86.35 144.54,85.23 144.08,84.78 144.08,82.59 143.9,82.41 143.9,77.81 143.56,77.46 143.56,76.16 144.03,75.69 144.03,73.41 143.72,73.1 143.53,73.1 arc(143.28,73.03) 143.1,72.85 143.1,72.85 arc(142.92,72.67) 142.67,72.6 142.66,72.6 arc(142.41,72.53) 142.23,72.35 142.23,72.35 arc(142.05,72.17) 141.8,72.1 141.79,72.1 arc(141.54,72.03) 141.36,71.85 arc(141.18,71.67) 140.93,71.6 140.93,71.6 arc(140.68,71.67) 140.5,71.85 arc(140.32,72.03) 140.07,72.1 140.06,72.1 arc(139.81,72.03) 139.63,71.85 arc(139.45,71.67) 139.2,71.6 139.2,71.6 arc(138.95,71.67) 138.77,71.85 arc(138.59,72.03) 138.34,72.1 138.32,72.1 arc(138.08,72.03) 137.9,71.85 arc(137.72,71.67) 137.47,71.6 137.46,71.6 arc(137.22,71.67) 137.03,71.85 arc(136.85,72.03) 136.61,72.1 136.59,72.1 arc(136.35,72.03) 136.17,71.85 arc(135.99,71.67) 135.74,71.6 135.73,71.6 arc(135.48,71.67) 135.3,71.85 arc(135.12,72.03) 134.88,72.1 134.86,72.1 arc(134.62,72.03) 134.44,71.85 arc(134.25,71.67) 134.01,71.6 134,71.6 133.94,71.61 133.45,71.12 arc(133.29,70.95) 133.06,70.89 133.05,70.89 arc(132.82,70.95) 132.66,71.12 arc(132.49,71.29) 132.26,71.35 arc(132.03,71.29) 131.86,71.12 131.86,71.12 arc(131.69,70.95) 131.46,70.89 131.46,70.89 arc(131.23,70.95) 131.06,71.12 131.03,71.16 arc(130.87,71.31) 130.65,71.37 130.62,71.37 arc(130.39,71.3) 130.22,71.14 130.18,71.07 arc(130.05,70.94) 129.87,70.89 arc(129.64,70.95) 129.47,71.12 129.19,71.28 125.61,71.28 125.31,70.98 124.81,70.98 124.76,71.02 arc(124.72,71.07) 124.68,71.13 arc(124.51,71.29) 124.29,71.35 arc(124.06,71.29) 123.89,71.12 arc(123.73,70.95) 123.51,70.89 123.49,70.89 arc(123.26,70.95) 123.09,71.12 123.09,71.13 arc(122.92,71.29) 122.7,71.35 arc(122.47,71.29) 122.3,71.12 arc(122.14,70.95) 121.92,70.89 121.9,70.89 arc(121.67,70.95) 121.5,71.12 121.49,71.13 arc(121.33,71.29) 121.1,71.35 arc(120.87,71.29) 120.7,71.12 arc(120.54,70.95) 120.32,70.89 120.31,70.89 arc(120.08,70.95) 119.91,71.12 119.91,71.12 arc(119.51,71.35) 119.11,71.12 arc(118.94,70.95) 118.71,70.89 arc(118.48,70.95) 118.31,71.12 118.3,71.14 arc(118.14,71.29) 117.92,71.35 arc(117.69,71.29) 117.52,71.12 arc(117.36,70.96) 117.14,70.89 117.12,70.89 arc(116.89,70.95) 116.72,71.12 116.71,71.14 arc(116.54,71.29) 116.32,71.35 arc(116.09,71.29) 115.92,71.12 arc(115.76,70.96) 115.55,70.89 115.52,70.89 arc(115.29,70.95) 115.13,71.12 115.12,71.13 arc(114.95,71.29) 114.73,71.35 arc(114.5,71.41) 114.33,71.58 v1(113.93,72.27)
DDR4_DDIMM2_DQ17: length 99.8
  L14_SIG5 w0.081: v1(113.13,72.73) 113.41,72.73 113.95,72.73 arc(114.17,72.66) 114.33,72.5 arc(114.49,72.34) 114.71,72.27 114.73,72.27 arc(114.95,72.21) 115.12,72.06 115.14,72.02 arc(115.3,71.87) 115.52,71.81 115.54,71.81 arc(115.76,71.88) 115.92,72.04 arc(116.08,72.2) 116.3,72.27 116.32,72.27 arc(116.54,72.21) 116.71,72.06 116.73,72.02 arc(116.9,71.87) 117.12,71.81 117.14,71.81 arc(117.36,71.88) 117.52,72.04 arc(117.68,72.2) 117.9,72.27 117.92,72.27 arc(118.14,72.21) 118.3,72.06 118.32,72.02 arc(118.49,71.87) 118.71,71.81 118.73,71.81 arc(118.95,71.87) 119.11,72.04 arc(119.27,72.2) 119.49,72.27 119.51,72.27 arc(119.73,72.21) 119.9,72.05 119.92,72.02 arc(120.08,71.87) 120.31,71.81 120.32,71.81 arc(120.54,71.87) 120.7,72.04 arc(120.87,72.2) 121.09,72.27 121.1,72.27 arc(121.33,72.21) 121.49,72.05 121.51,72.03 arc(121.68,71.87) 121.9,71.81 121.91,71.81 arc(122.14,71.87) 122.3,72.04 arc(122.46,72.2) 122.68,72.27 122.7,72.27 arc(122.92,72.21) 123.09,72.05 123.1,72.03 arc(123.27,71.87) 123.49,71.81 123.51,71.81 arc(123.73,71.87) 123.89,72.04 arc(124.05,72.2) 124.28,72.27 124.29,72.27 arc(124.51,72.21) 124.68,72.05 124.69,72.03 arc(124.86,71.87) 125.09,71.81 126.8,71.81 127.13,72.14 127.48,72.27 arc(127.7,72.21) 127.87,72.05 127.88,72.04 arc(127.91,71.99) 127.95,71.94 128.08,71.81 128.3,71.81 128.67,72.04 arc(128.84,72.21) 129.06,72.27 129.07,72.27 arc(129.3,72.21) 129.47,72.05 129.47,72.03 arc(129.64,71.87) 129.87,71.81 129.87,71.81 arc(130.1,71.87) 130.27,72.04 arc(130.43,72.21) 130.66,72.27 130.66,72.27 arc(130.89,72.21) 131.06,72.04 131.07,72.04 arc(131.46,71.81) 131.86,72.04 131.86,72.04 arc(132.03,72.21) 132.26,72.27 132.26,72.27 arc(132.49,72.21) 132.66,72.04 arc(132.82,71.87) 133.05,71.81 133.15,71.81 133.87,72.52 134,72.6 134.01,72.6 arc(134.26,72.67) 134.44,72.85 arc(134.62,73.03) 134.87,73.1 134.87,73.1 arc(135.12,73.03) 135.3,72.85 arc(135.48,72.67) 135.73,72.6 135.74,72.6 arc(135.99,72.67) 136.17,72.85 arc(136.6,73.1) 137.03,72.85 137.03,72.85 arc(137.21,72.67) 137.46,72.6 137.47,72.6 arc(137.72,72.67) 137.9,72.85 arc(138.08,73.03) 138.33,73.1 138.33,73.1 arc(138.58,73.03) 138.76,72.85 138.77,72.85 arc(138.95,72.67) 139.2,72.6 139.21,72.6 arc(139.45,72.67) 139.63,72.85 arc(139.81,73.03) 140.06,73.1 arc(140.31,73.03) 140.5,72.85 140.5,72.85 arc(140.68,72.67) 140.92,72.6 140.94,72.6 arc(141.18,72.67) 141.36,72.85 arc(141.55,73.03) 141.79,73.1 141.8,73.1 arc(142.04,73.16) 142.23,73.34 142.23,73.35 arc(142.41,73.53) 142.66,73.6 arc(142.91,73.67) 143.09,73.85 143.1,73.85 arc(143.16,74.1) 143.1,74.35 arc(143.03,74.6) 143.09,74.84 143.1,74.85 arc(143.16,75.1) 143.1,75.35 arc(143.04,75.51) 143.04,75.69 143.18,75.99 arc(143.17,76.16) 143.1,76.31 arc(143.03,76.46) 143.01,76.63 143.1,76.81 143.01,77.56 arc(143.08,77.79) 143.01,78.02 arc(142.95,78.25) 143.01,78.48 143.02,78.48 arc(143.08,78.71) 143.01,78.94 arc(142.95,79.17) 143.01,79.4 143.02,79.4 arc(143.08,79.63) 143.01,79.86 arc(142.95,80.09) 143.01,80.31 143.01,80.32 arc(143.08,80.55) 143.02,80.77 143.01,80.79 arc(142.95,81.01) 143.01,81.24 arc(143.04,81.3) 143.06,81.36 arc(143.07,81.53) 143.01,81.7 143.01,82.18 143.62,82.78 143.62,84.97 144.08,85.43 144.08,86.54 150.2,92.66 159.78,92.66 159.86,92.74 159.86,93.2 159.95,93.28 160.12,93.28 160.2,93.2 160.2,92.74 160.28,92.66 160.45,92.66 160.53,92.74 160.53,93.2 160.62,93.28 160.79,93.28 160.87,93.2 160.87,92.74 160.95,92.66 161.12,92.66 161.21,92.74 161.21,93.2 161.29,93.28 161.46,93.28 161.54,93.2 161.54,92.74 161.62,92.66 161.79,92.66 161.88,92.74 161.88,93.2 161.96,93.28 162.13,93.28 162.21,93.2 162.21,92.74 162.29,92.66 162.87,92.66 163.18,92.97 167.18,92.97 167.89,93.67 167.9,93.67 168.11,93.89 168.11,93.9 169.32,95.11 169.32,100.12 169.77,100.56 172.06,100.56 172.14,100.64 arc(172.15,100.65) 172.17,100.65 173.27,100.65 arc(173.28,100.65) 173.29,100.64 174.23,99.7 arc(174.24,99.69) 174.24,99.68 174.24,98.6 arc(174.24,98.59) 174.23,98.58 174.13,98.47 174.13,95.12 172.84,93.84 v1(172.84,93.34)
DDR4_DDIMM2_DQ18: length 98.7
  L14_SIG5 w0.081: v1(167.74,99.34) 167.74,97.14 167.01,96.41 159.04,96.41 158.96,96.49 158.96,97.46 158.88,97.54 158.71,97.54 158.63,97.46 158.63,96.49 158.55,96.41 158.37,96.41 158.29,96.49 158.29,97.46 158.21,97.54 158.04,97.54 157.96,97.46 157.96,96.49 157.88,96.41 157.7,96.41 157.62,96.49 157.62,97.46 157.54,97.54 157.37,97.54 157.29,97.46 157.29,96.49 157.2,96.41 157.03,96.41 156.95,96.49 156.95,97.46 156.87,97.54 156.7,97.54 156.62,97.46 156.62,96.49 156.53,96.41 156.36,96.41 156.28,96.49 156.28,97.46 156.2,97.54 156.03,97.54 155.94,97.46 155.94,96.49 155.86,96.41 155.69,96.41 155.61,96.49 155.61,97.46 155.53,97.54 155.36,97.54 155.27,97.46 155.27,96.49 155.19,96.41 155.02,96.41 154.94,96.49 154.94,97.46 154.86,97.54 154.68,97.54 154.6,97.46 154.6,96.49 154.52,96.41 154.35,96.41 154.27,96.49 154.27,97.46 154.19,97.54 154.01,97.54 153.93,97.46 153.93,96.49 153.85,96.41 152.63,96.41 152,95.78 151.89,95.78 151.37,96.29 151.25,96.29 151.13,96.17 151.13,96.06 151.65,95.54 151.65,95.43 151.53,95.3 151.41,95.3 150.89,95.82 150.78,95.82 150.66,95.7 150.66,95.58 151.17,95.07 151.17,94.95 151.05,94.83 150.94,94.83 150.42,95.35 150.31,95.35 150.18,95.22 150.18,95.11 150.7,94.59 150.7,94.48 150.58,94.36 150.46,94.36 149.95,94.87 149.83,94.87 149.71,94.75 149.71,94.63 150.23,94.12 150.23,94 143.15,86.93 143.15,85.81 142.69,85.35 142.69,83.54 141.71,82.55 141.71,81.74 141.41,81.23 arc(141.36,81) 141.42,80.78 arc(141.48,80.55) 141.43,80.33 141.42,80.32 arc(141.36,80.09) 141.42,79.86 arc(141.48,79.63) 141.42,79.4 141.42,79.39 arc(141.36,79.17) 141.42,78.94 arc(141.48,78.71) 141.42,78.48 141.42,78.48 arc(141.36,78.25) 141.42,78.02 arc(141.48,77.79) 141.42,77.56 141.42,77.56 arc(141.36,77.33) 141.42,77.1 141.36,75.85 arc(141.18,75.67) 140.94,75.6 140.92,75.6 arc(140.68,75.53) 140.5,75.35 arc(140.32,75.17) 140.07,75.1 140.06,75.1 arc(139.81,75.03) 139.63,74.85 arc(139.45,74.67) 139.2,74.6 139.2,74.6 arc(138.95,74.67) 138.77,74.85 138.77,74.85 arc(138.58,75.03) 138.34,75.1 138.33,75.1 arc(138.08,75.03) 137.9,74.85 137.9,74.85 arc(137.47,74.6) 137.04,74.85 137.03,74.85 arc(136.85,75.03) 136.61,75.1 136.6,75.1 arc(136.35,75.03) 136.17,74.85 136.17,74.85 arc(135.98,74.67) 135.73,74.6 arc(135.48,74.67) 135.3,74.85 arc(135.12,75.03) 134.87,75.1 134.87,75.1 134.47,74.96 134.09,74.57 133.05,74.57 arc(132.82,74.51) 132.66,74.34 arc(132.49,74.17) 132.27,74.11 132.25,74.11 arc(132.03,74.05) 131.86,73.88 131.86,73.87 arc(131.46,73.65) 131.07,73.87 131.06,73.88 arc(130.9,74.05) 130.67,74.11 130.66,74.11 arc(130.43,74.05) 130.27,73.88 130.26,73.88 arc(130.1,73.71) 129.87,73.65 arc(129.64,73.71) 129.47,73.87 129.47,73.88 arc(129.3,74.05) 129.08,74.11 129.06,74.11 arc(128.84,74.05) 128.67,73.88 128.67,73.88 arc(128.5,73.71) 128.27,73.65 arc(128.05,73.71) 127.88,73.87 127.88,73.88 arc(127.71,74.05) 127.48,74.11 127.47,74.11 arc(127.24,74.05) 127.08,73.88 127.08,73.88 arc(126.91,73.71) 126.68,73.65 arc(126.45,73.71) 126.29,73.87 126.28,73.88 arc(126.12,74.05) 125.89,74.11 125.88,74.11 arc(125.65,74.05) 125.48,73.88 125.48,73.88 arc(125.32,73.71) 125.09,73.65 arc(124.86,73.71) 124.69,73.87 124.69,73.88 arc(124.52,74.05) 124.29,74.11 124.28,74.11 arc(124.06,74.05) 123.89,73.88 123.89,73.88 arc(123.72,73.71) 123.49,73.65 arc(123.27,73.71) 123.1,73.87 123.09,73.88 arc(122.93,74.05) 122.7,74.11 122.69,74.11 arc(122.46,74.05) 122.3,73.88 122.3,73.88 arc(122.13,73.71) 121.9,73.65 arc(121.67,73.71) 121.5,73.87 121.5,73.88 arc(121.33,74.05) 121.11,74.11 121.09,74.11 arc(120.87,74.05) 120.7,73.88 120.7,73.88 arc(120.53,73.71) 120.31,73.65 arc(120.08,73.71) 119.91,73.87 119.91,73.88 arc(119.74,74.05) 119.51,74.11 119.5,74.11 arc(119.28,74.05) 119.11,73.88 119.11,73.88 arc(118.94,73.71) 118.71,73.65 arc(118.48,73.71) 118.32,73.87 118.31,73.88 arc(118.15,74.05) 117.92,74.11 117.91,74.11 arc(117.68,74.05) 117.52,73.88 117.52,73.88 arc(117.35,73.71) 117.12,73.65 arc(116.89,73.71) 116.72,73.87 116.72,73.88 arc(116.55,74.05) 116.33,74.11 116.31,74.11 arc(116.09,74.05) 115.92,73.88 115.92,73.88 arc(115.75,73.71) 115.52,73.65 arc(115.3,73.71) 115.13,73.87 115.13,73.88 arc(114.96,74.05) 114.73,74.11 114.73,74.11 v1(113.93,74.11)
DDR4_DDIMM2_DQ19: length 99.7
  L14_SIG5 w0.081: v1(166.89,93.34) 166.32,93.92 166.32,94.02 arc(166.32,94.03) 166.33,94.04 166.94,94.66 arc(166.95,94.67) 166.95,94.68 166.95,94.77 arc(166.95,94.78) 166.94,94.79 166.84,94.9 arc(166.83,94.9) 166.82,94.91 166.73,94.91 arc(166.72,94.9) 166.71,94.9 166.09,94.28 arc(166.08,94.27) 166.07,94.27 165.97,94.27 165.84,94.39 165.84,94.51 166.54,95.21 166.54,95.32 166.42,95.45 166.31,95.45 165.61,94.75 165.49,94.75 165.37,94.87 165.37,94.98 166.07,95.68 166.07,95.8 165.95,95.92 165.83,95.92 165.13,95.22 165.02,95.22 164.58,95.66 164.38,95.66 164.3,95.58 164.3,94.48 164.21,94.4 164.04,94.4 163.96,94.48 163.96,95.58 163.88,95.66 163.71,95.66 163.62,95.58 163.62,94.48 163.54,94.4 163.37,94.4 163.29,94.48 163.29,95.58 163.21,95.66 162.67,95.66 162.32,95.31 160.37,95.31 160.29,95.23 160.29,94.39 160.21,94.31 160.04,94.31 159.96,94.39 159.96,95.23 159.88,95.31 159.7,95.31 159.62,95.23 159.62,94.39 159.54,94.31 159.37,94.31 159.29,94.39 159.29,95.23 159.21,95.31 159.03,95.31 158.95,95.23 158.95,94.39 158.87,94.31 158.7,94.31 158.62,94.39 158.62,95.23 158.53,95.31 158.36,95.31 158.28,95.23 158.28,94.39 158.2,94.31 158.03,94.31 157.95,94.39 157.95,95.23 157.86,95.31 156.82,95.31 156.73,95.23 156.73,94.18 156.65,94.1 156.48,94.1 156.4,94.18 156.4,95.23 156.32,95.31 155.21,95.31 154.93,95.03 154.93,94.91 155.42,94.41 155.42,94.3 155.3,94.18 155.19,94.18 154.69,94.67 154.57,94.67 154.45,94.55 154.45,94.44 154.95,93.94 154.95,93.82 154.83,93.7 154.71,93.7 154.21,94.2 154.1,94.2 153.02,93.12 151.99,93.12 151.9,93.21 151.9,93.35 151.82,93.43 151.65,93.43 151.57,93.35 151.57,93.21 151.49,93.12 151.32,93.12 151.23,93.21 151.23,93.35 151.15,93.43 150.98,93.43 150.9,93.35 150.9,93.21 150.82,93.12 150.01,93.12 143.62,86.73 143.62,85.62 143.16,85.16 143.16,83.16 142.32,82.32 142.32,80.85 142.16,80.68 142.16,79.63 arc(142.17,79.51) 142.22,79.4 142.22,79.4 arc(142.28,79.17) 142.22,78.94 arc(142.16,78.71) 142.22,78.48 142.22,78.48 arc(142.28,78.25) 142.22,78.02 arc(142.16,77.79) 142.22,77.56 142.23,77.19 arc(142.17,77.03) 142.17,76.85 142.29,76.61 arc(142.29,76.43) 142.23,76.27 arc(142.17,76.11) 142.17,75.93 142.25,75.78 arc(142.29,75.56) 142.23,75.35 arc(142.05,75.17) 141.8,75.1 141.79,75.1 arc(141.54,75.03) 141.36,74.85 141.36,74.85 arc(141.18,74.67) 140.93,74.6 140.93,74.6 arc(140.68,74.53) 140.5,74.35 140.49,74.34 arc(140.31,74.16) 140.06,74.1 arc(139.82,74.03) 139.64,73.86 139.63,73.85 arc(139.45,73.67) 139.2,73.6 139.2,73.6 arc(138.95,73.67) 138.77,73.85 138.76,73.86 arc(138.58,74.03) 138.33,74.1 arc(138.08,74.03) 137.9,73.85 137.9,73.85 arc(137.72,73.67) 137.47,73.6 137.46,73.6 arc(137.22,73.67) 137.03,73.85 137.03,73.86 arc(136.6,74.1) 136.17,73.86 136.17,73.85 arc(135.99,73.67) 135.74,73.6 135.73,73.6 arc(135.48,73.67) 135.3,73.85 135.3,73.85 arc(135.12,74.03) 134.87,74.1 arc(134.62,74.03) 134.44,73.86 134.44,73.85 arc(134.25,73.67) 134.01,73.6 134,73.6 133.76,73.51 133.48,73.23 133.48,72.9 133.31,72.73 133.05,72.73 arc(132.82,72.79) 132.66,72.96 arc(132.49,73.13) 132.26,73.19 132.26,73.19 arc(132.03,73.13) 131.86,72.96 131.86,72.96 arc(131.46,72.73) 131.07,72.96 131.06,72.96 arc(130.89,73.13) 130.66,73.19 130.66,73.19 arc(130.43,73.13) 130.27,72.96 arc(130.1,72.79) 129.87,72.73 129.87,72.73 arc(129.64,72.79) 129.47,72.95 129.47,72.97 arc(129.3,73.13) 129.07,73.19 129.06,73.19 arc(128.84,73.13) 128.67,72.96 arc(128.51,72.79) 128.28,72.73 128.27,72.73 arc(128.05,72.79) 127.88,72.95 127.87,72.97 arc(127.7,73.13) 127.48,73.19 127.47,73.19 arc(127.24,73.12) 127.08,72.96 arc(126.91,72.79) 126.69,72.73 126.68,72.73 arc(126.46,72.79) 126.29,72.95 126.28,72.97 arc(126.11,73.13) 125.88,73.19 125.87,73.19 arc(125.65,73.12) 125.49,72.96 arc(125.32,72.79) 125.1,72.73 125.09,72.73 arc(124.86,72.79) 124.69,72.95 124.68,72.97 arc(124.51,73.13) 124.29,73.19 124.28,73.19 arc(124.05,73.12) 123.89,72.96 arc(123.73,72.79) 123.51,72.73 123.49,72.73 arc(123.27,72.79) 123.1,72.95 123.09,72.97 arc(122.92,73.13) 122.7,73.19 122.68,73.19 arc(122.46,73.12) 122.3,72.96 arc(122.14,72.79) 121.91,72.73 121.9,72.73 arc(121.68,72.79) 121.51,72.95 121.49,72.97 arc(121.33,73.13) 121.1,73.19 121.09,73.19 arc(120.87,73.12) 120.7,72.96 arc(120.54,72.79) 120.32,72.73 120.31,72.73 arc(120.08,72.79) 119.92,72.94 119.9,72.97 arc(119.73,73.13) 119.51,73.19 119.49,73.19 arc(119.27,73.12) 119.11,72.96 arc(118.95,72.79) 118.73,72.73 118.71,72.73 arc(118.49,72.79) 118.32,72.94 118.3,72.98 arc(118.14,73.13) 117.92,73.19 117.9,73.19 arc(117.68,73.12) 117.52,72.96 arc(117.36,72.8) 117.14,72.73 117.12,72.73 arc(116.9,72.79) 116.73,72.94 116.71,72.98 arc(116.54,73.13) 116.32,73.19 116.3,73.19 arc(116.08,73.12) 115.92,72.96 arc(115.76,72.8) 115.54,72.73 115.52,72.73 arc(115.3,72.79) 115.14,72.94 115.12,72.98 arc(114.95,73.13) 114.73,73.19 114.72,73.19 arc(114.5,73.25) 114.33,73.42 arc(114.16,73.59) 113.94,73.65 113.34,73.65 v1(113.13,73.65)
DDR4_DDIMM2_DQ20: length 97.6
  L14_SIG5 w0.081: v1(175.39,97.95) 175.39,97.29 175.49,97.19 175.49,94.98 174.2,93.69 arc(174.09,93.53) 174.06,93.34 arc(174.07,93.25) 174.09,93.16 174.1,93.13 arc(174.11,93.07) 174.12,93.01 174.12,91.89 173.75,91.53 arc(173.72,91.48) 173.68,91.44 arc(173.64,91.36) 173.61,91.28 arc(173.61,91.25) 173.61,91.23 arc(173.57,91.06) 173.47,90.92 171.77,89.22 169.98,89.22 167.72,86.96 arc(167.71,86.95) 167.7,86.95 167.24,86.95 arc(167.19,86.95) 167.13,86.93 arc(167.02,86.92) 166.91,86.93 arc(166.86,86.95) 166.8,86.95 165.76,86.95 arc(165.74,86.95) 165.73,86.94 160.45,81.66 160.45,81.54 160.71,81.28 160.71,81.17 160.59,81.05 160.48,81.05 160.22,81.31 160.1,81.31 159.98,81.19 159.98,81.07 160.24,80.81 160.24,80.69 160.12,80.57 160,80.57 159.74,80.83 159.63,80.83 159.5,80.71 159.5,80.6 159.77,80.33 159.77,80.22 159.64,80.1 159.53,80.1 159.27,80.36 159.15,80.36 156.07,77.27 150.27,77.27 147.3,74.3 147.3,70.61 146.04,69.35 146.04,67.77 145.37,67.1 143.53,67.1 arc(143.28,67.03) 143.1,66.85 143.1,66.85 arc(142.91,66.67) 142.67,66.6 142.66,66.6 arc(142.41,66.67) 142.23,66.85 arc(142.05,67.03) 141.8,67.1 141.79,67.1 arc(141.54,67.03) 141.36,66.85 arc(141.18,66.67) 140.93,66.6 140.93,66.6 arc(140.68,66.67) 140.5,66.85 arc(140.32,67.03) 140.07,67.1 140.06,67.1 arc(139.81,67.03) 139.63,66.85 arc(139.45,66.67) 139.2,66.6 139.2,66.6 arc(138.95,66.67) 138.77,66.85 arc(138.59,67.03) 138.34,67.1 138.32,67.1 arc(138.08,67.03) 137.9,66.85 arc(137.72,66.67) 137.47,66.6 137.46,66.6 arc(137.22,66.67) 137.03,66.85 arc(136.85,67.03) 136.61,67.1 136.59,67.1 arc(136.35,67.03) 136.17,66.85 arc(135.99,66.67) 135.74,66.6 135.73,66.6 arc(135.48,66.67) 135.3,66.85 arc(135.12,67.03) 134.88,67.1 134.86,67.1 arc(134.62,67.03) 134.44,66.85 arc(134.25,66.67) 134.01,66.6 133.63,66.6 133.32,66.29 133.05,66.29 arc(132.82,66.35) 132.66,66.52 arc(132.49,66.69) 132.26,66.75 arc(132.03,66.69) 131.86,66.52 arc(131.69,66.35) 131.47,66.29 131.45,66.29 arc(131.23,66.35) 131.06,66.52 131.06,66.52 arc(130.89,66.69) 130.66,66.75 arc(130.43,66.69) 130.27,66.52 arc(130.1,66.35) 129.88,66.29 129.86,66.29 arc(129.64,66.35) 129.47,66.52 129.47,66.53 arc(129.3,66.69) 129.07,66.75 arc(128.84,66.69) 128.67,66.52 arc(128.51,66.35) 128.29,66.29 128.27,66.29 arc(128.05,66.35) 127.88,66.51 127.87,66.53 arc(127.7,66.69) 127.48,66.75 arc(127.25,66.69) 127.08,66.52 arc(126.92,66.35) 126.69,66.29 126.68,66.29 arc(126.45,66.35) 126.29,66.51 126.28,66.52 arc(126.11,66.69) 125.88,66.75 125.87,66.75 arc(125.65,66.68) 125.49,66.52 arc(125.32,66.35) 125.1,66.29 125.09,66.29 arc(124.86,66.35) 124.69,66.51 124.68,66.53 arc(124.51,66.69) 124.29,66.75 arc(124.06,66.69) 123.89,66.52 arc(123.73,66.35) 123.51,66.29 123.49,66.29 arc(123.27,66.35) 123.1,66.51 123.09,66.53 arc(122.92,66.69) 122.7,66.75 arc(122.47,66.69) 122.3,66.52 arc(122.14,66.35) 121.92,66.29 121.9,66.29 arc(121.67,66.35) 121.51,66.51 121.49,66.53 arc(121.33,66.69) 121.1,66.75 arc(120.87,66.69) 120.7,66.52 arc(120.54,66.35) 120.32,66.29 120.31,66.29 arc(120.08,66.35) 119.91,66.52 119.9,66.53 arc(119.73,66.69) 119.51,66.75 119.51,66.75 arc(119.28,66.69) 119.11,66.52 arc(118.95,66.35) 118.73,66.29 118.71,66.29 arc(118.49,66.35) 118.32,66.5 118.3,66.53 arc(118.14,66.69) 117.92,66.75 117.91,66.75 arc(117.69,66.69) 117.52,66.52 arc(117.36,66.36) 117.14,66.29 117.12,66.29 arc(116.9,66.35) 116.73,66.5 116.71,66.54 arc(116.54,66.69) 116.32,66.75 arc(116.09,66.69) 115.92,66.52 arc(115.76,66.36) 115.55,66.29 115.52,66.29 arc(115.3,66.35) 115.14,66.5 115.12,66.54 arc(114.95,66.69) 114.73,66.75 arc(114.5,66.81) 114.33,66.98 arc(114.17,67.14) 113.95,67.21 113.93,67.21 arc(113.71,67.26) 113.54,67.42 113.52,67.46 arc(113.36,67.61) 113.13,67.67 113.11,67.67 arc(112.9,67.74) 112.74,67.9 arc(112.58,68.06) 112.36,68.13 112.34,68.13 arc(112.12,68.18) 111.95,68.34 111.93,68.38 arc(111.76,68.53) 111.54,68.59 111.52,68.59 arc(111.3,68.66) 111.14,68.82 arc(110.98,68.98) 110.77,69.05 110.74,69.05 arc(110.52,69.1) 110.36,69.26 110.33,69.3 arc(110.17,69.45) 109.95,69.51 109.92,69.51 arc(109.71,69.58) 109.55,69.74 109.55,69.74 arc(109.49,69.97) 109.55,70.2 arc(109.61,70.43) 109.55,70.65 109.55,70.66 arc(109.49,70.89) 109.55,71.12 109.55,71.12 arc(109.61,71.35) 109.55,71.58 arc(109.49,71.81) 109.55,72.03 v1(109.95,72.73)
DDR4_DDIMM2_DQ21: length 99
  L14_SIG5 w0.081: v1(174.54,93.34) 174.54,93.34 174.58,93.25 174.69,92.98 174.69,91.7 174.07,91.08 174.07,90.38 172.45,88.75 170.17,88.75 167.73,86.31 167.13,86.31 164.42,83.6 164.3,83.6 164.05,83.86 163.93,83.86 163.81,83.74 163.81,83.62 164.07,83.37 164.07,83.25 163.95,83.13 163.83,83.13 163.57,83.38 163.46,83.38 163.34,83.26 163.34,83.15 163.59,82.89 163.59,82.78 163.47,82.65 163.36,82.65 163.1,82.91 162.99,82.91 162.86,82.79 162.86,82.67 163.12,82.42 163.12,82.3 163,82.18 162.88,82.18 162.63,82.44 162.51,82.44 162.39,82.31 162.39,82.2 162.64,81.94 162.64,81.83 162.52,81.71 162.41,81.71 162.15,81.96 162.04,81.96 161.91,81.84 161.91,81.72 162.17,81.47 162.17,81.35 156.59,75.78 149.43,75.78 147.76,74.1 147.76,67.57 146.29,66.09 143.59,66.09 143.53,66.1 arc(143.28,66.03) 143.1,65.85 143.1,65.85 arc(142.91,65.67) 142.67,65.6 142.66,65.6 arc(142.41,65.67) 142.23,65.85 142.23,65.85 arc(142.05,66.03) 141.8,66.1 141.79,66.1 arc(141.55,66.03) 141.36,65.85 arc(141.18,65.67) 140.93,65.6 140.93,65.6 arc(140.68,65.67) 140.5,65.85 140.5,65.85 arc(140.06,66.1) 139.63,65.85 139.63,65.85 arc(139.45,65.67) 139.2,65.6 139.2,65.6 arc(138.95,65.67) 138.77,65.85 138.76,65.85 arc(138.58,66.03) 138.33,66.1 138.33,66.1 arc(138.08,66.03) 137.9,65.85 arc(137.72,65.67) 137.47,65.6 137.46,65.6 arc(137.22,65.67) 137.03,65.85 137.03,65.85 arc(136.6,66.1) 136.17,65.85 136.17,65.85 arc(135.99,65.67) 135.74,65.6 135.73,65.6 arc(135.48,65.67) 135.3,65.85 arc(135.12,66.03) 134.87,66.1 arc(134.62,66.03) 134.44,65.85 134.44,65.85 arc(134.25,65.67) 134.01,65.6 133.62,65.6 133.4,65.37 133.05,65.37 arc(132.82,65.43) 132.66,65.6 arc(132.49,65.76) 132.27,65.83 132.25,65.83 arc(132.02,65.76) 131.86,65.6 131.86,65.59 arc(131.46,65.37) 131.07,65.59 131.06,65.6 arc(130.9,65.76) 130.67,65.83 130.65,65.83 arc(130.43,65.76) 130.27,65.6 arc(130.1,65.43) 129.87,65.37 129.87,65.37 arc(129.64,65.43) 129.47,65.59 129.47,65.6 arc(129.3,65.77) 129.08,65.83 129.06,65.83 arc(128.84,65.76) 128.67,65.6 arc(128.51,65.43) 128.28,65.37 128.27,65.37 arc(128.05,65.43) 127.88,65.59 127.87,65.6 arc(127.71,65.77) 127.48,65.83 127.46,65.83 arc(127.24,65.76) 127.08,65.6 arc(126.91,65.43) 126.69,65.37 126.68,65.37 arc(126.46,65.43) 126.29,65.59 126.28,65.6 arc(126.11,65.77) 125.88,65.83 125.87,65.83 arc(125.65,65.76) 125.49,65.6 arc(125.32,65.43) 125.1,65.37 125.09,65.37 arc(124.86,65.43) 124.69,65.59 124.68,65.61 arc(124.52,65.77) 124.29,65.83 124.27,65.83 arc(124.05,65.76) 123.89,65.6 arc(123.73,65.43) 123.51,65.37 123.49,65.37 arc(123.27,65.43) 123.1,65.59 123.09,65.61 arc(122.92,65.77) 122.7,65.83 122.68,65.83 arc(122.46,65.76) 122.3,65.6 arc(122.14,65.43) 121.91,65.37 121.9,65.37 arc(121.68,65.43) 121.51,65.59 121.5,65.61 arc(121.33,65.77) 121.1,65.83 121.1,65.83 arc(120.87,65.77) 120.7,65.6 120.7,65.59 arc(120.53,65.43) 120.31,65.37 120.3,65.37 arc(120.07,65.43) 119.91,65.6 arc(119.74,65.76) 119.52,65.83 119.5,65.83 arc(119.28,65.76) 119.11,65.6 119.11,65.59 arc(118.71,65.37) 118.32,65.59 118.31,65.6 arc(118.15,65.76) 117.92,65.83 117.9,65.83 arc(117.68,65.76) 117.52,65.6 arc(117.35,65.43) 117.12,65.37 117.12,65.37 arc(116.89,65.43) 116.72,65.59 116.72,65.6 arc(116.55,65.77) 116.33,65.83 116.31,65.83 arc(116.09,65.76) 115.92,65.6 arc(115.76,65.43) 115.53,65.37 115.52,65.37 arc(115.3,65.43) 115.13,65.59 115.13,65.6 arc(114.96,65.77) 114.73,65.83 114.71,65.83 arc(114.49,65.89) 114.33,66.06 arc(114.17,66.22) 113.94,66.29 113.93,66.29 arc(113.71,66.35) 113.54,66.5 113.52,66.54 arc(113.36,66.69) 113.13,66.75 113.11,66.75 arc(112.9,66.82) 112.74,66.98 arc(112.58,67.14) 112.36,67.21 112.34,67.21 arc(112.12,67.26) 111.95,67.42 111.93,67.46 arc(111.76,67.61) 111.54,67.67 111.52,67.67 arc(111.3,67.74) 111.14,67.9 arc(110.98,68.06) 110.77,68.13 110.74,68.13 arc(110.52,68.18) 110.36,68.34 110.33,68.38 arc(110.17,68.53) 109.95,68.59 109.93,68.59 arc(109.71,68.66) 109.55,68.82 arc(109.39,68.98) 109.17,69.05 109.15,69.05 arc(108.92,69.11) 108.75,69.28 arc(108.69,69.51) 108.75,69.73 108.75,69.74 arc(108.81,69.97) 108.75,70.2 arc(108.69,70.43) 108.75,70.65 108.75,70.66 arc(108.81,70.89) 108.75,71.12 arc(108.69,71.35) 108.75,71.58 arc(108.81,71.81) 108.75,72.03 108.75,72.04 108.75,72.5 arc(108.91,72.66) 109.13,72.73 109.17,72.73 arc(109.39,72.8) 109.55,72.96 v1(109.95,73.65)
DDR4_DDIMM2_DQ22: length 99
  TOP w0.149: v1(174.88,97.15) 169.83,97.15 169.44,97.54 J1.32
  L14_SIG5 w0.081: v1(110.74,74.11) 110.34,73.42 arc(110.28,73.2) 110.33,72.98 110.35,72.95 arc(110.41,72.73) 110.35,72.5 arc(110.28,72.27) 110.34,72.04 110.35,72.03 arc(110.41,71.81) 110.35,71.58 arc(110.28,71.35) 110.35,71.12 arc(110.41,70.89) 110.35,70.66 110.34,70.65 arc(110.28,70.43) 110.35,70.2 arc(110.51,70.03) 110.74,69.97 110.77,69.97 arc(110.98,69.9) 111.14,69.74 arc(111.3,69.58) 111.52,69.51 111.54,69.51 arc(111.76,69.45) 111.93,69.3 111.95,69.26 arc(112.12,69.1) 112.34,69.05 arc(112.56,68.99) 112.72,68.83 arc(112.9,68.64) 113.15,68.58 arc(113.37,68.52) 113.53,68.36 113.54,68.34 arc(113.71,68.19) 113.93,68.13 113.95,68.13 arc(114.17,68.06) 114.33,67.9 arc(114.49,67.74) 114.71,67.67 114.73,67.67 arc(114.95,67.61) 115.12,67.46 115.13,67.44 arc(115.29,67.27) 115.52,67.21 115.54,67.21 arc(115.76,67.28) 115.92,67.44 arc(116.08,67.6) 116.3,67.67 116.32,67.67 arc(116.55,67.61) 116.72,67.44 116.72,67.44 arc(116.89,67.27) 117.12,67.21 117.14,67.21 arc(117.36,67.27) 117.52,67.44 arc(117.68,67.6) 117.9,67.67 117.92,67.67 arc(118.14,67.61) 118.3,67.45 118.31,67.44 arc(118.48,67.27) 118.71,67.21 118.73,67.21 arc(118.95,67.27) 119.11,67.44 arc(119.27,67.6) 119.49,67.67 119.51,67.67 arc(119.73,67.61) 119.9,67.45 119.91,67.44 arc(120.08,67.27) 120.31,67.21 120.32,67.21 arc(120.54,67.27) 120.7,67.44 arc(120.87,67.6) 121.09,67.67 121.1,67.67 arc(121.33,67.61) 121.49,67.45 121.5,67.44 arc(121.67,67.27) 121.9,67.21 121.91,67.21 arc(122.14,67.27) 122.3,67.44 arc(122.46,67.6) 122.68,67.67 122.7,67.67 arc(122.92,67.61) 123.09,67.45 123.09,67.44 arc(123.26,67.27) 123.49,67.21 123.51,67.21 arc(123.73,67.27) 123.89,67.44 arc(124.05,67.6) 124.28,67.67 124.29,67.67 arc(124.51,67.61) 124.68,67.45 124.69,67.43 arc(124.86,67.27) 125.09,67.21 arc(125.32,67.27) 125.49,67.44 arc(125.65,67.6) 125.87,67.67 125.88,67.67 arc(126.11,67.61) 126.28,67.45 126.29,67.43 arc(126.45,67.27) 126.68,67.21 arc(126.91,67.27) 127.08,67.44 arc(127.24,67.6) 127.47,67.67 127.48,67.67 arc(127.7,67.61) 127.87,67.45 127.88,67.43 arc(128.05,67.27) 128.27,67.21 arc(128.5,67.27) 128.67,67.44 arc(128.84,67.6) 129.06,67.67 129.07,67.67 arc(129.3,67.61) 129.47,67.44 129.47,67.43 arc(129.64,67.27) 129.87,67.21 arc(130.1,67.27) 130.27,67.44 arc(130.43,67.61) 130.66,67.67 130.67,67.67 arc(130.9,67.61) 131.06,67.44 arc(131.23,67.27) 131.46,67.21 131.46,67.21 arc(131.69,67.27) 131.86,67.44 arc(132.03,67.61) 132.26,67.67 132.26,67.67 arc(132.49,67.61) 132.66,67.44 arc(132.82,67.27) 133.05,67.21 133.53,67.21 133.92,67.59 134,67.6 134.01,67.6 arc(134.26,67.67) 134.44,67.85 134.44,67.85 arc(134.62,68.03) 134.87,68.1 134.87,68.1 arc(135.12,68.03) 135.3,67.85 arc(135.48,67.67) 135.73,67.6 135.74,67.6 arc(135.99,67.67) 136.17,67.85 136.17,67.85 arc(136.6,68.1) 137.03,67.85 137.03,67.85 arc(137.21,67.67) 137.46,67.6 137.47,67.6 arc(137.72,67.67) 137.9,67.85 arc(138.08,68.03) 138.33,68.1 138.33,68.1 arc(138.58,68.03) 138.76,67.85 138.77,67.85 arc(138.95,67.67) 139.19,67.6 139.21,67.6 arc(139.45,67.67) 139.63,67.85 139.63,67.85 arc(140.06,68.1) 140.5,67.85 140.5,67.85 arc(140.68,67.67) 140.92,67.6 140.94,67.6 arc(141.18,67.67) 141.36,67.85 arc(141.55,68.03) 141.79,68.1 141.8,68.1 arc(142.05,68.03) 142.23,67.85 142.23,67.85 arc(142.41,67.67) 142.66,67.6 142.67,67.6 arc(142.92,67.67) 143.1,67.85 143.1,67.85 arc(143.28,68.03) 143.53,68.1 144.14,68.1 146.83,70.8 146.83,74.49 150.08,77.74 155.44,77.74 165.99,88.28 166.51,88.28 166.87,88.63 168.74,88.63 169.79,89.68 171.57,89.68 173.15,91.25 173.15,92.16 173.37,92.38 173.37,92.68 173.31,92.75 173.31,93.64 174.93,95.27 174.93,97.09 v1(174.88,97.15)
DDR4_DDIMM2_DQ23: length 97.8
  TOP w0.149: v1(173.35,95.63) 172.95,95.22 169.04,95.22 168.59,94.78 J1.177
  L14_SIG5 w0.081: v1(110.74,72.27) 110.74,71.98 111.14,71.58 arc(111.2,71.35) 111.14,71.12 111.14,71.12 arc(111.08,70.89) 111.14,70.66 arc(111.31,70.49) 111.54,70.43 111.54,70.43 arc(111.76,70.37) 111.93,70.22 111.95,70.18 arc(112.12,70.03) 112.34,69.97 112.36,69.97 arc(112.58,69.9) 112.74,69.74 arc(112.9,69.58) 113.11,69.51 113.13,69.51 arc(113.36,69.45) 113.52,69.3 113.54,69.26 arc(113.71,69.11) 113.93,69.05 113.95,69.05 arc(114.17,68.98) 114.33,68.82 arc(114.49,68.66) 114.71,68.59 114.73,68.59 arc(114.95,68.53) 115.12,68.38 115.14,68.34 arc(115.3,68.19) 115.52,68.13 115.54,68.13 arc(115.76,68.2) 115.92,68.36 arc(116.08,68.52) 116.3,68.59 116.32,68.59 arc(116.54,68.53) 116.71,68.38 116.73,68.34 arc(116.9,68.19) 117.12,68.13 117.14,68.13 arc(117.35,68.19) 117.51,68.34 arc(117.89,68.55) 118.27,68.35 arc(118.45,68.19) 118.68,68.13 118.71,68.13 arc(118.94,68.19) 119.11,68.36 arc(119.27,68.52) 119.49,68.59 119.51,68.59 arc(119.73,68.53) 119.9,68.37 119.92,68.34 arc(120.08,68.19) 120.31,68.13 120.32,68.13 arc(120.54,68.19) 120.7,68.36 arc(121.1,68.59) 121.5,68.36 121.51,68.35 arc(121.68,68.19) 121.9,68.13 121.91,68.13 arc(122.14,68.19) 122.3,68.36 arc(122.46,68.52) 122.68,68.59 122.7,68.59 arc(122.92,68.53) 123.09,68.37 123.1,68.35 arc(123.27,68.19) 123.49,68.13 123.51,68.13 arc(123.73,68.19) 123.89,68.36 arc(124.05,68.52) 124.28,68.59 124.29,68.59 arc(124.51,68.53) 124.68,68.37 124.69,68.35 arc(124.86,68.19) 125.09,68.13 125.1,68.13 arc(125.32,68.19) 125.49,68.36 arc(125.65,68.52) 125.87,68.59 125.88,68.59 arc(126.11,68.53) 126.28,68.37 126.29,68.35 arc(126.45,68.19) 126.68,68.13 126.69,68.13 arc(126.92,68.19) 127.08,68.36 arc(127.24,68.52) 127.47,68.59 127.48,68.59 arc(127.7,68.53) 127.87,68.37 127.88,68.35 arc(128.05,68.19) 128.27,68.13 128.28,68.13 arc(128.51,68.19) 128.67,68.36 arc(128.84,68.52) 129.06,68.59 129.07,68.59 arc(129.3,68.53) 129.47,68.36 129.47,68.35 arc(129.64,68.19) 129.87,68.13 129.87,68.13 arc(130.1,68.19) 130.27,68.36 arc(130.43,68.53) 130.66,68.59 130.67,68.59 arc(130.9,68.53) 131.06,68.36 arc(131.23,68.19) 131.46,68.13 131.46,68.13 arc(131.69,68.19) 131.86,68.36 arc(132.03,68.53) 132.26,68.59 132.26,68.59 arc(132.49,68.53) 132.66,68.36 arc(132.82,68.19) 133.05,68.13 133.26,68.13 133.74,68.61 134,68.6 134.01,68.6 arc(134.25,68.67) 134.44,68.85 134.44,68.85 arc(134.62,69.03) 134.87,69.1 134.87,69.1 arc(135.12,69.03) 135.3,68.85 arc(135.48,68.67) 135.73,68.6 135.74,68.6 arc(135.99,68.67) 136.17,68.85 136.17,68.85 arc(136.6,69.1) 137.03,68.85 137.03,68.85 arc(137.22,68.67) 137.47,68.6 137.47,68.6 arc(137.72,68.67) 137.9,68.85 arc(138.08,69.03) 138.33,69.1 138.33,69.1 arc(138.58,69.03) 138.76,68.85 138.77,68.85 arc(138.95,68.67) 139.2,68.6 139.2,68.6 arc(139.45,68.67) 139.63,68.85 arc(139.81,69.03) 140.06,69.1 arc(140.31,69.03) 140.5,68.85 140.5,68.85 arc(140.68,68.67) 140.93,68.6 140.93,68.6 arc(141.18,68.67) 141.36,68.85 arc(141.55,69.03) 141.79,69.1 141.8,69.1 arc(142.05,69.03) 142.23,68.85 142.23,68.85 arc(142.41,68.67) 142.66,68.6 arc(142.91,68.66) 143.09,68.85 143.1,68.85 arc(143.28,69.03) 143.52,69.1 144.48,69.1 146.37,70.99 146.37,74.68 149.89,78.2 154.76,78.2 159.8,83.24 159.8,84.94 160.39,85.53 160.5,85.53 160.82,85.21 160.94,85.21 161.06,85.33 161.06,85.44 160.74,85.76 160.74,85.88 160.86,86 160.97,86 161.3,85.68 161.41,85.68 161.53,85.8 161.53,85.92 161.21,86.24 161.21,86.35 161.33,86.48 161.45,86.48 161.77,86.15 161.88,86.15 162.01,86.28 162.01,86.39 161.69,86.71 161.69,86.83 161.81,86.95 161.92,86.95 162.24,86.63 162.36,86.63 162.48,86.75 162.48,86.87 162.16,87.19 162.16,87.3 162.28,87.42 162.4,87.42 162.72,87.1 162.83,87.1 162.95,87.23 162.95,87.34 162.63,87.66 162.63,87.78 164.42,89.56 169.02,89.56 169.6,90.14 170.98,90.14 172.19,91.35 172.19,92.18 172.2,92.19 172.2,93.85 173.35,95 v1(173.35,95.63)
DDR4_DDIMM2_DQ24: length 59
  L12_SIG4 w0.089: v1(164.34,97.95) 164.34,97.69 164.57,97.47 164.73,97.47 164.82,97.56 164.82,98.15 164.65,98.32 164.01,98.32 163.91,98.22 163.91,97.62 164.14,97.39 164.14,97.12 163.99,96.98 163.99,96.85 164.11,96.73 164.23,96.73 164.4,96.91 164.62,96.91 164.73,96.8 164.73,96.49 164.63,96.38 164.18,96.38 164.08,96.29 164.08,96.12 164.17,96.04 164.64,96.04 164.73,95.95 164.73,95.77 164.59,95.63 163.8,95.63 163.72,95.72 163.72,96.28 163.63,96.37 163.26,96.37 163.2,96.31 163.2,96.16 163.11,96.07 162.92,96.07 162.83,95.98 162.83,95.81 162.92,95.72 163.11,95.72 163.2,95.64 163.2,95.13 162.8,94.73 162.8,93.84 162.65,93.69 162.65,93.16 162.52,93.03 162.39,93.03 162.27,93.16 162.14,93.16 162.03,93.04 162.03,92.92 162.15,92.79 162.15,92.67 162.03,92.55 161.91,92.55 161.78,92.67 161.66,92.67 161.54,92.56 161.54,92.43 161.66,92.31 161.66,92.18 161.55,92.06 161.42,92.06 161.3,92.19 161.17,92.19 161.06,92.07 161.06,91.95 161.18,91.82 161.18,91.7 158.98,89.5 158.73,89.5 158.64,89.41 158.64,89.16 158.55,89.07 158.14,89.07 158.05,88.97 158.05,88.77 157.96,88.68 157.79,88.68 157.7,88.77 157.7,88.95 157.61,89.04 157.45,89.04 157.36,88.95 157.36,88.77 157.27,88.68 157.11,88.68 157.02,88.77 157.02,88.95 156.93,89.04 156.76,89.04 156.67,88.95 156.67,88.77 156.59,88.68 156.42,88.68 156.33,88.77 156.33,88.95 156.24,89.04 156.08,89.04 155.44,88.4 147.5,88.4 143.03,83.92 140.5,83.92 140.15,83.57 136.94,83.57 136.83,83.46 131.89,83.46 131.5,83.07 131.21,83.07 130.77,82.63 130.58,82.63 130.24,82.96 130.06,82.96 129.97,82.87 129.97,82.44 129.88,82.35 128.92,82.35 128.56,81.98 128.03,81.98 127.6,81.55 127.6,81.29 127.51,81.2 127.11,81.2 126.95,81.35 126.77,81.35 126.61,81.2 126.07,81.2 v1(125.88,81.01)
DDR4_DDIMM2_DQ25: length 56.3
  L12_SIG4 w0.089: v1(125.88,79.17) 126.28,79.86 arc(126.34,80.09) 126.29,80.31 126.27,80.34 arc(126.24,80.42) 126.22,80.51 arc(126.22,80.55) 126.22,80.59 arc(126.24,80.69) 126.28,80.78 126.31,80.83 126.47,80.99 127.7,80.99 128.22,81.51 129.33,81.51 129.42,81.6 129.42,81.71 129.51,81.8 129.68,81.8 129.77,81.71 129.77,81.6 129.86,81.51 130.02,81.51 130.11,81.6 130.11,81.71 130.2,81.8 130.36,81.8 130.45,81.71 130.45,81.6 130.54,81.51 130.72,81.51 131.27,82.06 131.27,82.19 131.23,82.23 131.23,82.36 131.34,82.47 131.47,82.47 131.51,82.43 131.64,82.43 132.08,82.87 132.58,82.87 132.69,82.98 132.92,82.98 133.03,82.87 133.26,82.87 133.37,82.98 133.61,82.98 133.71,82.87 133.95,82.87 134.06,82.98 134.29,82.98 134.4,82.87 134.64,82.87 134.74,82.98 134.98,82.98 135.09,82.87 135.32,82.87 135.43,82.98 135.67,82.98 135.77,82.87 136.01,82.87 136.11,82.98 136.35,82.98 136.46,82.87 136.9,82.87 137.12,83.09 141.88,83.09 141.97,83.18 141.97,83.34 142.05,83.42 142.22,83.42 142.31,83.34 142.31,83.18 142.4,83.09 142.86,83.09 147.7,87.93 155.63,87.93 155.91,88.21 158.35,88.21 159.11,88.96 159.24,88.96 159.34,88.86 159.46,88.86 159.58,88.98 159.58,89.11 159.48,89.2 159.48,89.33 159.6,89.45 159.72,89.45 159.82,89.35 159.95,89.35 160.06,89.46 160.06,89.59 159.96,89.69 159.96,89.82 160.08,89.93 160.21,89.93 160.31,89.83 160.43,89.83 160.55,89.95 160.55,90.08 160.45,90.17 160.45,90.3 160.56,90.42 160.69,90.42 160.79,90.32 160.92,90.32 161.03,90.43 161.03,90.56 160.93,90.66 160.93,90.79 161.05,90.9 161.18,90.9 161.28,90.8 161.4,90.8 161.52,90.92 161.52,91.04 161.42,91.14 161.42,91.27 161.53,91.39 161.66,91.39 161.76,91.29 161.89,91.29 162,91.4 162,91.53 161.9,91.63 161.9,91.75 162.02,91.87 162.15,91.87 162.24,91.77 162.37,91.77 162.49,91.89 162.49,92.01 162.39,92.11 162.39,92.24 163.12,92.97 163.12,93.5 163.27,93.65 163.27,94.54 163.89,95.16 164.59,95.16 164.68,95.07 164.68,94.52 164.59,94.43 163.79,94.43 163.7,94.34 163.7,94.18 163.79,94.09 164.54,94.09 164.64,93.99 164.64,93.81 164.55,93.72 164.19,93.72 163.72,93.25 163.59,93.25 v1(163.49,93.34)
DDR4_DDIMM2_DQ26: length 57.7
  TOP w0.149: v1(165.73,97.14) 165.5,96.91 159.05,96.91 158.39,97.56 J1.45
  L12_SIG4 w0.089: v1(126.68,79.63) 127.14,80.09 127.14,80.23 127.34,80.43 128.02,80.43 128.51,80.92 131.55,80.92 132.28,81.64 arc(132.53,81.81) 132.83,81.87 134.74,81.87 arc(135.06,81.81) 135.34,81.62 arc(135.54,81.48) 135.79,81.44 137.82,81.44 arc(137.95,81.42) 138.09,81.37 arc(138.09,81.36) 138.1,81.36 arc(138.22,81.29) 138.35,81.26 139.09,81.26 arc(139.3,81.3) 139.48,81.42 139.69,81.63 arc(139.71,81.65) 139.73,81.67 arc(139.74,81.69) 139.77,81.71 arc(139.8,81.74) 139.83,81.77 139.87,81.81 arc(140.21,82.04) 140.62,82.12 143.22,82.12 148.09,86.99 156.02,86.99 156.3,87.27 159.29,87.27 163.23,91.21 163.66,91.21 165.67,93.22 165.67,97.08 v1(165.73,97.14)
DDR4_DDIMM2_DQ27: length 59.5
  L12_SIG4 w0.089: v1(126.68,80.55) 127.16,80.55 127.25,80.64 127.88,80.64 128.38,81.14 131.03,81.14 132.29,82.4 136.8,82.4 136.91,82.29 138.19,82.29 138.49,82.59 143.03,82.59 147.89,87.46 155.83,87.46 156.11,87.74 159.1,87.74 162.97,91.61 162.97,91.96 163.2,92.19 163.76,92.19 165.2,93.62 165.2,97.27 165.57,97.64 165.57,98.31 165.09,98.79 161.6,98.79 161.03,98.23 160.22,98.23 159.62,97.63 159.62,96.77 v1(157.54,94.69)
DDR4_DDIMM2_DQ28: length 57
  L12_SIG4 w0.089: v1(122.7,81.01) 122.98,81.38 122.98,82.09 123.01,82.12 123.01,83.2 124.81,85 124.81,85.62 125.25,86.06 128.6,86.06 129.02,86.48 129.74,86.48 130.29,87.04 131.81,87.04 134.38,89.6 135.33,89.6 135.72,89.6 136.48,90.36 145.45,90.36 146.02,90.93 149.57,90.93 150.48,91.84 156.01,91.84 156.99,92.82 156.99,94.83 158.08,95.92 158.08,96.05 157.77,96.36 157.77,96.48 157.88,96.6 158.01,96.6 158.32,96.29 158.45,96.29 158.56,96.4 158.56,96.53 158.25,96.84 158.25,96.97 158.37,97.08 158.5,97.08 158.81,96.77 158.93,96.77 159.15,97 159.15,97.83 160.59,99.26 165.39,99.26 166.04,98.61 v1(166.04,97.95)
DDR4_DDIMM2_DQ29: length 59.3
  TOP w0.149: v1(157.29,95.74) 157.5,95.95 arc(157.51,95.96) 157.52,95.96 164.42,95.96 arc(164.43,95.96) 164.44,95.95 165.19,95.2 arc(165.2,95.19) 165.2,95.18 165.2,94.06 arc(165.2,94.05) J1.181
  L12_SIG4 w0.089: v1(157.29,95.74) 157.24,95.74 156.76,95.27 156.64,95.27 156.44,95.47 156.31,95.47 156.19,95.35 156.19,95.23 156.39,95.03 156.39,94.9 156.24,94.75 156.24,94.48 156.33,94.39 156.42,94.39 156.51,94.3 156.51,94.13 156.42,94.05 156.33,94.05 156.24,93.96 156.24,92.8 155.78,92.34 155.59,92.34 155.5,92.43 155.5,93 155.41,93.09 155.24,93.09 155.15,93 155.15,92.43 155.07,92.34 150.32,92.34 149.38,91.4 145.82,91.4 145.25,90.83 136.28,90.83 135.53,90.07 135.14,90.07 134.18,90.07 132.21,88.1 131.97,88.1 131.88,88.01 131.88,87.8 131.79,87.71 131.63,87.71 131.54,87.8 131.54,88.19 131.43,88.3 130.88,88.3 130.68,88.09 130.68,87.89 130.82,87.75 130.82,87.59 130.73,87.51 130.58,87.51 130.4,87.68 130.27,87.68 129.54,86.95 128.82,86.95 128.51,86.64 127.47,86.64 125,86.64 123.68,85.32 123.68,84.54 122.54,83.4 122.54,82.89 122.19,82.54 122.19,81.78 122.25,81.72 122.25,80.86 122.31,80.75 arc(122.36,80.53) 122.3,80.32 122.3,80.31 arc(122.24,80.09) 122.3,79.86 v1(122.7,79.17)
DDR4_DDIMM2_DQ30: length 58.4
  TOP w0.149: J1.43 v1(160.09,97.44)
  L12_SIG4 w0.089: v1(123.49,79.63) 123.49,80 123.58,80.08 123.84,80.08 123.93,79.98 123.93,79.39 123.75,79.21 123.19,79.21 123,79.39 123,79.62 123.12,79.74 123.12,80.85 123.64,81.37 123.64,81.88 123.84,82.08 123.84,82.56 123.75,82.65 123.63,82.65 123.54,82.74 123.54,82.9 123.63,82.99 123.75,82.99 123.84,83.08 123.84,83.37 124.25,83.77 124.37,83.77 124.77,83.37 124.9,83.37 125.01,83.49 125.01,83.62 124.61,84.02 124.61,84.14 124.77,84.3 124.9,84.3 125.04,84.15 125.16,84.15 125.28,84.27 125.28,84.4 125.14,84.54 125.14,84.66 125.28,84.81 125.28,85.15 125.69,85.57 128.76,85.57 129.21,86.01 129.93,86.01 130.48,86.57 131.11,86.57 131.19,86.48 131.19,86.11 131.28,86.02 131.45,86.02 131.54,86.11 131.54,86.48 131.63,86.57 132.01,86.57 132.4,86.96 132.52,86.96 132.68,86.79 132.81,86.79 132.93,86.91 132.93,87.04 132.76,87.2 132.76,87.32 132.88,87.44 133.01,87.44 133.17,87.28 133.29,87.28 133.41,87.4 133.41,87.52 133.25,87.68 133.25,87.81 133.37,87.93 133.49,87.93 133.65,87.76 133.78,87.76 133.9,87.88 133.9,88.01 133.73,88.17 133.73,88.29 133.85,88.41 133.98,88.41 134.14,88.25 134.26,88.25 134.38,88.37 134.38,88.49 134.22,88.65 134.22,88.78 134.57,89.13 135.14,89.13 135.53,89.13 135.92,89.13 136.67,89.89 145.8,89.89 146.37,90.46 149.77,90.46 150.26,90.95 151.82,90.95 151.91,91.04 151.91,91.24 152,91.33 152.16,91.33 152.25,91.24 152.25,91.04 152.34,90.95 152.51,90.95 152.6,91.04 152.6,91.24 152.69,91.33 152.85,91.33 152.94,91.24 152.94,91.04 153.03,90.95 153.81,90.95 154.22,91.36 155.3,91.36 155.42,91.23 155.64,91.23 155.77,91.36 156.23,91.36 157.46,92.59 157.46,93.95 160.09,96.58 v1(160.09,97.44)
DDR4_DDIMM2_DQ31: length 56.9
  L12_SIG4 w0.089: v1(123.49,80.55) 123.49,80.74 123.91,81.16 123.91,81.17 124.13,81.38 124.14,81.38 124.18,81.43 124.18,81.72 arc(124.18,81.75) 124.2,81.78 124.31,81.89 124.31,82.1 125.71,83.5 125.71,84 125.97,84.26 125.97,84.38 125.89,84.46 125.89,84.59 126,84.7 126.13,84.7 126.21,84.63 126.33,84.63 126.64,84.93 128.8,84.93 129.41,85.54 131.65,85.54 131.82,85.71 132.43,85.71 134.4,87.69 135.13,87.69 136.87,89.42 145.99,89.42 146.56,89.99 150.36,89.99 150.45,90.08 150.45,90.34 150.54,90.43 150.7,90.43 150.79,90.34 150.79,90.08 150.88,89.99 151.04,89.99 151.13,90.08 151.13,90.34 151.22,90.43 151.39,90.43 151.48,90.34 151.48,90.08 151.56,89.99 151.73,89.99 151.82,90.08 151.82,90.34 151.91,90.43 152.07,90.43 152.16,90.34 152.16,90.08 152.25,89.99 152.42,89.99 152.5,90.08 152.5,90.34 152.59,90.43 152.76,90.43 152.85,90.34 152.85,90.08 152.94,89.99 153.1,89.99 153.19,90.08 153.19,90.34 153.28,90.43 153.44,90.43 153.53,90.34 153.53,90.08 153.62,89.99 153.79,89.99 153.88,90.08 153.88,90.34 153.96,90.43 154.13,90.43 154.22,90.34 154.22,90.08 154.31,89.99 154.82,89.99 154.91,90.08 154.91,90.21 154.56,90.56 154.56,90.68 154.68,90.8 154.81,90.8 155.16,90.45 155.28,90.45 155.44,90.6 157.04,90.6 157.23,90.79 157.23,90.91 156.96,91.18 156.96,91.31 157.07,91.43 157.2,91.43 157.47,91.16 157.59,91.16 157.71,91.27 157.71,91.4 157.44,91.67 157.44,91.79 157.56,91.91 157.69,91.91 157.95,91.64 158.08,91.64 158.33,91.89 158.33,92.81 157.93,93.21 157.93,93.76 159.87,95.69 159.99,95.69 160.12,95.56 160.12,95.43 158.7,94.01 158.7,92.84 158.79,92.75 159.02,92.75 159.28,93.01 v1(159.28,93.27)
DDR4_DDIMM2_DQ32: length 50.9
  L03_SIG1 w0.081: v1(109.1,99.26) 109.1,98.82 109.75,98.17 109.75,97.9 109.67,97.82 109.48,97.82 109.4,97.74 109.4,97.57 109.48,97.48 109.67,97.48 109.75,97.4 109.75,95.5 107.78,93.54 107.78,93.15 108.42,92.51 111.07,92.51 116.01,87.57 116.01,83.39 115.81,83.19 115.81,80.91 116.03,80.69 116.03,80.35 115.97,80.29 115.97,79.54 115.51,79.08 115.37,79.08 115.15,78.86 115.15,74.47 114.88,74.2 114.54,74.2 114.08,73.74 113.75,73.74 113.29,73.28 113.13,73.28 112.76,72.91 112.53,72.91 112.47,72.86 112.19,72.86 111.93,73.11 111.29,73.11 110.88,73.52 110.4,73.52 110.12,73.24 110.12,73.08 110.32,72.88 110.32,72.75 110.43,72.64 111.11,72.64 111.6,72.14 111.94,72.14 112.18,71.9 112.49,71.9 112.73,72.14 113.28,72.14 113.78,72.64 114.11,72.64 114.72,73.25 115.11,73.25 115.39,73.52 115.55,73.52 115.95,73.92 115.95,78.8 v2(116.32,79.17)
DDR4_DDIMM2_DQ33: length 49.2
  L03_SIG1 w0.081: v1(108.24,93.34) 108.62,92.97 110.2,92.97 110.46,93.23 110.46,93.98 110.42,94.02 110.42,94.6 110.65,94.82 110.77,94.82 111.34,94.25 111.45,94.25 111.58,94.37 111.58,94.49 111,95.06 111,95.18 111.01,95.18 111.01,95.89 111.01,95.89 111.01,96.7 111.09,96.78 111.53,96.78 111.61,96.87 111.61,97.04 111.53,97.12 111.09,97.12 111.01,97.2 111.01,97.37 111.09,97.45 111.4,97.45 111.48,97.54 111.48,97.71 111.4,97.79 111.09,97.79 111.01,97.87 111.01,98.59 111.27,98.85 111.27,99.66 111.35,99.74 111.86,99.74 111.94,99.82 111.94,100 111.86,100.08 111.35,100.08 111.27,100.16 111.27,100.28 111.57,100.58 112.27,100.58 112.45,100.41 112.45,99.82 112.12,99.5 112.12,99.19 112.4,98.91 112.4,98.75 112.32,98.67 112.11,98.67 112.03,98.59 112.03,98.42 112.11,98.33 112.32,98.33 112.4,98.25 112.4,98.02 112.32,97.94 112.18,97.94 112.09,97.86 112.09,97.69 112.18,97.6 112.32,97.6 112.4,97.52 112.4,96.6 112.32,96.52 111.88,96.52 111.8,96.44 111.8,96.26 111.88,96.18 112.32,96.18 112.4,96.1 112.4,95.93 112.32,95.85 111.58,95.85 111.5,95.77 111.5,95.59 111.58,95.51 112.32,95.51 112.4,95.43 112.4,94.77 112.13,94.49 112.13,94.18 112.4,93.91 112.4,93.74 112.32,93.66 112.09,93.66 112.01,93.58 112.01,93.4 112.09,93.32 112.32,93.32 112.4,93.24 112.4,93.07 112.32,92.99 112.09,92.99 112.01,92.9 112.01,92.73 112.09,92.65 112.32,92.65 112.4,92.57 112.4,92.4 112.62,92.18 112.62,92.07 112.48,91.93 112.48,91.81 112.6,91.69 112.72,91.69 112.86,91.83 112.97,91.83 113.88,90.93 113.88,90.81 113.74,90.68 113.74,90.57 113.86,90.44 113.98,90.44 114.11,90.58 114.23,90.58 114.35,90.46 114.35,90.34 114.22,90.21 114.22,90.09 114.34,89.97 114.45,89.97 114.59,90.1 114.7,90.1 114.82,89.98 114.82,89.87 114.69,89.73 114.69,89.62 114.81,89.5 114.93,89.5 115.06,89.63 115.18,89.63 115.3,89.51 115.3,89.39 115.16,89.26 115.16,89.14 115.29,89.02 115.4,89.02 115.53,89.15 115.65,89.15 115.77,89.03 115.77,88.92 115.64,88.78 115.64,88.67 115.76,88.55 115.88,88.55 116.01,88.68 116.12,88.68 116.25,88.56 116.25,88.44 116.11,88.31 116.11,88.19 116.23,88.07 116.35,88.07 116.48,88.21 116.6,88.21 116.94,87.87 116.94,87.71 116.85,87.62 116.58,87.62 116.5,87.54 116.5,87.37 116.58,87.29 116.85,87.29 116.94,87.21 116.94,87.03 116.85,86.95 116.58,86.95 116.5,86.87 116.5,86.7 116.58,86.62 116.85,86.62 116.94,86.54 116.94,84.9 116.85,84.82 116.62,84.82 116.54,84.74 116.54,84.57 116.62,84.49 116.85,84.49 116.94,84.41 116.94,84.23 116.85,84.15 116.62,84.15 116.54,84.07 116.54,83.9 116.62,83.82 116.85,83.82 116.94,83.74 116.94,83.15 116.48,82.7 116.48,82.51 116.32,82.35 116.32,82.17 116.48,82.01 116.48,81.83 116.32,81.68 116.32,81.5 116.48,81.34 116.48,81.17 v2(116.32,81.01)
DDR4_DDIMM2_DQ34: length 49.3
  L03_SIG1 w0.081: v1(103.14,99.34) 103.14,99.59 103.33,99.77 103.72,99.77 104.39,100.44 104.39,102.06 104.58,102.24 104.58,103.48 104.44,103.63 104.44,104.16 104.82,104.54 109.83,104.54 112.03,102.34 112.03,101.99 112.91,101.11 112.91,99.63 112.86,99.59 112.86,99.1 112.87,99.1 112.87,96.65 112.92,96.6 112.92,93.12 113.31,92.73 113.31,92.16 115.36,90.1 115.48,90.1 116.4,91.02 116.51,91.02 116.64,90.9 116.64,90.79 115.72,89.87 115.72,89.75 115.84,89.63 115.95,89.63 116.95,90.62 117.07,90.62 117.19,90.5 117.19,90.39 116.19,89.39 116.19,89.28 116.31,89.15 116.43,89.15 117.35,90.07 117.46,90.07 117.58,89.95 117.58,89.84 116.66,88.92 116.66,88.8 116.79,88.68 116.9,88.68 117.64,89.42 117.75,89.42 117.87,89.3 117.87,89.18 117.14,88.44 117.14,88.33 117.4,88.07 117.4,82.96 116.94,82.5 116.94,80.73 v2(117.12,80.55)
DDR4_DDIMM2_DQ35: length 51.5
  TOP w0.149: J1.249 v1(102.29,92.79)
  L03_SIG1 w0.081: v2(117.12,79.63) 117.12,79.36 116.69,78.93 116.69,72.58 116.48,72.36 115.96,72.36 115.68,72.64 115.37,72.64 115.09,72.36 114.81,72.36 114.17,71.72 113.52,71.72 113.21,71.42 113.07,71.42 arc(112.97,71.4) 112.89,71.34 112.78,71.23 arc(112.75,71.19) 112.73,71.14 arc(112.71,71.1) 112.68,71.06 112.62,70.99 arc(112.61,70.99) 112.6,70.99 112.44,70.99 arc(112.42,70.98) 112.39,70.98 arc(112.34,70.98) 112.28,70.98 arc(112.26,70.98) 112.23,70.99 112.2,70.99 112.18,71 112.17,71 arc(112.15,71.03) 112.12,71.05 arc(112.07,71.09) 112.03,71.14 arc(112.01,71.16) 111.99,71.18 111.7,71.47 111.68,71.48 111.64,71.48 arc(111.62,71.48) 111.59,71.48 arc(111.54,71.48) 111.49,71.48 arc(111.47,71.48) 111.44,71.48 111.41,71.48 111.39,71.49 111.16,71.72 110.33,71.72 110.09,71.48 109.81,71.48 109.57,71.72 108.74,71.72 108.49,71.48 108.22,71.48 107.98,71.72 107.14,71.72 106.9,71.48 106.62,71.48 105.91,70.76 105.82,70.76 105.43,70.37 105.42,70.35 105.01,70.35 104.6,70.76 104.43,70.76 104,71.2 104,73.29 104.23,73.52 104.41,73.52 105.08,74.2 105.32,74.2 105.55,74.43 105.55,76.14 105.85,76.44 106.26,76.44 106.61,76.78 106.94,76.78 107.4,77.24 107.74,77.24 108.37,77.88 108.51,77.88 108.78,78.15 108.78,84.73 109.03,84.98 109.03,86.31 108.78,86.56 108.17,86.56 102.29,92.44 v1(102.29,92.79)
DDR4_DDIMM2_DQ36: length 52.7
  L03_SIG1 w0.081: v2(113.14,79.17) 112.73,78.76 112.73,75.82 112.49,75.58 112.18,75.58 111.94,75.82 111.14,75.82 110.9,75.58 110.59,75.58 110.35,75.82 109.55,75.82 109.31,75.58 108.8,75.58 108.34,76.04 108.2,76.04 107.97,76.26 107.97,76.72 108.21,76.96 108.51,76.96 108.79,77.24 109.07,77.24 109.48,77.65 109.48,77.93 109.39,78.02 109.39,78.42 109.52,78.56 109.52,78.86 109.39,79 109.39,79.34 109.52,79.48 109.52,79.78 109.39,79.92 109.39,80.26 109.52,80.4 109.52,80.7 109.39,80.84 109.39,84.68 109.49,84.79 109.49,86.51 108.97,87.02 108.36,87.02 102.76,92.63 102.76,93.02 102.14,93.63 102.14,94.91 102.43,95.2 102.43,96.53 102.57,96.67 102.57,97.84 103.91,99.18 103.91,99.31 104.86,100.25 104.86,101.87 105.04,102.05 105.04,103.53 105.59,104.08 109.63,104.08 111.17,102.55 111.17,100.83 110.79,100.45 v1(110.79,99.34)
