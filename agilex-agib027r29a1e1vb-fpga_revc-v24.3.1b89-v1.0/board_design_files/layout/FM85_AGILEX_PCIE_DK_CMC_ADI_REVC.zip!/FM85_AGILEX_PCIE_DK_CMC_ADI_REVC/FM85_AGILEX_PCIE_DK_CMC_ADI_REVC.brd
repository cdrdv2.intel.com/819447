# Allegro board FM85_AGILEX_PCIE_DK_CMC_ADI_REVC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_COMP_CH1_DQ35: length 50.7
  L07_SIG3 w0.089: v1(144.79,28.86) 146.8,28.86 147.02,28.64 147.02,27.88 146.81,27.67 145.99,27.67 145.9,27.58 145.9,27.16 145.81,27.07 145.65,27.07 145.56,27.16 145.56,27.58 145.47,27.67 141.67,27.67 141.58,27.58 141.58,26.5 141.49,26.41 141.33,26.41 141.24,26.5 141.24,27.58 141.15,27.67 140.98,27.67 140.9,27.58 140.9,26.5 140.81,26.41 140.64,26.41 140.55,26.5 140.55,27.58 140.46,27.67 140.3,27.67 140.21,27.58 140.21,26.5 140.12,26.41 139.96,26.41 139.87,26.5 139.87,27.58 139.78,27.67 137.18,27.67 137.09,27.58 137.09,26.51 137,26.42 136.83,26.42 136.74,26.51 136.74,27.58 136.66,27.67 135.54,27.67 135.45,27.58 135.45,26.53 135.36,26.44 135.2,26.44 135.11,26.53 135.11,27.58 135.02,27.67 132.21,27.67 131.89,27.99 131.89,34.26 130.36,35.79 127.03,35.79 126.73,36.08 126.73,36.45 126.3,36.87 126.3,38.79 126.04,39.06 125.7,39.06 125.24,39.52 125.1,39.52 124.7,39.93 124.7,41.8 124.29,42.2 v1(124.29,42.37)
DDR4_COMP_CH1_DQ36: length 52
  L07_SIG3 w0.089: v1(127.48,44.21) 128.54,44.21 128.92,43.83 129.23,43.83 129.69,44.29 129.98,44.29 130.45,43.82 130.86,43.82 131.31,43.37 131.64,43.37 132.1,42.91 132.35,42.91 132.81,42.45 133.14,42.45 133.43,42.16 133.43,37.61 133.82,37.21 134.3,37.21 136.12,35.39 136.79,35.39 137.29,34.89 138.27,34.89 138.36,34.8 138.36,34.58 138.45,34.49 138.62,34.49 138.7,34.58 138.7,34.8 138.79,34.89 138.96,34.89 139.05,34.8 139.05,34.58 139.14,34.49 139.3,34.49 139.39,34.58 139.39,34.8 139.48,34.89 139.64,34.89 139.73,34.8 139.73,34.58 139.82,34.49 139.99,34.49 140.08,34.58 140.08,34.8 140.17,34.89 140.33,34.89 140.42,34.8 140.42,34.58 140.51,34.49 140.67,34.49 140.76,34.58 140.76,34.8 140.85,34.89 141.02,34.89 141.11,34.8 141.11,34.58 141.19,34.49 141.36,34.49 141.45,34.58 141.45,34.8 141.54,34.89 141.7,34.89 141.79,34.8 141.79,34.58 141.88,34.49 142.04,34.49 142.13,34.58 142.13,34.8 142.22,34.89 142.39,34.89 142.48,34.8 142.48,34.58 142.57,34.49 142.73,34.49 142.82,34.58 142.82,34.8 142.91,34.89 143.07,34.89 143.16,34.8 143.16,34.58 143.25,34.49 143.42,34.49 143.51,34.58 143.51,34.8 143.59,34.89 143.76,34.89 143.85,34.8 143.85,34.58 143.94,34.49 144.1,34.49 144.19,34.58 144.19,34.8 144.28,34.89 144.62,34.89 147.6,31.92 149.26,31.92 151.88,29.29 151.88,24.81 151.47,24.4 150.92,24.4 150.83,24.49 146.12,24.49 146.03,24.58 146.03,25.22 v1(144.79,26.46)
DDR4_COMP_CH1_DQ37: length 51.3
  L07_SIG3 w0.089: v1(148.79,28.06) 148.85,28 149.11,28 149.21,28.1 149.21,29.33 148.52,30.03 145.14,30.03 144.95,29.84 141.45,29.84 141.29,29.99 141.29,31.31 141.2,31.39 141.04,31.39 140.95,31.31 140.95,30.01 140.86,29.92 140.69,29.92 140.6,30.01 140.6,31.29 140.51,31.37 140.34,31.37 140.23,31.26 140.23,30.01 140.14,29.92 139.98,29.92 139.87,30.03 139.87,31.4 139.7,31.56 136.18,31.56 136.04,31.43 136.04,31.08 135.96,30.99 135.17,30.99 135.08,30.9 135.08,30.74 135.17,30.65 135.96,30.65 136.04,30.56 136.04,29.94 135.92,29.81 134.84,29.81 134.72,29.93 134.72,30.72 134.63,30.81 133.15,30.81 133.03,30.93 133.03,31.26 133.12,31.35 134.68,31.35 134.77,31.44 134.77,31.76 134.63,31.9 134.36,31.9 134.27,31.99 134.27,32.15 134.36,32.24 134.63,32.24 134.72,32.33 134.72,33.03 130.83,36.92 130.74,36.92 130.3,36.92 129.71,37.51 129.71,37.51 129.47,37.75 129.47,38.82 129.23,39.06 129.06,39.06 128.43,39.69 127.92,39.69 127.63,39.98 127.29,39.98 126.83,40.44 126.71,40.44 126.54,40.61 126.52,40.61 126.3,40.83 126.3,40.85 126.27,40.88 126.27,42.71 126.07,42.91 125.73,42.91 125.27,43.37 124.76,43.37 124.39,43.75 v1(123.49,43.75)
DDR4_COMP_CH1_DQ38: length 51.4
  L07_SIG3 w0.089: v1(124.29,44.21) 125.35,44.21 125.73,43.83 126.24,43.83 126.52,44.12 126.84,44.12 127.12,43.83 127.52,43.83 128.15,43.2 128.43,43.2 128.89,42.74 129.07,42.74 129.07,42.75 129.55,43.24 130.14,43.24 130.47,42.91 130.85,42.91 131.31,42.45 131.64,42.45 132.27,41.82 132.41,41.82 132.63,41.6 132.63,37.92 132.63,37.07 133.04,36.67 134.19,36.67 136.52,34.33 136.52,33.51 136.63,33.4 137.46,33.4 137.57,33.51 137.57,33.97 137.68,34.07 139.01,34.07 139.11,33.98 139.11,33.53 139.2,33.44 139.87,33.44 139.96,33.53 139.96,33.92 140.1,34.06 142.2,34.06 142.34,33.93 142.34,33.68 142.48,33.54 143.63,33.54 143.78,33.7 143.78,33.99 143.92,34.13 144.87,34.13 147.42,31.57 149.11,31.57 151.54,29.15 151.54,25.51 151.32,25.29 147,25.29 146.78,25.51 146.78,25.81 146.56,26.03 146.02,26.03 v1(144.79,27.26)
DDR4_COMP_CH1_DQ39: length 51.7
  L07_SIG3 w0.089: v1(147.99,26.46) 147.05,26.46 146.96,26.37 146.96,26.15 147.05,26.06 147.61,26.06 147.8,25.87 148.25,25.87 148.41,26.04 150.99,26.04 151.19,26.24 151.19,29.01 148.97,31.23 147.24,31.23 145.31,33.16 142.35,33.16 141.79,33.72 140.36,33.72 140.3,33.66 140.3,32.68 140.21,32.59 140.05,32.59 139.96,32.68 139.96,32.92 139.87,33.01 139.7,33.01 139.61,32.92 139.61,32.68 139.53,32.59 139.36,32.59 139.27,32.68 139.27,32.92 139.18,33.01 139.02,33.01 138.93,32.92 138.93,32.68 138.84,32.59 138.67,32.59 138.59,32.68 138.59,32.92 138.5,33.01 138.33,33.01 138.24,32.92 138.24,32.68 138.15,32.59 137.99,32.59 137.9,32.68 137.9,32.92 137.81,33.01 137.65,33.01 137.56,32.92 137.56,32.68 137.47,32.59 137.3,32.59 137.21,32.68 137.21,32.92 137.13,33.01 136.2,33.01 135.62,33.6 135.62,33.72 136.06,34.16 136.06,34.29 135.94,34.41 135.81,34.41 135.37,33.97 135.25,33.97 135.13,34.08 135.13,34.21 135.57,34.65 135.57,34.77 135.45,34.89 135.33,34.89 134.89,34.45 134.76,34.45 134.65,34.57 134.65,34.69 135.09,35.13 135.09,35.26 134.97,35.38 134.84,35.38 134.4,34.94 134.28,34.94 134.16,35.05 134.16,35.18 134.6,35.62 134.6,35.74 134.48,35.86 134.36,35.86 133.92,35.42 133.79,35.42 131.84,37.38 131.84,41.14 131.62,41.36 131.28,41.36 130.82,41.82 130.63,41.82 130.17,42.28 129.6,42.28 129.14,41.82 128.89,41.82 128.43,42.28 128.23,42.28 127.6,42.91 127.32,42.91 127.1,43.13 127.1,43.32 v1(126.68,43.75)
DDR4_COMP_CH1_DQ40: length 29.5
  L03_SIG1 w0.081: v1(143.41,40.53) 143.03,40.15 143.03,37.44 145.39,35.09 145.39,34.18 148.28,31.28 154.58,31.28 157.08,28.79 157.08,26.44 156.99,26.36 156.77,26.36 156.67,26.26 156.67,26.1 156.77,26 156.97,26 157.08,25.9 157.08,23.8 157.95,22.92 158.82,22.92 158.95,23.05 v5(158.95,23.3)
DDR4_COMP_CH1_DQ41: length 31.5
  L03_SIG1 w0.081: v1(140.23,40.53) 140.62,40.13 140.62,36.82 141.29,36.15 141.29,35.11 143.53,32.87 143.64,32.87 143.96,33.19 144.08,33.19 144.19,33.08 144.19,32.96 143.87,32.64 143.87,32.53 143.99,32.41 144.1,32.41 144.42,32.73 144.54,32.73 144.65,32.62 144.65,32.5 144.33,32.18 144.33,32.07 144.45,31.95 144.56,31.95 144.88,32.27 145,32.27 145.11,32.16 145.11,32.04 144.79,31.72 144.79,31.61 145.03,31.37 145.14,31.37 145.32,31.55 145.44,31.55 145.56,31.42 145.56,31.31 145.38,31.13 145.38,31.02 146.49,29.91 154.09,29.91 154.57,29.43 154.57,23.68 v5(154.95,23.3)
DDR4_COMP_CH1_DQ42: length 29.5
  L03_SIG1 w0.081: v1(142.62,40.07) 142.62,39.88 142.22,39.49 142.22,37.74 145.05,34.91 145.05,34.04 148.14,30.95 154.44,30.95 156.61,28.77 156.61,28.2 156.18,27.77 156.18,24.8 156.27,24.72 156.55,24.72 156.63,24.64 156.63,24.47 156.55,24.39 156.27,24.39 156.18,24.31 156.18,23.71 156.27,23.62 156.68,23.62 156.71,23.6 156.72,23.6 157.73,22.59 158.06,22.59 v5(158.15,22.5)
DDR4_COMP_CH1_DQ43: length 31.7
  L03_SIG1 w0.081: v5(154.15,23.3) 153.76,23.69 153.03,23.69 152.87,23.85 152.87,28.55 152.19,29.24 146.21,29.24 145.3,30.15 144.82,30.15 144.74,30.07 144.74,29.95 144.66,29.87 144.49,29.87 144.41,29.95 144.41,30.07 144.33,30.15 143.99,30.15 142.45,31.69 142.45,31.8 142.55,31.9 142.55,32.02 142.37,32.21 142.25,32.21 141.96,31.91 141.84,31.91 141.73,32.03 141.73,32.14 142.02,32.44 142.02,32.55 141.91,32.67 141.79,32.67 141.5,32.37 141.38,32.37 141.27,32.49 141.27,32.6 141.56,32.9 141.56,33.04 141.48,33.13 141.33,33.13 141.04,32.83 140.91,32.83 140.83,32.91 140.83,33.64 140.91,33.72 141.17,33.72 141.25,33.81 141.25,33.98 141.17,34.06 140.91,34.06 140.83,34.14 140.83,34.62 140.48,34.97 140.48,35.9 139.02,37.37 139.02,39.66 v1(139.43,40.07)
DDR4_COMP_CH1_DQ44: length 31.2
  L03_SIG1 w0.081: v1(143.41,41.45) 143.9,40.96 143.9,38.15 144.14,37.91 144.14,37.79 143.91,37.56 143.91,37.45 144.03,37.33 144.15,37.33 144.38,37.56 144.49,37.56 144.62,37.43 144.62,37.32 144.39,37.09 144.39,36.97 144.51,36.85 144.62,36.85 144.85,37.08 144.97,37.08 145.09,36.96 145.09,36.84 144.86,36.62 144.86,36.5 144.98,36.38 145.1,36.38 145.33,36.61 145.44,36.61 145.75,36.3 145.75,34.29 148.42,31.62 154.72,31.62 157.42,28.92 157.42,24.75 157.7,24.47 158.26,24.47 158.26,24.47 158.3,24.47 158.52,24.25 158.52,23.38 158.41,23.26 158.18,23.26 v5(158.15,23.3)
DDR4_COMP_CH1_DQ45: length 32.4
  L03_SIG1 w0.081: v5(154.15,24.1) 153.77,24.48 153.77,29.01 153.2,29.57 146.35,29.57 144.79,31.14 144.67,31.14 144.21,30.68 144.1,30.68 143.98,30.8 143.98,30.92 144.44,31.37 144.44,31.49 144.31,31.61 144.2,31.61 143.74,31.16 143.63,31.16 143.51,31.27 143.51,31.4 143.96,31.85 143.96,31.96 143.84,32.09 143.72,32.09 143.4,31.76 143.29,31.76 143.16,31.88 143.16,32 143.49,32.32 143.49,32.44 143.37,32.56 143.25,32.56 142.93,32.24 142.81,32.24 142.69,32.36 142.69,32.47 143.01,32.8 143.01,32.91 140.9,35.03 140.9,36.07 139.86,37.11 139.86,41.08 v1(140.23,41.45)
DDR4_COMP_CH1_DQ46: length 31.1
  L03_SIG1 w0.081: v5(158.15,24.9) 157.76,25.29 157.76,29.25 157.22,29.79 157.22,29.9 157.35,30.03 157.35,30.15 157.23,30.27 157.11,30.27 156.98,30.14 156.87,30.14 156.61,30.39 156.61,30.51 157.06,30.96 157.06,31.12 156.94,31.25 156.79,31.25 156.34,30.8 156.21,30.8 156.06,30.95 156.06,31.06 156.52,31.52 156.52,31.63 156.38,31.77 156.24,31.77 155.8,31.32 155.68,31.32 155.06,31.95 148.56,31.95 146.09,34.43 146.09,36.44 144.23,38.29 144.23,41.15 143.49,41.89 142.63,41.89 v1(142.62,41.91)
DDR4_COMP_CH1_DQ47: length 32.9
  L03_SIG1 w0.081: v5(154.95,22.5) 154.58,22.87 153.51,22.87 153.5,22.87 152.81,22.87 152.07,23.61 152.07,28.21 151.79,28.49 143.71,28.49 143.56,28.64 143.56,29.32 143.32,29.56 143.32,30.33 142.07,31.57 141.7,31.57 141.39,31.89 141.39,31.96 141.31,32.03 141.24,32.03 140.93,32.35 140.93,32.42 140.86,32.49 140.77,32.49 140.49,32.77 140.49,32.86 140.48,32.87 140.48,34.18 139.69,34.97 139.69,36.11 138.25,37.55 138.25,40.73 v1(139.43,41.91)
DDR4_COMP_CH1_DQ48: length 46.4
  TOP w0.149: U9.J7 v1(147.62,22.7)
  L14_SIG5 w0.081: v1(135.44,39.61) 135.87,39.18 135.87,38.99 136.09,38.78 136.28,38.78 136.91,38.14 137.2,38.14 137.97,37.37 137.97,34.84 138.25,34.56 143.02,34.56 147.24,30.35 149.79,30.35 150.11,30.02 150.11,29.6 150.19,29.52 150.5,29.52 150.58,29.44 150.58,29.26 150.5,29.18 150.19,29.18 150.11,29.1 150.11,28.93 150.19,28.85 150.5,28.85 150.58,28.76 150.58,28.59 150.5,28.51 150.19,28.51 150.11,28.43 150.11,28.22 150.11,28.22 150.11,27.91 150.11,27.91 150.11,27.5 150.19,27.41 150.43,27.41 150.51,27.33 150.51,27.16 150.43,27.08 150.19,27.08 150.11,27 150.11,26.82 150.19,26.74 150.38,26.74 150.46,26.66 150.46,26.49 150.38,26.41 150.19,26.41 150.11,26.33 150.11,24.32 150.92,23.5 151.65,23.5 152.13,23.02 152.13,22.3 152.58,21.85 152.58,21 152.3,20.72 150.28,20.72 149.98,21.02 149.98,21.82 149.7,22.09 149.43,22.09 149.22,22.31 149.22,22.58 148.96,22.83 148.08,22.83 147.98,22.73 147.98,22.24 148.12,22.09 148.63,22.09 148.63,22.09 148.9,22.09 149.16,21.83 149.16,21.48 148.97,21.29 148.52,21.29 148.42,21.19 148.42,20.8 148.33,20.72 148.16,20.72 148.08,20.8 148.08,21.21 148,21.29 147.61,21.29 147.44,21.46 147.44,22.53 v1(147.62,22.7)
DDR4_COMP_CH1_DQ49: length 48.7
  L14_SIG5 w0.081: v1(132.26,39.61) 132.45,39.42 132.45,39.02 132.63,38.84 132.63,37.92 132.63,37.61 130.55,35.53 130.55,30.43 130.97,30.01 133.43,30.01 133.6,30.17 133.9,30.17 134.15,29.92 135.01,29.92 135.09,29.84 135.09,28.46 135.18,28.38 135.35,28.38 135.43,28.46 135.43,29.74 135.51,29.82 135.68,29.82 135.76,29.74 135.76,28.46 135.85,28.38 136.02,28.38 136.1,28.46 136.1,29.77 136.18,29.85 136.35,29.85 136.44,29.77 136.44,27.64 136.52,27.56 136.67,27.56 136.77,27.66 136.77,29.44 136.85,29.52 142.68,29.52 142.76,29.44 142.76,29.26 142.68,29.18 141.01,29.18 140.93,29.1 140.93,28.93 141.01,28.85 142.68,28.85 142.76,28.77 142.76,28.59 142.68,28.51 141.01,28.51 140.93,28.43 140.93,28.26 141.01,28.18 142.68,28.18 142.76,28.09 142.76,27.92 142.68,27.84 141.97,27.84 141.89,27.76 141.89,25.35 141.97,25.27 142.34,25.27 142.42,25.19 142.42,24.97 142.5,24.89 142.68,24.89 142.76,24.97 142.76,25.19 142.84,25.27 144.27,25.27 144.38,25.16 144.38,24.16 144.29,24.06 v1(143.99,24.06)
DDR4_COMP_CH1_DQ50: length 47.7
  L14_SIG5 w0.081: v1(132.26,37.77) 130.22,35.72 130.22,30.29 130.83,29.67 133.3,29.67 133.56,29.41 134.09,29.41 134.2,29.3 134.2,25.12 134.4,24.92 135.1,24.92 135.18,25 135.18,27.37 135.26,27.45 135.43,27.45 135.51,27.36 135.51,25 135.6,24.92 135.9,24.92 136.01,24.81 136.01,23.99 136.1,23.9 136.52,23.9 136.63,24.01 136.63,27.02 136.72,27.1 136.88,27.1 136.97,27.01 136.97,23.63 137.06,23.54 137.22,23.54 137.3,23.62 137.3,26.11 137.41,26.22 137.54,26.22 137.64,26.13 137.64,24.63 137.83,24.43 139.85,24.43 139.93,24.51 139.93,25.1 140.01,25.18 140.18,25.18 140.27,25.1 140.27,24.51 140.4,24.38 141.48,24.38 141.56,24.3 141.56,23.58 141.65,23.49 141.82,23.49 141.9,23.57 141.9,24.27 142.06,24.43 143.47,24.43 143.56,24.34 143.56,23.97 143.83,23.69 144.36,23.69 v1(144.79,23.26)
DDR4_COMP_CH1_DQ51: length 45.9
  L14_SIG5 w0.081: v1(135.45,37.77) 136.28,37.77 136.42,37.62 136.42,33.56 136.51,33.47 137.49,33.47 137.57,33.55 137.57,34.18 137.65,34.26 137.82,34.26 137.9,34.18 137.9,33.54 137.98,33.46 138.16,33.46 138.24,33.54 138.24,34.04 138.32,34.12 138.49,34.12 138.57,34.04 138.57,33.54 138.65,33.46 140.22,33.46 140.3,33.54 140.3,34.12 140.39,34.2 140.56,34.2 140.64,34.12 140.64,33.54 140.72,33.46 140.89,33.46 140.97,33.54 140.97,34.12 141.06,34.2 141.23,34.2 141.31,34.12 141.31,33.54 141.39,33.46 141.56,33.46 141.65,33.54 141.65,34.12 141.73,34.2 141.9,34.2 141.98,34.12 141.98,33.54 142.06,33.46 143.64,33.46 147.53,29.57 147.87,29.57 147.95,29.65 147.95,29.93 148.03,30.01 148.2,30.01 148.28,29.93 148.28,29.65 148.36,29.57 149.03,29.57 149.16,29.44 149.16,23.84 149.3,23.69 150.26,23.69 150.79,23.17 151.51,23.17 151.8,22.88 151.8,22.16 152.24,21.72 152.24,21.13 152.16,21.05 151.25,21.05 151.17,21.13 151.17,21.32 151.25,21.4 151.6,21.4 151.68,21.48 151.68,21.63 151.58,21.73 151.25,21.73 151.17,21.81 151.17,22.43 151.09,22.51 150.91,22.51 150.83,22.43 150.83,21.13 150.75,21.05 150.42,21.05 150.31,21.16 150.31,21.96 149.96,22.31 149.96,22.77 149.84,22.89 149.43,22.89 149.06,23.26 v1(148.79,23.26)
DDR4_COMP_CH1_DQ52: length 48.1
  L14_SIG5 w0.081: v1(144.79,22.46) 144.79,22.18 144.64,22.04 141.26,22.04 141.18,21.96 141.18,21.44 141.1,21.35 140.93,21.35 140.85,21.44 140.85,21.96 140.76,22.04 132.03,22.04 131.55,22.52 131.55,23.01 131.63,23.09 132.9,23.09 132.98,23.17 132.98,23.34 132.9,23.42 131.63,23.42 131.55,23.5 131.55,24.26 131.63,24.34 132.54,24.34 132.62,24.42 132.62,24.59 132.54,24.67 131.63,24.67 131.55,24.75 131.55,24.93 131.63,25.01 132.54,25.01 132.62,25.09 132.62,25.26 132.54,25.34 131.63,25.34 131.55,25.42 131.55,25.6 131.63,25.68 132.54,25.68 132.62,25.76 132.62,25.93 132.54,26.01 131.63,26.01 131.55,26.09 131.55,26.27 131.63,26.35 132.54,26.35 132.62,26.43 132.62,26.6 132.54,26.68 131.63,26.68 131.55,26.76 131.55,27.91 131.63,28 132.51,28 132.6,28.08 132.6,28.25 132.51,28.33 130.9,28.33 130.82,28.41 130.82,28.56 130.92,28.67 132.22,28.67 132.3,28.75 132.3,28.92 132.22,29 130.55,29 129.54,30.01 129.54,36.1 131.03,37.59 131.03,37.8 v1(131.46,38.23)
DDR4_COMP_CH1_DQ53: length 46.4
  L14_SIG5 w0.081: v1(147.99,24.86) 147.99,25.88 147.84,26.03 147.22,26.03 147.14,26.12 147.14,26.61 147.22,26.69 147.55,26.69 147.63,26.77 147.63,26.95 147.55,27.03 147.22,27.03 147.14,27.11 147.14,27.44 147.08,27.5 147.08,29 147.01,29.08 147.01,29.09 143.37,32.73 142.28,32.73 142.2,32.65 142.2,32.16 142.12,32.08 141.95,32.08 141.86,32.16 141.86,32.65 141.78,32.73 141.61,32.73 141.53,32.65 141.53,32.16 141.45,32.08 141.28,32.08 141.19,32.16 141.19,32.65 141.11,32.73 140.94,32.73 140.86,32.65 140.86,32.16 140.78,32.08 140.61,32.08 140.52,32.16 140.52,32.65 140.44,32.73 140.27,32.73 140.19,32.65 140.19,32.16 140.11,32.08 139.77,32.08 139.69,32.16 139.69,32.71 139.61,32.79 139.44,32.79 139.36,32.71 139.36,32.16 139.27,32.08 139.1,32.08 139.02,32.16 139.02,32.71 138.94,32.79 138.77,32.79 138.68,32.71 138.68,32.16 138.6,32.08 138.43,32.08 138.35,32.16 138.35,32.71 138.27,32.79 138.1,32.79 138.01,32.71 138.01,32.16 137.93,32.08 137.76,32.08 137.68,32.16 137.68,32.71 137.6,32.79 137.43,32.79 137.34,32.71 137.34,32.16 137.26,32.08 137.09,32.08 137.01,32.16 137.01,32.71 136.93,32.79 136.75,32.79 136.67,32.71 136.67,32.16 136.59,32.08 136.42,32.08 136.34,32.16 136.34,32.71 136.26,32.79 136.08,32.79 136,32.71 136,32.16 135.92,32.08 135.75,32.08 135.67,32.16 135.67,32.71 135.59,32.79 135.41,32.79 135.33,32.71 135.33,32.16 135.25,32.08 135.08,32.08 135,32.16 135,32.71 134.92,32.79 134.74,32.79 134.66,32.71 134.66,32.16 134.58,32.08 134.09,32.08 134.01,32.16 134.01,32.37 133.93,32.45 133.75,32.45 133.67,32.37 133.67,32.16 133.59,32.08 133.14,32.08 133.02,32.2 133.02,32.78 133.1,32.86 133.57,32.86 133.65,32.94 133.65,33.12 133.57,33.2 133.1,33.2 133.02,33.28 133.02,33.45 133.1,33.53 133.57,33.53 133.65,33.61 133.65,33.79 133.57,33.87 133.1,33.87 133.02,33.95 133.02,34.12 133.1,34.2 133.57,34.2 133.65,34.29 133.65,34.46 133.57,34.54 133.1,34.54 133.02,34.62 133.02,34.79 133.1,34.87 133.57,34.87 133.65,34.96 133.65,35.32 133.79,35.46 134.31,35.46 134.77,35.92 134.77,36.53 134.53,36.78 134.53,38.07 v1(134.68,38.22)
DDR4_COMP_CH1_DQ54: length 48.8
  L14_SIG5 w0.081: v1(143.99,23.26) 143.71,23.26 143.34,23.63 142.93,23.63 142.47,23.17 141.95,23.17 141.87,23.09 141.87,22.46 141.79,22.38 141.62,22.38 141.54,22.46 141.54,23.09 141.46,23.17 141.28,23.17 141.2,23.09 141.2,22.46 141.12,22.38 140.95,22.38 140.87,22.46 140.87,23.3 140.73,23.43 139.9,23.43 139.8,23.33 139.8,22.97 139.72,22.89 139.16,22.89 139.06,23 139.06,23.47 138.92,23.61 138.01,23.61 137.87,23.47 137.87,22.46 137.79,22.38 137.62,22.38 137.54,22.46 137.54,23.09 137.46,23.17 137.29,23.17 137.2,23.09 137.2,22.46 137.12,22.38 136.95,22.38 136.87,22.46 136.87,23.09 136.4,23.56 136.06,23.56 135.81,23.31 135.81,22.54 135.68,22.41 135.21,22.41 135.12,22.49 135.12,23.67 135.21,23.75 135.59,23.75 135.68,23.83 135.68,24 135.59,24.08 135.21,24.08 135.12,24.17 135.12,24.5 135.04,24.58 134.87,24.58 134.79,24.5 134.79,22.48 134.69,22.38 134.54,22.38 134.45,22.46 134.45,24.5 134.37,24.58 134.2,24.58 134.12,24.5 134.12,22.95 134.03,22.86 133.48,22.86 133.4,22.94 133.4,23.83 133.48,23.92 133.7,23.92 133.78,24 133.78,24.17 133.7,24.25 133.48,24.25 133.4,24.33 133.4,29.1 133.16,29.34 130.69,29.34 129.88,30.15 129.88,35.96 131.83,37.91 131.83,38.78 v1(131.46,39.15)
DDR4_COMP_CH1_DQ55: length 45.7
  L14_SIG5 w0.081: v1(134.67,39.13) 134.54,39.13 134.33,38.92 134.33,38.68 134.42,38.6 134.83,38.6 135.05,38.38 135.05,38.07 134.86,37.89 134.86,36.91 135.11,36.67 135.11,35.34 134.87,35.1 134.07,35.1 133.99,35.02 133.99,34.68 134.07,34.6 135.03,34.6 135.11,34.52 135.11,34.36 135.02,34.27 134.07,34.27 133.99,34.19 133.99,33.03 134.1,32.92 134.35,32.92 134.46,33.03 134.46,33.85 134.54,33.93 134.92,33.93 135,33.85 135,33.21 135.08,33.13 135.37,33.13 135.46,33.21 135.46,37.2 135.54,37.28 135.68,37.28 135.79,37.18 135.79,36.74 135.87,36.66 136.01,36.66 136.09,36.58 136.09,36.41 136.01,36.33 135.87,36.33 135.79,36.25 135.79,36.07 135.87,35.99 136.01,35.99 136.09,35.91 136.09,35.74 136.01,35.66 135.87,35.66 135.79,35.57 135.79,35.4 135.87,35.32 136.01,35.32 136.09,35.24 136.09,35.07 136.01,34.99 135.87,34.99 135.79,34.9 135.79,34.73 135.87,34.65 136.01,34.65 136.09,34.57 136.09,34.4 136.01,34.32 135.87,34.32 135.79,34.23 135.79,34.06 135.87,33.98 136.01,33.98 136.09,33.9 136.09,33.73 136.01,33.64 135.87,33.64 135.79,33.56 135.79,33.21 135.87,33.13 143.5,33.13 147.39,29.23 148.2,29.23 148.36,29.08 148.36,28.74 148.28,28.66 147.91,28.66 147.83,28.58 147.83,28.41 147.91,28.33 148.28,28.33 148.36,28.25 148.36,28.07 148.28,27.99 147.91,27.99 147.83,27.91 147.83,27.74 147.91,27.66 148.28,27.66 148.36,27.58 148.36,23.34 148.28,23.26 v1(147.99,23.26)
DDR4_COMP_CH1_DQ56: length 45.8
  L16_SIG6 w0.081: v1(118.71,46.51) 117.85,46.51 117.3,45.96 116.96,45.96 116.5,45.5 116.17,45.5 115.71,45.04 115.16,45.04 114.88,44.76 114.71,44.76 114.3,44.35 114.3,36.6 116.31,34.6 116.68,34.6 117.2,34.07 117.2,31.5 117.86,30.84 117.86,19.97 118.04,19.79 122.18,19.79 122.5,20.1 122.5,21.02 122.71,21.23 123.02,21.23 123.3,21.51 123.3,21.82 123.51,22.03 123.79,22.03 124.05,22.29 124.05,22.67 123.87,22.85 123.71,22.85 123.63,22.93 123.63,23.1 123.71,23.18 124,23.18 124.09,23.26 124.09,23.44 124,23.52 123.71,23.52 123.63,23.6 123.63,23.77 123.71,23.85 124,23.85 124.09,23.94 124.09,24.1 124,24.19 123.71,24.19 123.63,24.27 123.63,24.38 123.71,24.47 124,24.47 124.09,24.55 124.09,26.08 v1(124.47,26.46)
DDR4_COMP_CH1_DQ57: length 47.9
  L16_SIG6 w0.081: v1(124.47,27.26) 124.77,27.26 124.92,27.11 124.92,26.1 125,26.02 126.43,26.02 126.56,26.15 126.56,27.69 126.48,27.77 126.17,27.77 126.08,27.86 126.08,28.03 126.17,28.11 126.48,28.11 126.56,28.19 126.56,29.17 126.48,29.25 126.14,29.25 126.06,29.17 126.06,28.9 125.98,28.82 125.8,28.82 125.71,28.91 125.71,29.17 125.63,29.25 123.54,29.25 123.53,29.26 122.57,29.26 122.46,29.15 122.46,28.8 121.32,27.65 121.32,22.67 121.23,22.59 119.42,22.59 119.34,22.67 119.34,26.66 119.75,27.07 119.75,28.48 119.34,28.89 119.34,31.77 119.93,32.36 119.93,32.71 119.68,32.96 119.68,33.2 119.9,33.42 119.9,33.75 119.56,34.09 119.56,34.22 118.56,35.22 117.97,35.22 117.17,36.01 117.17,37.76 117.49,38.07 117.49,38.38 117.27,38.6 117.27,38.78 117.49,38.99 117.49,39.3 117.27,39.52 117.27,39.7 117.49,39.91 117.49,40.22 117.27,40.44 117.27,40.62 117.49,40.83 117.49,41.14 117.27,41.36 117.27,41.54 117.49,41.75 117.49,42.06 117.27,42.28 117.27,42.46 117.73,42.92 118.07,42.92 118.29,43.13 118.29,43.29 118.37,43.38 118.87,43.38 119.08,43.59 119.08,44.34 119.51,44.77 v1(119.51,45.13)
DDR4_COMP_CH1_DQ58: length 47.9
  L16_SIG6 w0.081: v1(122.7,46.05) 122.95,46.05 123.12,46.21 123.12,46.51 123.04,46.6 122.38,46.6 122.28,46.5 122.28,45.22 122.1,45.04 121.95,45.04 121.95,45.04 121.75,45.04 121.53,44.82 121.53,44.51 121.75,44.3 121.75,44.12 121.47,43.84 121.47,43.65 121.75,43.38 121.75,43.2 121.53,42.98 121.53,42.16 121.38,42.01 120.98,42.01 120.5,41.52 120.44,41.52 120.43,41.51 120.1,41.51 119.73,41.14 119.73,40.83 119.92,40.64 119.92,37.82 120,37.74 120.64,37.74 120.73,37.66 120.73,37.49 120.64,37.41 119.85,37.41 119.7,37.26 119.7,36.53 120.16,36.07 120.28,36.07 120.58,36.37 120.58,36.49 120.31,36.75 120.31,36.87 120.44,36.99 120.55,36.99 120.82,36.73 120.93,36.73 121.57,37.37 121.69,37.37 121.81,37.24 121.81,37.13 120.51,35.83 120.51,35.72 120.63,35.6 120.75,35.6 121.26,36.1 121.37,36.1 121.49,35.98 121.49,35.87 120.99,35.36 120.99,35.24 121.39,34.84 121.39,34.23 121.47,34.15 122.62,34.15 122.7,34.07 122.7,33.12 122.54,32.96 121.47,32.96 121.39,32.88 121.39,32.66 121.47,32.58 121.74,32.58 121.84,32.48 121.84,32.31 121.76,32.23 121.47,32.23 121.39,32.15 121.39,31.84 121.48,31.75 123.13,31.75 123.21,31.83 123.21,32.35 123.3,32.43 123.54,32.43 123.62,32.51 123.62,32.67 123.53,32.76 123.2,32.76 123.12,32.85 123.12,33.02 123.2,33.1 123.7,33.1 123.78,33.18 123.78,33.3 123.64,33.43 123.2,33.43 123.12,33.52 123.12,33.69 123.2,33.77 123.56,33.77 123.64,33.85 123.64,34.02 123.56,34.1 123.2,34.1 123.12,34.19 123.12,34.4 123.2,34.48 124.74,34.48 124.89,34.33 arc(125.2,34.13) 125.57,34.03 arc(125.62,34.03) 125.67,34.02 arc(126.5,33.74) 127.28,33.35 arc(127.31,33.32) 127.34,33.3 128.25,32.39 arc(128.72,31.69) 128.88,30.86 128.88,28.71 128.47,28.29 v1(128.47,28.06)
DDR4_COMP_CH1_DQ59: length 47.5
  L16_SIG6 w0.081: v1(121.9,44.67) 122.32,44.25 122.32,41.6 122.32,40.69 122.19,40.56 121.8,40.56 121.46,40.9 120.77,40.9 120.59,40.71 120.59,40.3 120.68,40.22 120.68,40.21 120.91,39.98 121.26,39.98 121.65,39.58 122.22,39.58 122.32,39.48 122.32,38.84 122.32,38.76 122.23,38.66 121.65,38.66 121.14,39.18 120.9,39.18 120.52,38.79 120.52,38.63 120.84,38.32 121.28,38.32 121.8,37.8 122.13,37.8 122.54,37.4 122.94,37.4 123.22,37.12 123.22,36.74 123.3,36.66 123.71,36.66 123.79,36.57 123.79,36.4 123.71,36.32 122.8,36.32 122.72,36.4 122.72,36.98 122.64,37.06 122.47,37.06 122.39,36.98 122.39,36.4 122.31,36.32 121.92,36.32 121.84,36.24 121.84,36.07 121.92,35.99 124.17,35.99 124.26,35.9 124.26,35.73 124.18,35.65 121.75,35.65 121.64,35.54 121.64,35.4 121.72,35.31 122.17,35.31 122.25,35.23 122.25,34.77 122.33,34.69 122.5,34.69 122.59,34.77 122.59,35.23 122.67,35.31 122.84,35.31 122.92,35.23 122.92,34.9 123,34.82 123.18,34.82 123.26,34.9 123.26,35.23 123.34,35.31 123.51,35.31 123.59,35.23 123.59,34.9 123.67,34.82 123.85,34.82 123.93,34.9 123.93,35.23 124.01,35.31 124.38,35.31 125,34.7 arc(125.33,34.46) 125.73,34.37 arc(125.8,34.36) 125.87,34.34 arc(126.7,34.04) 127.51,33.66 arc(127.54,33.64) 127.57,33.61 128.37,32.81 arc(129.06,31.78) 129.3,30.57 129.3,29.35 129.64,29.02 129.64,28.59 129.53,28.49 129.14,28.49 128.9,28.24 128.9,27.71 128.98,27.63 129.59,27.63 129.7,27.52 129.7,26.95 129.59,26.83 129.01,26.83 128.9,26.72 128.9,26.29 128.64,26.03 128.18,26.03 128.07,26.14 128.07,27.6 128.18,27.7 128.39,27.7 128.47,27.62 v1(128.47,27.26)
DDR4_COMP_CH1_DQ60: length 48.1
  L16_SIG6 w0.081: v1(127.67,27.26) 127.37,27.26 127.27,27.16 127.27,25.88 127.19,25.8 126.98,25.8 126.9,25.88 126.9,27.61 126.98,27.7 127.6,27.7 127.7,27.79 127.7,27.95 127.61,28.03 126.98,28.03 126.9,28.11 126.9,29.42 126.74,29.58 123.68,29.58 123.18,30.08 122.29,30.08 122.01,29.81 122.01,28.82 120.98,27.79 120.98,23.07 120.9,22.99 119.76,22.99 119.68,23.07 119.68,26.53 120.09,26.93 120.09,28.62 119.68,29.03 119.68,31.63 120.26,32.22 120.26,32.85 120.24,32.87 120.24,34.01 118.73,35.52 118.73,35.88 118.34,36.28 118.34,38.07 118.34,38.99 118.34,39.91 118.34,40.83 118.34,41.75 118.34,42.37 118.42,42.46 118.87,42.46 119.17,42.76 119.51,42.76 119.88,43.13 119.88,44.36 119.84,44.4 119.84,44.84 120.13,45.12 120.43,45.12 120.95,45.64 121.35,45.64 121.9,46.2 v1(121.9,46.51)
DDR4_COMP_CH1_DQ61: length 46
  L16_SIG6 w0.081: v1(123.67,27.26) 123.86,27.26 123.95,27.34 123.95,27.53 123.79,27.69 122.67,27.69 122.5,27.52 122.5,22.35 122.06,21.91 122.06,21.55 121.63,21.13 121.46,21.13 121.38,21.05 121.38,20.5 121.33,20.46 121.1,20.46 121.04,20.51 121.04,21.19 120.94,21.3 120.22,21.3 120.04,21.12 120.04,20.54 119.96,20.46 119.78,20.46 119.7,20.54 119.7,21.05 119.62,21.13 119.45,21.13 119.37,21.05 119.37,20.54 119.29,20.46 119.11,20.46 119.03,20.54 119.03,21.05 118.95,21.13 118.61,21.13 118.53,21.21 118.53,31.87 118.67,32.01 118.67,32.85 118.46,33.05 118.46,33.22 118.67,33.42 118.67,34.16 118.28,34.55 117.67,34.55 116.95,35.27 116.62,35.27 115.9,35.99 115.9,36.36 115.82,36.45 115.57,36.45 115.49,36.53 115.49,36.7 115.57,36.78 115.82,36.78 115.9,36.86 115.9,37.04 115.82,37.12 115.57,37.12 115.49,37.2 115.49,37.37 115.57,37.45 115.82,37.45 115.9,37.53 115.9,43.49 116.25,43.84 116.47,43.84 116.76,44.12 117.24,44.12 117.85,44.73 118.09,44.73 118.52,45.16 118.84,45.16 119.19,45.51 119.19,45.73 v1(119.51,46.05)
DDR4_COMP_CH1_DQ62: length 47.5
  L16_SIG6 w0.081: v1(127.67,26.46) 127.67,25.08 127.3,24.71 126.98,24.71 126.83,24.85 126.83,25.37 126.75,25.45 126.58,25.45 126.5,25.37 126.5,24.89 126.33,24.73 125.54,24.73 125.41,24.85 125.41,25.61 125.33,25.69 125.16,25.69 125.08,25.61 125.08,24.85 124.99,24.77 124.55,24.77 124.42,24.65 124.42,24.31 124.5,24.23 124.63,24.23 124.71,24.15 124.71,23.98 124.63,23.9 124.5,23.9 124.42,23.82 124.42,23.64 124.5,23.56 124.63,23.56 124.71,23.48 124.71,23.31 124.63,23.23 124.5,23.23 124.42,23.15 124.42,22.64 124.55,22.51 124.89,22.51 125.05,22.67 125.05,24.03 125.38,24.37 127.45,24.37 128.31,25.23 128.56,25.23 128.9,25.57 128.9,25.82 129.11,26.03 129.57,26.03 129.85,26.31 130.04,26.77 130.04,27.66 129.79,27.91 129.79,28.22 130.04,28.47 130.04,29.09 129.82,29.3 129.82,30.26 129.82,30.27 129.82,30.97 arc(129.51,32.5) 128.65,33.79 127.54,34.9 arc(127.19,35.13) 126.78,35.21 125.94,35.21 arc(125.76,35.22) 125.57,35.24 arc(125.53,35.26) 125.5,35.29 125.23,35.31 arc(125.19,35.32) 125.16,35.35 124.89,35.66 arc(124.87,35.7) 124.86,35.74 124.88,36.02 124.91,36.05 124.91,36.42 124.85,36.48 124.72,36.61 124.27,36.61 123.69,37.19 123.69,37.31 123.92,37.54 123.92,37.66 123.8,37.78 123.69,37.78 123.45,37.54 123.27,37.54 123.09,37.72 123.09,44.82 123.34,45.06 123.7,45.06 124.17,45.53 124.39,45.53 124.81,45.96 124.81,46.23 124.5,46.54 124.12,46.54 123.54,45.96 123.34,45.96 123.12,45.74 123.12,45.54 122.71,45.13 v1(122.7,45.13)
DDR4_COMP_CH1_DQ63: length 47.7
  L16_SIG6 w0.081: v1(124.47,28.86) 125.19,28.86 125.35,28.7 125.35,28.46 125,28.11 125,27.8 124.89,27.68 124.3,27.68 124.05,27.94 124.05,28.3 123.89,28.46 122.6,28.46 121.65,27.51 121.65,26.87 121.73,26.79 122.08,26.79 122.16,26.71 122.16,26.54 122.08,26.46 121.73,26.46 121.65,26.38 121.65,26.2 121.73,26.12 122.08,26.12 122.16,26.04 122.16,25.87 122.08,25.79 121.73,25.79 121.65,25.71 121.65,25.53 121.73,25.45 122.08,25.45 122.16,25.37 122.16,25.2 122.08,25.12 121.73,25.12 121.65,25.04 121.65,24.86 121.73,24.78 122.08,24.78 122.16,24.7 122.16,24.53 122.08,24.45 121.73,24.45 121.65,24.36 121.65,23.56 121.73,23.48 122.08,23.48 122.16,23.4 122.16,23.23 122.08,23.14 121.73,23.14 121.65,23.06 121.65,21.72 121.57,21.64 120.73,21.64 120.65,21.72 120.65,22.11 120.57,22.19 120.39,22.19 120.31,22.11 120.31,21.73 120.23,21.65 120.06,21.65 119.98,21.73 119.98,22.11 119.9,22.19 119.72,22.19 119.64,22.11 119.64,21.56 119.56,21.48 119.39,21.48 119.3,21.57 119.3,22.24 119.01,22.54 119.01,26.8 119.41,27.21 119.41,28.34 119.01,28.75 119.01,31.91 119.09,31.99 119.09,32.71 119.35,32.97 119.35,33.18 119.11,33.42 119.11,33.75 119.22,33.86 119.22,34.08 118.42,34.88 117.83,34.88 116.7,36 116.7,38.83 116.47,39.06 116.47,39.24 116.69,39.45 116.69,39.76 116.47,39.98 116.47,40.16 116.69,40.37 116.69,40.68 116.47,40.9 116.47,41.08 116.69,41.29 116.69,41.6 116.47,41.82 116.47,42 116.69,42.21 116.69,42.93 116.96,43.2 117.24,43.2 117.88,43.84 118.07,43.84 118.29,44.05 118.29,44.24 v1(118.71,44.67)
DDR4_COMP_CH1_DQ64: length 60.3
  L14_SIG5 w0.081: v1(131.46,44.67) 131.89,45.09 131.89,45.28 132.1,45.5 132.34,45.5 132.93,46.08 133.46,46.08 133.85,46.47 134.16,46.47 134.55,46.08 136.89,46.08 138.34,44.63 139.25,44.63 139.65,44.23 140.54,44.23 140.78,44.47 141.08,44.47 141.46,44.09 142.13,44.09 142.51,44.47 142.82,44.47 143.19,44.09 143.56,44.09 143.93,43.72 145.92,43.72 146.24,43.4 146.24,42.04 146.49,41.79 147.02,41.79 147.1,41.87 147.1,42.38 147.18,42.46 147.36,42.46 147.44,42.38 147.44,41.87 147.52,41.79 147.69,41.79 147.77,41.87 147.77,42.38 147.86,42.46 148.03,42.46 148.11,42.38 148.11,41.87 148.19,41.79 148.36,41.79 148.44,41.87 148.44,42.38 148.53,42.46 148.7,42.46 148.78,42.38 148.78,41.87 148.86,41.79 149.03,41.79 149.12,41.87 149.12,42.38 149.2,42.46 149.37,42.46 149.45,42.38 149.45,41.87 149.53,41.79 149.7,41.79 149.79,41.87 149.79,42.38 149.84,42.43 150.07,42.43 150.12,42.38 150.12,41.87 150.2,41.79 150.37,41.79 150.46,41.87 150.46,42.38 150.54,42.46 150.71,42.46 150.79,42.38 150.79,41.87 150.87,41.79 151.05,41.79 151.13,41.87 151.13,42.38 151.21,42.46 151.38,42.46 151.46,42.38 151.46,41.87 151.54,41.79 151.72,41.79 151.8,41.87 151.8,42.74 151.88,42.82 152.04,42.82 152.13,42.73 152.13,41.87 152.21,41.79 153.24,41.79 153.48,41.56 153.6,41.56 153.84,41.8 153.95,41.8 154.07,41.68 154.07,41.56 153.83,41.32 153.83,41.2 153.96,41.08 154.07,41.08 154.31,41.32 154.43,41.32 154.55,41.2 154.55,41.09 154.31,40.85 154.31,40.73 154.43,40.61 154.54,40.61 154.79,40.85 154.9,40.85 155.02,40.73 155.02,40.61 154.78,40.37 154.78,40.26 154.9,40.13 155.02,40.13 155.26,40.38 155.38,40.38 155.5,40.25 155.5,40.14 155.26,39.9 155.26,39.78 155.38,39.66 155.49,39.66 155.73,39.9 155.85,39.9 155.97,39.78 155.97,39.66 155.73,39.42 155.73,39.31 155.85,39.19 155.97,39.19 156.21,39.43 156.32,39.43 156.45,39.3 156.45,39.19 156.2,38.95 156.2,38.83 156.33,38.71 156.44,38.71 156.68,38.95 156.8,38.95 156.92,38.83 156.92,38.72 156.68,38.47 156.68,38.36 156.8,38.24 156.92,38.24 157.16,38.48 157.27,38.48 157.39,38.36 157.39,38.24 157.15,38 157.15,37.89 157.27,37.76 157.39,37.76 157.63,38 157.75,38 157.87,37.88 157.87,37.77 157.63,37.53 157.63,37.41 157.75,37.29 157.86,37.29 158.11,37.53 158.22,37.53 158.34,37.41 158.34,37.29 158.1,37.05 158.1,36.94 158.48,36.56 158.48,35.44 158.48,31.08 159.33,30.23 159.33,28.49 v1(158.95,28.1)
DDR4_COMP_CH1_DQ65: length 60.7
  L14_SIG5 w0.081: v1(154.95,28.9) 155.13,28.72 155.13,28.55 155.05,28.47 152.53,28.47 152.45,28.55 152.45,29.02 152.36,29.1 152.19,29.1 152.11,29.02 152.11,28.41 152.03,28.33 151.69,28.33 151.61,28.41 151.61,29.35 151.7,29.44 153.92,29.44 154,29.52 154,29.69 153.92,29.77 151.83,29.77 151.75,29.86 151.75,30.03 151.83,30.11 154.01,30.11 154.09,30.19 154.09,30.33 153.98,30.44 151.83,30.44 151.75,30.53 151.75,30.7 151.83,30.78 155.06,30.78 155.15,30.86 155.15,31.01 155.04,31.12 151.83,31.12 151.6,31.34 147.85,31.34 143.24,35.95 141.98,35.95 141.9,36.03 141.9,36.64 141.82,36.72 141.65,36.72 141.56,36.63 141.56,36.03 141.48,35.95 141.31,35.95 141.21,36.05 141.21,36.97 141.29,37.06 141.82,37.06 141.9,37.14 141.9,37.31 141.82,37.39 141.29,37.39 141.12,37.57 141.12,38.69 141.56,39.13 141.56,39.36 141.28,39.63 140.82,39.63 140.35,39.16 139.94,39.16 139.51,39.59 139.2,39.59 138.74,40.06 138.41,40.06 138.26,40.21 138.26,40.37 138.26,41.08 137.96,41.39 137.62,41.39 137.19,41.82 135.66,41.82 135.22,41.38 134.91,41.38 134.41,41.87 133.73,41.87 133.32,41.47 132.76,41.47 132.41,41.82 132.09,41.82 131.76,41.49 131.28,41.49 130.8,41.97 130.45,41.97 130.04,42.38 129.75,42.38 129.4,42.74 129.07,42.74 128.43,43.38 128.07,43.38 127.88,43.56 127.88,44.28 v1(128.27,44.67)
DDR4_COMP_CH1_DQ66: length 59.9
  L14_SIG5 w0.081: v1(158.15,27.3) 158.56,27.71 158.56,29.87 158.14,30.28 158.14,32.88 158.06,32.96 157.75,32.96 157.66,33.05 157.66,33.22 157.75,33.3 158.06,33.3 158.14,33.38 158.14,33.55 158.06,33.63 157.75,33.63 157.66,33.72 157.66,33.89 157.75,33.97 158.06,33.97 158.14,34.05 158.14,34.22 158.06,34.3 157.75,34.3 157.66,34.39 157.66,34.56 157.75,34.64 158.06,34.64 158.14,34.72 158.14,35.3 158.14,36.05 157.68,36.51 157.57,36.51 157.35,36.3 157.24,36.3 157.12,36.42 157.12,36.54 157.33,36.75 157.33,36.87 157.21,36.99 157.09,36.99 156.88,36.77 156.76,36.77 156.64,36.9 156.64,37.01 156.85,37.23 156.85,37.34 156.73,37.46 156.62,37.46 156.4,37.25 156.29,37.25 156.17,37.37 156.17,37.49 156.38,37.7 156.38,37.81 156.26,37.94 156.14,37.94 155.93,37.72 155.81,37.72 155.69,37.84 155.69,37.96 155.91,38.17 155.91,38.29 155.78,38.41 155.67,38.41 155.46,38.2 155.34,38.2 155.22,38.32 155.22,38.43 155.43,38.65 155.43,38.76 155.31,38.89 155.2,38.89 154.98,38.67 154.87,38.67 154.74,38.79 154.74,38.91 154.96,39.12 154.96,39.24 154.84,39.36 154.72,39.36 154.51,39.15 154.39,39.15 154.27,39.27 154.27,39.38 154.48,39.6 154.48,39.71 153.54,40.65 151.68,40.65 151.59,40.73 151.59,41.35 151.51,41.43 151.34,41.43 151.26,41.35 151.26,40.73 151.18,40.65 151,40.65 150.92,40.73 150.92,41.35 150.84,41.43 150.67,41.43 150.59,41.35 150.59,40.73 150.51,40.65 150.33,40.65 150.25,40.73 150.25,41.35 150.17,41.43 150,41.43 149.92,41.35 149.92,40.73 149.84,40.65 149.66,40.65 149.58,40.73 149.58,41.35 149.5,41.43 149.33,41.43 149.25,41.35 149.25,40.73 149.17,40.65 148.99,40.65 148.91,40.73 148.91,41.35 148.83,41.43 148.66,41.43 148.58,41.35 148.58,40.73 148.5,40.65 148.32,40.65 148.24,40.73 148.24,41.35 148.16,41.43 147.99,41.43 147.91,41.35 147.91,40.73 147.82,40.65 147.65,40.65 147.57,40.73 147.57,41.35 147.49,41.43 147.32,41.43 147.24,41.35 147.24,40.73 147.15,40.65 146.98,40.65 146.9,40.73 146.9,41.35 146.82,41.43 146.65,41.43 146.57,41.35 146.57,40.73 146.48,40.65 146.04,40.65 145.89,40.8 145.89,42.96 145.69,43.17 143.44,43.17 142.9,43.7 142.42,43.7 141.95,43.23 141.64,43.23 141.28,43.59 140.59,43.59 140.22,43.23 139.87,43.23 139.37,43.73 138.72,43.73 138.7,43.74 138.7,43.75 138.49,43.97 138.48,43.97 137.42,45.02 136.63,45.02 136.02,45.64 135.53,45.64 134.97,45.08 134.72,45.08 134.21,45.6 133.81,45.6 133.35,45.13 v1(132.26,45.13)
DDR4_COMP_CH1_DQ67: length 60.1
  L14_SIG5 w0.081: v1(154.95,27.3) 154.95,27.57 154.84,27.68 153.05,27.68 152.93,27.56 152.93,27.13 152.44,26.64 152.44,24.57 152.3,24.43 151.95,24.43 151.28,25.1 151.28,25.53 151.36,25.61 152.03,25.61 152.11,25.69 152.11,25.86 152.03,25.94 151.36,25.94 151.28,26.03 151.28,26.2 151.36,26.28 152.03,26.28 152.11,26.36 152.11,26.53 152.03,26.61 151.36,26.61 151.28,26.7 151.28,26.87 151.36,26.95 152.03,26.95 152.11,27.03 152.11,27.2 152.03,27.29 151.36,27.29 151.28,27.37 151.28,27.54 151.36,27.62 152.08,27.62 152.16,27.7 152.16,27.85 152.06,27.96 151.36,27.96 151.28,28.04 151.28,30.75 151.02,31.01 147.71,31.01 143.1,35.62 140.95,35.62 140.78,35.79 140.78,36.26 140.7,36.34 139.48,36.34 139.4,36.42 139.4,36.59 139.48,36.68 140.7,36.68 140.78,36.76 140.78,36.93 140.7,37.01 139.48,37.01 139.4,37.09 139.4,37.27 139.48,37.35 140.57,37.35 140.65,37.43 140.65,38.23 140.56,38.32 140.07,38.32 139.62,38.76 139.17,38.76 138.7,39.24 138.39,39.24 137.93,39.7 137.68,39.7 137.44,39.94 137.44,40.77 137.31,40.91 136.83,40.91 136.44,40.52 136.18,40.52 135.73,40.97 135.16,40.97 134.8,40.62 134.49,40.62 134.08,41.03 133.62,41.03 133.41,40.82 133.41,40.82 133.19,40.6 132.89,40.6 132.67,40.82 132.67,40.84 132.54,40.97 132.01,40.97 131.65,40.62 131.31,40.62 130.95,40.97 130.56,40.97 130,41.54 129.71,41.54 129.43,41.82 128.96,41.82 128.32,42.46 127.94,42.46 127.48,42.92 127.32,42.92 127.08,43.16 127.08,44.33 127.32,44.58 127.48,44.58 128.12,45.22 128.43,45.22 128.64,45.43 128.64,45.62 v1(129.07,46.05)
DDR4_COMP_CH1_DQ68: length 60
  L14_SIG5 w0.081: v1(128.27,46.51) 128.7,46.93 128.7,47.16 128.88,47.34 129.27,47.34 129.69,46.91 130.03,46.91 130.51,47.39 130.87,47.39 131.24,47.03 131.7,47.03 132.06,47.38 132.34,47.38 132.86,47.91 133.29,47.91 133.85,48.47 134.3,48.47 134.8,47.97 136.75,47.97 137.3,47.42 137.3,47.39 138.22,46.47 139.35,46.47 139.74,46.08 140.24,46.08 140.63,46.47 141.08,46.47 141.4,46.15 142.2,46.15 142.51,46.47 142.82,46.47 143.21,46.07 143.9,46.07 144.24,45.73 151.05,45.73 160.2,36.57 160.2,35.96 160.29,35.88 161.07,35.88 161.15,35.8 161.15,35.63 161.07,35.54 160.29,35.54 160.2,35.46 160.2,35.29 160.29,35.21 161.07,35.21 161.15,35.13 161.15,34.96 161.07,34.87 160.29,34.87 160.2,34.79 160.2,34.62 160.29,34.54 161.07,34.54 161.15,34.46 161.15,34.29 161.07,34.2 160.29,34.2 160.2,34.12 160.2,33.95 160.29,33.87 161.07,33.87 161.15,33.79 161.15,33.61 161.07,33.53 160.29,33.53 160.2,33.45 160.2,33.28 160.29,33.2 161.07,33.2 161.15,33.12 161.15,32.94 161.07,32.86 160.29,32.86 160.2,32.78 160.2,32.18 161.01,31.38 161.01,27.83 160.07,26.89 158.54,26.89 v1(158.15,26.5)
DDR4_COMP_CH1_DQ69: length 61.1
  L14_SIG5 w0.081: v1(154.95,26.5) 154.68,26.5 154.56,26.38 154.56,24.4 155.22,23.75 155.22,22.62 155.37,22.47 156.04,22.47 156.19,22.62 156.19,24.55 156.08,24.67 155.32,24.67 155.22,24.77 155.22,25.08 155.3,25.16 156.09,25.16 156.17,25.25 156.17,25.42 156.09,25.5 155.56,25.5 155.48,25.58 155.48,25.75 155.56,25.84 156.09,25.84 156.17,25.92 156.17,26.09 156.09,26.17 155.56,26.17 155.48,26.25 155.48,26.42 155.56,26.51 156.09,26.51 156.17,26.59 156.17,26.76 156.09,26.84 155.56,26.84 155.48,26.92 155.48,27.1 155.56,27.18 156.09,27.18 156.17,27.26 156.17,27.43 156.09,27.51 155.56,27.51 155.48,27.59 155.48,28.52 155.56,28.6 155.94,28.6 156.02,28.68 156.02,28.86 155.94,28.94 155.56,28.94 155.48,29.02 155.48,29.19 155.56,29.27 155.94,29.27 156.02,29.36 156.02,29.53 155.94,29.61 154.46,29.61 154.38,29.69 154.38,29.86 154.46,29.94 155.94,29.94 156.02,30.03 156.02,30.2 155.94,30.28 155.58,30.28 155.5,30.36 155.5,30.63 155.49,30.64 155.49,31.09 155.5,31.1 155.5,31.36 155.4,31.46 151.95,31.46 151.74,31.68 147.99,31.68 143.38,36.29 142.88,36.29 142.23,36.93 142.23,39.87 141.95,40.16 141.46,40.16 141.18,40.44 140.87,40.44 140.59,40.16 140,40.16 139.54,40.62 139.2,40.62 138.1,41.72 137.76,41.72 137.26,42.23 136.04,42.23 135.24,43.03 134.55,43.03 133.95,42.43 132.86,42.43 132.53,42.75 132.05,42.75 131.64,42.34 131.25,42.34 130.68,42.92 130.51,42.92 130.12,43.3 129.76,43.3 129.22,43.84 128.83,43.84 128.7,43.96 128.7,44.76 v1(129.08,45.14)
DDR4_COMP_CH1_DQ70: length 57.4
  L14_SIG5 w0.081: v1(158.95,27.3) 159.32,27.67 160.05,27.67 160.16,27.78 160.16,30.33 159.13,31.36 159.13,31.73 159.24,31.85 159.78,31.85 159.86,31.93 159.86,32.1 159.78,32.19 159.24,32.19 159.16,32.27 159.16,32.6 159.24,32.68 159.77,32.68 159.85,32.76 159.85,32.94 159.77,33.02 159.24,33.02 159.16,33.1 159.16,33.27 159.24,33.35 159.77,33.35 159.85,33.44 159.85,33.61 159.77,33.69 159.24,33.69 159.16,33.77 159.16,33.94 159.24,34.02 159.77,34.02 159.85,34.11 159.85,34.28 159.77,34.36 159.24,34.36 159.16,34.44 159.16,34.61 159.24,34.69 159.77,34.69 159.85,34.78 159.85,34.95 159.77,35.03 159.24,35.03 159.16,35.11 159.16,35.28 159.24,35.37 159.77,35.37 159.85,35.45 159.85,35.62 159.77,35.7 159.24,35.7 159.16,35.78 159.16,35.95 159.24,36.04 159.77,36.04 159.85,36.12 159.85,36.29 159.77,36.37 159.24,36.37 159.16,36.45 159.16,37.06 152.68,43.54 151.26,43.54 151.18,43.62 151.18,43.93 151.1,44.02 150.93,44.02 150.84,43.93 150.84,43.62 150.76,43.54 150.59,43.54 150.51,43.62 150.51,43.93 150.43,44.02 150.26,44.02 150.17,43.93 150.17,43.62 150.09,43.54 149.92,43.54 149.84,43.62 149.84,43.93 149.76,44.02 149.58,44.02 149.5,43.93 149.5,43.62 149.42,43.54 149.25,43.54 149.17,43.62 149.17,43.93 149.09,44.02 148.91,44.02 148.83,43.93 148.83,43.62 148.75,43.54 148.58,43.54 148.5,43.62 148.5,43.93 148.42,44.02 148.24,44.02 148.16,43.93 148.16,43.62 148.08,43.54 147.91,43.54 147.83,43.62 147.83,43.93 147.75,44.02 147.57,44.02 147.49,43.93 147.49,43.62 147.41,43.54 146.79,43.54 146.66,43.68 146.66,44.62 146.56,44.73 144.24,44.73 143.89,45.08 143.21,45.08 142.82,45.47 142.51,45.47 142.21,45.16 141.39,45.16 140.96,45.59 140.68,45.59 140.31,45.23 139.91,45.23 139.61,45.52 138.97,45.52 138.39,46.11 137.98,46.11 137.03,47.06 136.54,47.06 136.12,46.64 135.59,46.64 135.26,46.97 134.66,46.97 134.16,47.47 133.85,47.47 133.3,46.92 132.8,46.92 132.26,46.37 v1(132.26,46.05)
DDR4_COMP_CH1_DQ71: length 57.7
  L14_SIG5 w0.081: v1(131.46,46.51) 128.8,46.51 128.43,46.14 128.09,46.14 127.63,45.68 127.34,45.68 126.7,45.04 126.53,45.04 126.28,44.79 126.28,42.7 126.53,42.46 126.86,42.46 127.5,41.82 127.7,41.82 127.99,41.54 128.46,41.54 128.92,41.08 129.11,41.08 129.67,40.52 130.11,40.52 130.64,39.98 131.03,39.98 131.31,39.7 131.61,39.7 131.98,40.06 132.46,40.06 132.91,39.6 133.31,39.6 133.69,39.98 134.21,39.98 134.49,39.7 134.58,39.7 134.58,39.69 134.8,39.69 135.09,39.98 135.8,39.98 135.84,39.95 135.84,39.95 136.2,39.59 136.45,39.59 136.87,39.16 137.23,39.16 137.61,38.78 137.87,38.78 138.39,38.25 138.7,38.25 139.04,37.9 139.04,36.32 138.81,36.1 138.81,35.48 139.13,35.17 142.69,35.17 142.69,35.17 143.07,35.17 147.57,30.67 150.3,30.67 150.87,30.1 150.87,26.45 150.61,26.19 150.61,24.7 150.92,24.4 151.29,24.4 152.98,22.72 152.98,22.29 153.19,22.08 154.29,22.08 154.52,22.3 154.52,23.47 153.5,24.49 153.19,24.49 152.97,24.72 152.97,25.83 152.98,25.84 152.98,25.85 153.19,26.07 153.48,26.07 153.72,26.31 153.72,26.61 154.15,27.04 v1(154.15,27.3)
DDR4_COMP_CH1_DQS_N0: length 52.6
  L07_SIG3 w0.076: 144.1,39.99 144.08,39.99 144.08,39.99 143.81,39.99 arc(143.69,39.99) 143.57,39.99 arc(143.53,39.99) 143.49,39.99 arc(143.43,39.98) 143.37,39.98 arc(143.29,39.99) 143.22,39.99 arc(143.06,40.04) 142.97,40.17 arc(142.83,40.37) 142.59,40.43 arc(142.34,40.49) 142.16,40.68 arc(141.82,40.89) 141.48,40.68 arc(141.48,40.67) 141.48,40.66 arc(141.32,40.48) 141.08,40.43 arc(140.84,40.39) 140.68,40.21 arc(140.51,40.01) 140.25,39.95 arc(140.11,39.93) 139.99,39.86 arc(139.95,39.81) 139.9,39.77 139.89,39.76 arc(139.87,39.74) 139.85,39.72 arc(139.8,39.67) 139.74,39.62 arc(139.72,39.6) 139.7,39.59 139.67,39.56 arc(139.57,39.5) 139.46,39.49 arc(139.4,39.49) 139.33,39.48 arc(139.28,39.45) 139.22,39.43 arc(139.19,39.41) 139.16,39.38 139.14,39.36 139.14,39.35 139.13,39.34
  L07_SIG3 w0.089: v1(165.11,24.86) 165.11,24.68 165.2,24.59 166.45,24.59 166.73,24.31 166.73,21.05 166.83,20.95 166.96,20.95 167.08,21.07 167.08,24.84 166.32,25.59 166.32,28.58 162.73,32.17 162.15,32.17 arc(162.04,32.2) 161.94,32.26 156.83,37.38 152.54,41.67 arc(152.5,41.69) 152.46,41.7 148.18,41.7 146.47,39.99 144.1,39.99 ; v1(137.82,38.2) 137.86,38.26 137.94,38.29 arc(138.01,38.29) 138.07,38.27 138.13,38.23 arc(138.2,38.14) 138.18,38.02 138.1,37.87 arc(138.05,37.74) 138.04,37.59 138.05,37.57 arc(138.09,37.43) 138.17,37.32 138.3,37.19 arc(138.59,37.07) 138.88,37.19 139.22,37.52 arc(139.31,37.74) 139.22,37.95 139.08,38.09 arc(139.02,38.23) 139.08,38.37 139.12,38.41 arc(139.23,38.69) 139.12,38.97 139.08,39 arc(139.02,39.15) 139.08,39.29 139.13,39.34
DDR4_COMP_CH1_DQS_N1: length 27.7
  L03_SIG1 w0.081: v1(128.27,38.23) 128.28,38.22 128.5,38.22 128.58,38.14 128.58,38.01 128.46,37.89 128.46,37.23 129.79,35.9 129.79,35.79 129.46,35.46 129.46,35.19 129.69,34.97 129.95,34.97 130.28,35.3 130.39,35.3 131.47,34.22 131.47,33.25 131.71,33.01 131.71,32.89 131.5,32.68 131.5,32.42 131.72,32.2 131.99,32.2 132.2,32.4 132.31,32.4 132.78,31.94 133.04,31.94 133.34,32.24 133.45,32.24 133.57,32.12 133.57,32.01 133.27,31.71 133.27,31.45 134.07,30.65 134.07,30.23 135.17,29.13 135.6,29.13 135.69,29.05 135.69,28.89 135.6,28.81 135.25,28.81 135.06,28.62 135.06,27.42 135.25,27.23 135.59,27.23 135.67,27.15 135.67,26.99 135.59,26.91 135.25,26.91 135.06,26.72 135.06,26.41 135.25,26.22 135.59,26.22 135.67,26.14 135.67,25.98 135.59,25.89 135.25,25.89 135.06,25.71 135.06,25.25 135.26,25.05 135.56,25.05 135.69,24.92 135.69,22.9 135.55,22.77 135.44,22.77 135.34,22.87 135.34,24.33 135.15,24.52 134.64,24.52 134.51,24.65 134.51,24.78 134.59,24.86 v5(134.63,24.86)
DDR4_COMP_CH1_DQS_N2: length 31
  L03_SIG1 w0.081: v5(124.47,24.86) 124.41,24.81 124.41,24.69 124.55,24.55 124.94,24.55 125.15,24.34 125.15,22.54 125.28,22.41 125.48,22.41 125.56,22.5 125.56,23.91 125.75,24.1 126.43,24.1 126.67,23.87 126.67,22.95 126.74,22.88 126.89,22.88 127.01,23.01 127.01,24.41 126.93,24.49 125.55,24.49 124.88,25.16 124.88,25.6 125.07,25.79 125.48,25.79 125.58,25.89 125.58,26.04 125.5,26.13 125.18,26.13 124.99,26.31 124.99,26.64 125.18,26.83 125.44,26.83 125.52,26.91 125.52,27.08 125.44,27.16 125.03,27.16 124.84,27.35 124.84,29.03 125.03,29.22 125.34,29.22 125.42,29.3 125.42,29.47 125.34,29.55 125.03,29.55 124.84,29.74 124.84,30.5 123.59,31.76 123.59,32.03 123.44,32.18 123.44,32.68 123.59,32.83 123.59,33.24 123.44,33.39 123.44,34.6 123.82,34.99 123.82,35.4 123.44,35.78 123.44,37.68 123.85,38.08 123.85,38.38 123.73,38.5 123.73,38.86 123.84,38.97 123.84,39.28 123.74,39.39 123.74,39.82 123.88,39.96 123.88,40.23 123.78,40.33 123.57,40.33 123.46,40.22 123.46,40.1 v1(123.48,40.08)
DDR4_COMP_CH1_DQS_N3: length 39.9
  TOP w0.149: U8.A7 v1(137.32,28.86)
  L05_SIG2 w0.076: 121.57,36.1 121.56,36.12 121.56,36.12 121.53,36.17 121.54,36.18 arc(121.37,36.41) 121.13,36.55 121.08,36.57 arc(120.69,36.84) 120.45,37.24 arc(120.43,37.31) 120.41,37.37 arc(120.4,37.44) 120.38,37.5 arc(120.4,37.74) 120.54,37.94 arc(120.67,38.17) 120.61,38.43 arc(120.53,38.66) 120.58,38.89 arc(120.6,38.93) 120.62,38.96 arc(120.67,39.16) 120.61,39.35 arc(120.57,39.44) 120.56,39.55 120.56,39.67 arc(120.57,39.77) 120.61,39.87 arc(120.67,40.07) 120.61,40.27 arc(120.57,40.36) 120.56,40.47 120.56,40.59 arc(120.57,40.73) 120.61,40.86 arc(120.63,40.97) 120.62,41.08 arc(120.61,41.14) 120.6,41.19 arc(120.59,41.24) 120.58,41.29 arc(120.56,41.48) 120.6,41.66 arc(120.62,41.71) 120.64,41.75 arc(120.67,41.88) 120.66,42.02 arc(120.63,42.11) 120.58,42.19 arc(120.51,42.36) 120.55,42.53 arc(120.49,42.73) v1(120.31,42.84)
  L05_SIG2 w0.081: v1(137.32,28.86) 137.32,28.73 137.5,28.55 137.65,28.55 137.74,28.64 137.74,29.56 137.48,29.81 137.36,29.81 136.48,30.69 135.76,30.69 135.68,30.61 135.68,29.51 135.49,29.32 135.16,29.32 134.97,29.51 134.97,30.61 134.89,30.69 132.44,30.69 132.35,30.61 132.35,29.2 132.17,29.01 131.84,29.01 131.65,29.2 131.65,30.58 131.57,30.66 131.4,30.66 131.32,30.58 131.32,29.2 131.13,29.01 130.81,29.01 130.62,29.2 130.62,30.56 130.49,30.69 129.92,30.69 129.73,30.88 129.73,35.26 129.47,35.52 125.17,35.52 125.03,35.38 124.84,35.38 124.7,35.52 124.5,35.52 124.36,35.38 124.17,35.38 124.03,35.52 123.83,35.52 123.69,35.38 123.5,35.38 123.36,35.52 122.65,35.52 arc(122.03,35.68) 121.57,36.1
DDR4_COMP_CH1_DQS_N4: length 52.1
  TOP w0.149: U9.A7 v1(147.48,28.86)
  L07_SIG3 w0.076: v1(125.09,42.83) 125.34,42.68 arc(125.38,42.63) 125.37,42.58 125.35,42.53 arc(125.31,42.41) 125.33,42.28 125.47,41.95 arc(125.48,41.92) 125.48,41.88 arc(125.46,41.82) 125.43,41.75 arc(125.34,41.49) 125.39,41.22 arc(125.44,40.99) 125.39,40.76 arc(125.45,40.2) 125.97,39.99 arc(126.05,39.98) 126.12,39.94 arc(126.15,39.91) 126.17,39.88 arc(126.18,39.85) 126.19,39.83 arc(126.19,39.82) 126.2,39.81 arc(126.22,39.76) 126.25,39.71 arc(126.43,39.57) 126.65,39.51 arc(126.66,39.51) 126.66,39.51 arc(126.66,39.51) 126.67,39.51 arc(126.68,39.51) 126.7,39.51 arc(126.77,39.52) 126.84,39.54 arc(126.89,39.54) 126.93,39.5 arc(126.94,39.47) 126.95,39.44 arc(126.97,39.39) 127,39.34 arc(127.04,39.21) 127.04,39.08 arc(127.01,38.94) 126.98,38.81 arc(126.97,38.62) 127.03,38.44 arc(127.23,38.23) 127.51,38.13 arc(127.73,38.03) 127.84,37.81 arc(127.94,37.57) 128.15,37.43 arc(128.29,37.39) 128.42,37.37 arc(128.7,37.28) 128.93,37.11 128.99,37.06 128.99,37.05
  L07_SIG3 w0.089: v1(147.48,28.86) 147.48,28.72 147.64,28.56 147.91,28.56 148,28.65 148,29.33 147.78,29.54 145.34,29.54 145.13,29.33 142.83,29.33 142.74,29.24 142.74,28.37 142.52,28.15 142.22,28.15 142.02,28.35 142.02,29.24 141.93,29.33 141.77,29.33 141.68,29.24 141.68,28.29 141.48,28.09 141.18,28.09 140.95,28.32 140.95,29.24 140.86,29.33 140.7,29.33 140.61,29.24 140.61,28.71 140.41,28.51 140.09,28.51 139.89,28.71 139.89,29.24 139.8,29.33 139.41,29.33 139.21,29.53 139.21,30.81 139.12,30.9 138.95,30.9 138.87,30.81 138.87,29.53 138.67,29.33 138.34,29.33 138.14,29.53 138.14,30.81 138.05,30.9 137.89,30.9 137.8,30.81 137.8,29.53 137.6,29.33 137.28,29.33 137.08,29.53 137.08,30.81 136.99,30.9 136.82,30.9 136.73,30.81 136.73,29.53 136.53,29.33 136.19,29.33 136.1,29.24 136.1,28.66 135.9,28.46 135.58,28.46 135.38,28.66 135.38,29.24 135.29,29.33 134.43,29.33 134.2,29.56 134.2,30.03 134.01,30.22 132.57,30.22 132.36,30.42 132.36,31.9 132.56,32.1 133.4,32.1 133.61,32.31 133.61,33.21 130.56,36.26 129.78,36.26 128.99,37.05
