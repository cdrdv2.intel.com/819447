# Allegro board FM85_AGILEX_PCIE_DK_CMC_ADI_REVC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_DDIMM2_A8: length 79.8
  L07_SIG3 w0.089: v1(138.84,99.34) 138.84,99.88 138.34,100.38 134.43,100.38 134.2,100.61 134.2,101.85 133.99,102.06 131.76,102.06 131.48,101.78 125.36,101.78 124.54,102.6 105.53,102.6 104.82,101.89 104.82,100.61 104.46,100.25 104.46,100.25 104.46,92.6 104.37,92.51 103.85,92.51 103.77,92.42 103.77,92.26 103.85,92.17 104.37,92.17 104.46,92.08 104.46,91.91 104.37,91.82 103.85,91.82 103.77,91.74 103.77,91.57 103.85,91.48 104.37,91.48 104.46,91.39 104.46,91.23 104.37,91.14 103.85,91.14 103.77,91.05 103.77,90.88 103.85,90.8 104.37,90.8 104.46,90.71 104.46,90.54 104.37,90.45 103.85,90.45 103.77,90.36 103.77,90.2 103.85,90.11 104.37,90.11 104.46,90.02 104.46,87.55 104.63,87.37 112.68,87.37 113.58,86.47 113.58,78.89 113.56,78.86 113.56,78.55 113.58,78.53 113.58,77.05 113.56,77.02 113.56,76.71 113.58,76.69 113.58,76.33 113.48,76.22 113.48,75.84 113.91,75.4 114.09,75.4 114.37,75.12 114.81,75.12 115.13,74.8 115.13,74.39 114.73,73.99 v1(114.73,73.65)
DDR4_DDIMM2_A9: length 79.8
  L07_SIG3 w0.089: v1(115.52,74.11) 115.52,74.31 115.97,74.75 115.97,76.23 115.7,76.49 115.37,76.49 115.14,76.72 115.14,87.05 114.07,88.12 109.28,88.12 108.97,88.43 108.97,92.12 108.76,92.33 106.28,92.33 106.17,92.44 106.17,93.96 106.41,94.2 107.02,94.2 107.36,94.54 107.36,94.66 107.45,94.74 108.17,94.74 108.26,94.83 108.26,95 108.17,95.09 107.45,95.09 107.36,95.18 107.36,95.34 107.45,95.43 108.17,95.43 108.26,95.52 108.26,95.68 108.17,95.77 107.45,95.77 107.36,95.86 107.36,96.03 107.45,96.12 108.17,96.12 108.26,96.21 108.26,96.37 108.17,96.46 107.45,96.46 107.36,96.55 107.36,96.71 107.45,96.8 108.17,96.8 108.26,96.89 108.26,97.06 108.17,97.15 107.45,97.15 107.36,97.23 107.36,97.4 107.45,97.49 108.17,97.49 108.26,97.58 108.26,97.74 108.17,97.83 107.45,97.83 107.36,97.92 107.36,98.48 107,98.84 107,100.04 107.55,100.59 112.9,100.59 113.6,101.29 114.8,101.29 116.08,100.01 125.19,100.01 125.5,99.71 131.69,99.71 132.56,98.84 134.07,98.84 134.95,99.72 138.36,99.72 138.45,99.63 138.45,99.04 138.54,98.95 140.14,98.95 v1(140.54,99.34)
DDR4_DDIMM2_A10: length 80.6
  L07_SIG3 w0.089: v1(122.69,93.35) 122.69,92.95 122.8,92.84 123.24,92.84 123.37,92.97 123.37,93.41 123.46,93.5 123.93,93.5 124.01,93.59 124.01,93.75 123.93,93.84 123.46,93.84 123.37,93.93 123.37,94.1 123.46,94.19 123.93,94.19 124.01,94.27 124.01,94.44 123.93,94.53 123.46,94.53 123.37,94.62 123.37,94.78 123.46,94.87 123.93,94.87 124.01,94.96 124.01,95.13 123.93,95.21 123.46,95.21 123.37,95.3 123.37,95.47 123.46,95.56 123.93,95.56 124.01,95.65 124.01,95.81 123.93,95.9 123.46,95.9 123.37,95.99 123.37,96.15 123.46,96.24 123.93,96.24 124.01,96.33 124.01,96.5 123.93,96.59 123.34,96.59 123.24,96.68 123.24,96.84 123.33,96.93 123.93,96.93 124.01,97.02 124.01,97.18 123.93,97.27 123.46,97.27 123.37,97.36 123.37,97.57 123.2,97.73 121.71,97.73 121.62,97.64 121.62,96.96 121.53,96.87 121.36,96.87 121.27,96.96 121.27,97.64 121.19,97.73 121.02,97.73 120.93,97.64 120.93,96.96 120.84,96.87 120.68,96.87 120.59,96.96 120.59,97.64 120.5,97.73 120.33,97.73 120.25,97.64 120.25,96.96 120.16,96.87 119.99,96.87 119.9,96.96 119.9,97.64 119.81,97.73 119.65,97.73 119.56,97.64 119.56,96.96 119.47,96.87 119.31,96.87 119.22,96.96 119.22,97.64 119.13,97.73 118.96,97.73 118.87,97.64 118.87,96.96 118.79,96.87 118.62,96.87 118.53,96.96 118.53,97.64 118.44,97.73 118.28,97.73 118.19,97.64 118.19,96.96 118.1,96.87 117.93,96.87 117.85,96.96 117.85,97.64 117.76,97.73 117.59,97.73 117.5,97.64 117.5,96.96 117.41,96.87 117.25,96.87 117.16,96.96 117.16,97.64 117.07,97.73 116.67,97.73 115.87,98.53 113,98.53 112.81,98.33 112.81,94.9 112.72,94.81 111.97,94.81 111.11,93.95 111.11,93.1 111.28,92.93 111.97,92.93 112.06,93.02 112.06,93.89 112.15,93.98 112.31,93.98 112.4,93.89 112.4,93.02 112.49,92.93 112.66,92.93 112.75,93.02 112.75,93.89 112.84,93.98 113,93.98 113.09,93.89 113.09,93.02 113.18,92.93 113.34,92.93 113.43,93.02 113.43,93.89 113.52,93.98 113.69,93.98 113.77,93.89 113.77,93.02 113.86,92.93 115.24,92.93 115.32,92.84 115.32,92.48 115.41,92.39 115.58,92.39 115.67,92.48 115.67,92.84 115.8,92.98 116.12,92.98 116.25,92.84 116.25,91.93 116.45,91.73 116.57,91.73 116.88,91.42 116.88,91.17 116.79,91.08 116.41,91.08 116.32,90.99 116.32,90.82 116.41,90.74 116.79,90.74 116.88,90.65 116.88,90.48 116.79,90.39 116.41,90.39 116.32,90.3 116.32,90.14 116.41,90.05 116.79,90.05 116.88,89.96 116.88,89.8 116.79,89.71 116.41,89.71 116.32,89.62 116.32,89.45 116.41,89.36 116.79,89.36 116.88,89.27 116.88,89.11 116.79,89.02 116.41,89.02 116.32,88.93 116.32,88.77 116.41,88.68 116.79,88.68 116.88,88.59 116.88,88.42 116.79,88.33 116.41,88.33 116.32,88.25 116.32,88.08 116.41,87.99 116.79,87.99 116.88,87.9 116.88,87.74 116.79,87.65 116.41,87.65 116.32,87.56 116.32,87.4 116.41,87.31 116.79,87.31 116.88,87.22 116.88,87.05 116.79,86.96 116.41,86.96 116.32,86.87 116.32,86.71 116.41,86.62 116.79,86.62 116.88,86.53 116.88,80.28 116.75,80.14 116.72,79.86 arc(116.66,79.63) 116.72,79.41 116.72,79.4 arc(116.78,79.17) 116.72,78.94 arc(116.66,78.71) 116.72,78.48 arc(116.78,78.25) 116.72,78.02 arc(116.66,77.79) 116.72,77.56 116.72,77.56 arc(116.78,77.33) 116.72,77.1 116.71,77.08 arc(116.66,76.86) 116.72,76.64 arc(116.78,76.42) 116.73,76.2 116.72,76.18 arc(116.66,75.95) 116.72,75.72 116.73,75.7 arc(116.78,75.48) 116.72,75.26 arc(116.66,75.03) 116.72,74.8 116.72,74.8 arc(116.78,74.58) 116.73,74.36 116.71,74.32 arc(116.66,74.1) 116.72,73.88 116.72,73.88 arc(116.78,73.65) 116.72,73.42 arc(116.55,73.25) 116.32,73.19 116.3,73.19 arc(116.08,73.12) 115.92,72.96 v1(115.52,72.27)
DDR4_DDIMM2_A11: length 80.3
  L12_SIG4 w0.089: v1(114.73,72.73) 114.73,72.85 arc(114.68,73.1) 114.54,73.31 114.46,73.39 arc(114.36,73.46) 114.24,73.49 113.97,73.52 arc(113.75,73.47) 113.61,73.29 arc(113.57,73.23) 113.51,73.18 arc(113.32,73.13) 113.13,73.1 arc(113.06,73.1) 112.99,73.07 arc(112.91,73.05) 112.84,73.04 112.81,73.04 arc(112.68,73.02) 112.57,72.95 arc(112.34,72.85) 112.1,72.95 arc(111.77,73.12) 111.39,73.07 arc(111.32,73.05) 111.25,73.04 111.21,73.04 arc(111.09,73.02) 110.98,72.95 arc(110.73,72.85) 110.49,72.96 arc(110.4,73.04) 110.28,73.07 arc(110.23,73.07) 110.19,73.08 110.08,73.09 arc(110.05,73.09) 110.02,73.1 arc(109.99,73.1) 109.95,73.1 arc(109.94,73.1) 109.92,73.11 arc(109.64,73.26) 109.53,73.56 109.53,74.33 arc(109.47,74.47) 109.33,74.53 108.93,74.53 arc(108.82,74.48) 108.78,74.37 108.78,73.46 arc(108.75,73.35) 108.69,73.25 108.63,73.19 arc(108.54,73.13) 108.42,73.1 108.26,73.1 arc(108.15,73.15) 108.11,73.25 arc(108.09,73.35) 108.04,73.43 arc(107.99,73.49) 107.98,73.56 107.98,73.61 arc(107.98,73.64) 107.98,73.67 arc(107.98,73.7) 107.98,73.73 107.98,74.04 arc(107.9,74.29) 107.69,74.46 arc(107.32,74.4) 107.19,74.04 107.19,73.43 arc(107.17,73.37) 107.14,73.31 107.05,73.22 arc(106.92,73.14) 106.78,73.11 arc(106.66,73.13) 106.57,73.2 106.45,73.31 arc(106.36,73.45) 106.33,73.61 106.33,73.98 arc(106.33,74.02) 106.33,74.07 arc(106.17,74.42) 105.78,74.44 arc(105.76,74.43) 105.75,74.41 arc(105.61,74.24) 105.6,74.01 arc(105.61,73.97) 105.61,73.92 105.61,73.41 arc(105.52,73.2) 105.31,73.11 105.3,73.11 arc(105.26,73.12) 105.23,73.14 arc(105.1,73.22) 104.99,73.31 arc(104.97,73.33) 104.95,73.34 arc(104.9,73.39) 104.85,73.44 arc(104.75,73.51) 104.65,73.56 104.1,73.82 arc(103.9,74.23) 104.26,74.52 104.42,74.52 arc(104.52,74.54) 104.6,74.59 104.76,74.75 arc(104.79,74.79) 104.8,74.84 104.83,75.5 arc(105.08,75.82) 105.45,75.67 arc(105.58,75.55) 105.74,75.5 106.12,75.5 arc(106.18,75.49) 106.23,75.46 106.56,75.13 arc(106.76,75.05) 106.95,75.13 107.1,75.28 arc(107.43,75.43) 107.77,75.34 arc(107.81,75.3) 107.85,75.27 arc(107.87,75.23) 107.91,75.2 107.93,75.18 arc(108.3,75.02) 108.68,75.18 108.96,75.46 arc(109.13,75.53) 109.31,75.46 109.59,75.18 arc(109.9,75.05) 110.21,75.18 110.44,75.41 arc(110.55,75.5) 110.66,75.56 arc(110.71,75.57) 110.75,75.57 arc(110.8,75.58) 110.84,75.59 arc(110.89,75.6) 110.94,75.6 arc(111.04,75.6) 111.14,75.61 arc(111.21,75.63) 111.27,75.68 arc(111.41,75.8) 111.6,75.82 arc(111.83,75.87) 111.98,76.06 arc(112.13,76.26) 112.39,76.32 arc(112.63,76.37) 112.79,76.55 arc(112.9,76.7) 113.07,76.78 arc(113.18,76.81) 113.27,76.88 113.33,76.95 arc(113.43,77.08) 113.5,77.23 arc(113.51,77.27) 113.51,77.31 arc(113.51,77.36) 113.52,77.4 113.62,78.19 arc(113.61,78.35) 113.56,78.5 113.56,78.51 113.5,78.63 113.41,78.71 113.11,78.71 113.03,78.8 113.03,78.97 113.11,79.06 113.41,79.06 113.5,79.15 113.5,79.31 113.41,79.4 113.11,79.4 113.03,79.49 113.03,79.65 113.11,79.74 113.41,79.74 113.5,79.83 113.5,80.21 113.31,80.39 112.73,81.39 112.7,81.46 112.58,81.84 112.58,82.57 112.75,82.74 112.75,83.4 112.88,83.53 112.88,85.07 112.59,85.36 112.59,86.12 111.67,87.04 111.67,87.73 114.29,90.36 114.63,90.36 114.96,90.69 116.09,90.69 117.16,91.76 119.68,91.76 v1(119.99,92.06)
  BOTTOM w0.149: v1(119.99,92.06) 120.97,91.08 133.37,91.08 134.97,92.67 134.97,93.38 135.38,93.79 135.38,95.37 135.87,95.86 139.26,95.86 140.54,94.58 v1(140.54,93.34)
DDR4_DDIMM2_A12: length 74.8
  L07_SIG3 w0.089: v1(141.39,99.34) 141.39,99.05 141.48,98.96 144.52,98.96 145.07,99.52 145.07,100.03 144.88,100.22 141.52,100.22 141.43,100.31 141.43,100.76 141.52,100.85 141.77,100.85 141.86,100.93 141.86,101.1 141.77,101.19 141.52,101.19 141.43,101.28 141.43,101.43 141.55,101.54 141.72,101.54 141.81,101.63 141.81,102.14 141.9,102.23 142.07,102.23 142.16,102.14 142.16,101.63 142.24,101.54 142.56,101.54 142.65,101.46 142.65,100.67 142.74,100.58 142.91,100.58 143,100.67 143,101.46 143.08,101.54 143.25,101.54 143.34,101.46 143.34,100.67 143.43,100.58 143.59,100.58 143.68,100.67 143.68,101.46 143.77,101.54 143.94,101.54 144.02,101.46 144.02,100.67 144.11,100.58 144.28,100.58 144.37,100.67 144.37,101.46 144.46,101.54 144.62,101.54 144.71,101.46 144.71,100.67 144.8,100.58 144.96,100.58 145.05,100.67 145.05,101.46 145.14,101.54 145.76,101.54 146.05,101.25 146.05,100.56 146.14,100.47 146.51,100.47 146.6,100.38 146.6,100.22 146.51,100.13 146.14,100.13 146.05,100.04 146.05,99.87 146.14,99.78 146.51,99.78 146.6,99.7 146.6,99.53 146.51,99.44 146.14,99.44 146.05,99.35 146.05,99.19 146.14,99.1 146.51,99.1 146.6,99.01 146.6,98.84 146.51,98.76 146.14,98.76 146.05,98.67 146.05,98.27 145.94,98.16 145.48,98.16 145.01,98.63 144.68,98.63 144.26,98.21 143.16,98.21 142.81,97.86 139.5,97.86 139.06,98.3 137.83,98.3 137.2,97.67 135.6,97.67 135.15,97.22 132.86,97.22 132.22,96.57 132.09,96.57 131.6,97.07 131.47,97.07 131.36,96.95 131.36,96.83 131.85,96.33 131.85,96.21 131.37,95.72 129.92,95.72 121.81,87.61 121.16,87.61 119.63,86.08 119.63,84.94 119.09,84.39 119.09,84.08 119.18,83.99 119.5,83.99 119.59,83.91 119.59,83.74 119.5,83.65 119.18,83.65 119.09,83.56 119.09,83.4 119.18,83.31 119.5,83.31 119.59,83.22 119.59,83.05 119.5,82.97 119.18,82.97 119.09,82.88 119.09,82.71 119.18,82.62 119.5,82.62 119.59,82.53 119.59,82.37 119.5,82.28 119.18,82.28 119.09,82.19 119.09,82.03 119.18,81.94 119.5,81.94 119.59,81.85 119.59,81.68 119.5,81.59 119.18,81.59 119.09,81.5 119.09,77.75 v1(119.51,77.33)
DDR4_DDIMM2_A13: length 77.9
  TOP w0.149: v1(116.66,92.83) 116.74,92.91 J1.232
  L05_SIG2 w0.081: v1(117.92,78.25) 117.49,78.68 117.49,78.86 117.27,79.08 117.09,79.08 116.68,79.49 116.68,80.26 116.1,80.85 116.1,84.48 116.42,84.81 116.63,84.81 116.88,85.05 116.88,86.79 117.36,87.27 117.36,89.98 117.29,90.04 117.29,90.45 115.9,91.84 115.9,92.1 115.67,92.34 115.34,92.34 115.26,92.42 115.26,92.72 114.92,93.07 114.04,93.07 113.47,93.63 113.02,93.63 112.94,93.71 112.94,95.12 113.04,95.22 113.47,95.22 113.69,95.44 113.69,95.96 114.24,96.51 114.24,98.81 114.58,99.15 114.58,100.19 114.36,100.41 113.45,100.41 113.31,100.55 109.38,100.55 109.25,100.68 109.25,101.22 109.17,101.31 108.99,101.31 108.91,101.22 108.91,100.64 108.82,100.55 108.01,100.55 107.79,100.77 107.79,100.9 107.71,100.99 107.36,100.99 107.27,101.07 107.27,101.24 107.36,101.32 107.71,101.32 107.79,101.4 107.79,102.03 107.94,102.18 108.24,102.18 108.32,102.1 108.32,101.49 108.4,101.41 108.58,101.41 108.66,101.49 108.66,102.1 108.74,102.18 109.46,102.18 109.54,102.1 109.54,101.46 109.62,101.37 109.79,101.37 109.87,101.46 109.87,102.1 109.95,102.18 110.13,102.18 110.21,102.1 110.21,101.31 110.29,101.22 110.46,101.22 110.54,101.31 110.54,102.1 110.62,102.18 110.8,102.18 110.88,102.1 110.88,101.44 110.92,101.39 110.93,101.39 110.97,101.35 111.13,101.35 111.21,101.44 111.21,102.1 111.3,102.18 111.47,102.18 111.55,102.1 111.55,101.42 111.63,101.34 111.79,101.34 111.88,101.43 111.88,102.1 111.97,102.18 112.23,102.18 112.5,102.45 112.63,102.45 112.71,102.37 112.71,101.96 112.63,101.87 112.43,101.87 112.35,101.79 112.35,101.62 112.43,101.54 112.63,101.54 112.71,101.46 112.71,101.28 112.8,101.18 112.96,101.18 113.04,101.26 113.04,102.52 113.13,102.61 113.3,102.61 113.38,102.53 113.38,101.19 113.46,101.11 113.63,101.11 113.71,101.19 113.71,102.51 113.79,102.6 113.95,102.6 114.05,102.5 114.05,101.39 114.13,101.31 114.3,101.31 114.38,101.39 114.38,102.47 114.52,102.61 114.86,102.61 115.02,102.45 115.02,101.1 114.94,101.02 114.75,101.02 114.67,100.94 114.67,100.76 114.75,100.68 114.94,100.68 115.02,100.6 115.02,99.87 115.1,99.79 115.55,99.79 115.63,99.71 115.63,99.54 115.55,99.46 115.1,99.46 115.02,99.38 115.02,99.2 115.1,99.12 115.55,99.12 115.63,99.04 115.63,98.87 115.55,98.79 115.1,98.79 115.02,98.7 115.02,98.54 114.73,98.25 114.73,96.06 114.7,96.03 114.7,95.43 114.62,95.35 114.24,95.35 114.15,95.27 114.15,95.1 114.24,95.01 114.62,95.01 114.7,94.93 114.7,94.76 114.62,94.68 113.97,94.68 113.87,94.58 113.87,94.43 113.95,94.34 114.62,94.34 114.7,94.26 114.7,94.01 115.88,92.83 v1(116.66,92.83)
DDR4_DDIMM2_A14: length 77.6
  L07_SIG3 w0.089: v1(120.14,93.34) 122.11,93.34 122.38,93.62 122.38,96.37 122.23,96.53 121.89,96.53 121.8,96.44 121.8,95.87 121.71,95.78 121.55,95.78 121.46,95.87 121.46,96.44 121.37,96.53 121.2,96.53 121.12,96.44 121.12,95.87 121.03,95.78 120.86,95.78 120.77,95.87 120.77,96.44 120.68,96.53 120.52,96.53 120.43,96.44 120.43,95.87 120.34,95.78 120.18,95.78 120.09,95.87 120.09,96.44 120,96.53 119.83,96.53 119.74,96.44 119.74,95.87 119.65,95.78 119.49,95.78 119.4,95.87 119.4,96.44 119.31,96.53 119.15,96.53 119.06,96.44 119.06,95.87 118.97,95.78 118.8,95.78 118.71,95.87 118.71,96.44 118.63,96.53 118.46,96.53 118.37,96.44 118.37,95.87 118.28,95.78 118.12,95.78 118.03,95.87 118.03,96.44 117.94,96.53 117.78,96.53 117.69,96.44 117.69,95.87 117.6,95.78 117.43,95.78 117.34,95.87 117.34,96.44 117.25,96.53 117.07,96.53 116.83,96.77 116.83,97.12 116.4,97.55 116.25,97.55 116.16,97.46 116.16,96.42 116.07,96.33 115.91,96.33 115.82,96.42 115.82,97.46 115.73,97.55 115.56,97.55 115.47,97.46 115.47,96.42 115.38,96.33 115.22,96.33 115.13,96.42 115.13,97.46 115.04,97.55 114.15,97.55 113.97,97.36 113.97,97.13 114.05,97.04 114.59,97.04 114.68,96.95 114.68,96.79 114.59,96.7 114.05,96.7 113.97,96.61 113.97,96.44 114.05,96.36 114.59,96.36 114.68,96.27 114.68,96.1 114.59,96.01 114.05,96.01 113.97,95.92 113.97,95.76 114.05,95.67 114.59,95.67 114.68,95.58 114.68,95.42 114.59,95.33 114.05,95.33 113.97,95.24 113.97,95.07 114.05,94.98 114.59,94.98 114.68,94.9 114.68,94.73 114.59,94.64 114.05,94.64 113.97,94.55 113.97,94.04 114.2,93.81 116.38,93.81 116.47,93.9 116.47,94.74 116.38,94.83 115.27,94.83 115.18,94.92 115.18,95.08 115.27,95.17 116.38,95.17 116.47,95.26 116.47,95.96 116.56,96.05 116.73,96.05 116.82,95.96 116.82,93.9 116.9,93.81 117.42,93.81 117.67,93.56 117.67,92.01 117.76,91.92 118.99,91.92 119.07,91.83 119.07,91.66 118.99,91.58 117.73,91.58 117.64,91.49 117.64,91.32 117.73,91.23 119.33,91.23 119.42,91.14 119.42,90.98 119.33,90.89 117.73,90.89 117.64,90.8 117.64,90.64 117.73,90.55 119.33,90.55 119.42,90.46 119.42,90.29 119.33,90.2 117.73,90.2 117.64,90.12 117.64,89.95 117.73,89.86 119.33,89.86 119.42,89.77 119.42,89.61 119.33,89.52 117.73,89.52 117.64,89.43 117.64,89.26 117.73,89.18 119.33,89.18 119.42,89.09 119.42,88.92 119.33,88.83 117.73,88.83 117.64,88.74 117.64,86.61 117.32,86.3 117.32,81.33 117.21,81.13 117.21,78.8 v1(117.12,78.71)
DDR4_DDIMM2_A15: length 75.4
  L05_SIG2 w0.081: v1(118.44,99.34) 118.31,99.47 116.21,99.47 115.26,100.43 115.26,102.72 115.06,102.92 114.79,102.92 114.71,103 114.71,103.19 114.63,103.27 114.45,103.27 114.37,103.19 114.37,103 114.29,102.92 113.13,102.92 112.65,103.41 112.19,103.41 112.11,103.33 112.11,102.53 112.03,102.45 111.85,102.45 111.77,102.53 111.77,103.42 111.69,103.5 111.52,103.5 111.44,103.42 111.44,102.53 111.35,102.45 111.18,102.45 111.1,102.53 111.1,103.41 111.01,103.5 110.85,103.5 110.77,103.42 110.77,102.53 110.68,102.45 110.51,102.45 110.43,102.53 110.43,103.43 110.33,103.53 110.18,103.53 110.09,103.45 110.09,102.53 110.01,102.45 109.84,102.45 109.76,102.53 109.76,103.43 109.68,103.51 109.52,103.51 109.42,103.42 109.42,102.53 109.34,102.45 109.17,102.45 109.09,102.53 109.09,103.33 109.01,103.41 108.84,103.41 108.75,103.33 108.75,102.53 108.67,102.45 108.5,102.45 108.42,102.53 108.42,103.33 108.34,103.41 108.16,103.41 108.08,103.33 108.08,102.53 108,102.45 107.83,102.45 107.75,102.53 107.75,103.33 107.67,103.41 107.15,103.41 107.02,103.28 107.02,102.6 106.94,102.52 106.74,102.52 106.65,102.6 106.65,103.5 106.57,103.58 106.4,103.58 106.32,103.5 106.32,102.6 106.24,102.52 105.84,102.52 105.76,102.44 105.76,102.27 105.84,102.19 106.22,102.19 106.3,102.11 106.3,101.63 106.38,101.54 106.56,101.54 106.64,101.63 106.64,102.11 106.72,102.19 106.94,102.19 107.02,102.11 107.02,100.88 106.87,100.73 106.6,100.73 106.46,100.59 106.46,100.44 106.62,100.28 107.18,100.28 107.27,100.36 107.27,100.55 107.35,100.63 107.52,100.63 107.6,100.55 107.6,100.36 107.68,100.28 112.66,100.28 113.22,99.72 113.34,99.72 113.62,100.01 113.74,100.01 113.86,99.88 113.86,99.77 113.57,99.48 113.57,99.24 114,98.81 114,96.61 113.36,95.97 113.16,95.97 112.61,95.41 112.05,95.41 111.87,95.24 111.87,95.1 111.95,95.02 112.28,95.02 112.36,94.94 112.36,94.77 112.28,94.69 111.95,94.69 111.87,94.6 111.87,94.25 112.86,93.26 113.36,93.26 113.8,92.81 113.8,92.38 114.12,92.06 114.46,92.06 115.16,91.37 116.05,91.37 117.06,90.35 117.06,87.34 115.86,86.14 115.86,85.78 115.94,85.7 116,85.7 116.08,85.62 116.08,85.44 116,85.36 115.94,85.36 115.86,85.28 115.86,79.53 116.26,79.13 116.58,79.13 116.66,79.05 116.66,78.73 arc(116.67,78.6) 116.72,78.48 arc(116.78,78.25) 116.72,78.02 arc(116.66,77.79) 116.72,77.56 116.73,77.54 arc(116.9,77.38) 117.12,77.33 v1(117.92,77.33)
DDR4_DDIMM2_A16: length 74.2
  L12_SIG4 w0.089: v1(121.8,98.12) 123.09,98.12 123.34,97.87 123.37,97.87 123.38,97.86 123.88,97.86 124.26,97.48 125.48,97.48 125.7,97.26 125.7,94 125.5,93.79 124.08,93.79 123.99,93.88 123.99,94.96 123.9,95.05 123.73,95.05 123.64,94.96 123.64,93.88 123.55,93.79 123.39,93.79 123.3,93.88 123.3,94.96 123.21,95.05 123.05,95.05 122.96,94.96 122.96,93.88 122.87,93.79 122.7,93.79 122.62,93.88 122.62,94.96 122.53,95.05 122.36,95.05 122.27,94.96 122.27,93.07 122.18,92.98 121.51,92.98 121.42,93.07 121.42,95.22 121.33,95.31 121.17,95.31 121.08,95.22 121.08,92.96 120.99,92.87 120.83,92.87 120.73,92.97 120.73,95.22 120.65,95.31 120.48,95.31 120.39,95.22 120.39,93.88 120.3,93.79 119.83,93.79 119.74,93.71 119.74,92.93 119.83,92.84 120.23,92.84 120.67,92.4 120.67,92.25 120.68,92.24 120.68,91.5 120.34,91.16 120.14,91.16 118.76,91.16 118.73,91.13 117.33,91.13 117.18,90.98 117.18,90.86 117.59,90.45 117.59,90.32 117.47,90.21 117.34,90.21 116.94,90.61 116.81,90.61 116.7,90.5 116.7,90.37 117.1,89.96 117.1,89.84 116.99,89.72 116.86,89.72 116.45,90.13 116.33,90.13 115.97,89.77 115.73,89.77 115.3,90.21 115.16,90.21 115.03,90.08 115.03,89.95 116.11,88.88 116.11,88.75 116,88.63 115.87,88.63 114.79,89.71 114.67,89.71 114.55,89.59 114.55,89.47 115.01,89.01 115.01,88.88 114.9,88.76 114.77,88.76 114.31,89.23 114.18,89.23 113.87,88.91 113.87,88.79 114.98,87.67 114.98,87.55 114.87,87.43 114.74,87.43 113.63,88.55 113.5,88.55 113.38,88.43 113.38,88.3 114.5,87.19 114.5,87.06 114.38,86.95 114.26,86.95 113.14,88.06 113.02,88.06 112.9,87.94 112.9,87.82 114.01,86.7 114.01,83.48 113.81,83.27 113.41,83.27 113.32,83.19 113.32,82.63 113.06,82.37 113.06,82.24 113.18,82.13 113.3,82.13 113.82,82.64 113.98,82.64 114.07,82.55 114.07,82.4 113.55,81.88 113.55,81.76 113.75,81.55 113.75,80.77 114.13,80.39 114.13,79.96 114.81,79.29 114.81,78.99 arc(114.86,78.73) 115.01,78.51 arc(115.11,78.35) 115.15,78.15 115.15,76.95 arc(115.15,76.92) 115.15,76.89 arc(115.15,76.86) 115.15,76.83 115.15,76.42 arc(115.16,76.32) 115.17,76.21 arc(115.18,76.13) 115.16,76.05 arc(115.22,75.73) 115.49,75.58 arc(115.82,75.62) 116.09,75.8 116.25,75.95 arc(116.32,76.01) 116.42,76.05 arc(116.59,76.14) 116.68,76.32 arc(116.72,76.41) 116.78,76.49 117.09,76.79 arc(117.11,76.83) v1(117.12,76.87)
DDR4_DDIMM2_A17: length 77.7
  TOP w0.149: v1(112.91,92.57) 112.91,92.39 113.16,92.14 115.02,92.14 115.27,92.39 115.27,93.13 115.04,93.35 J1.234
  L05_SIG2 w0.081: v1(112.91,92.57) 112.18,92.57 111.8,92.95 111.52,92.95 111.27,93.19 111.27,94.34 111.1,94.52 111.1,95.69 111.37,95.97 112.5,95.97 112.94,96.41 112.94,98.8 112.77,98.97 112.34,98.97 112.12,99.19 112.12,99.49 111.89,99.72 110.64,99.72 110.56,99.63 108.94,99.63 108.81,99.5 105.97,99.5 105.25,100.22 105.25,106.42 105.08,106.59 104.65,106.59 104.41,106.35 104.41,105.7 104.33,105.62 104,105.62 103.92,105.54 103.92,105.37 104,105.29 104.33,105.29 104.41,105.21 104.41,105.03 104.33,104.95 104,104.95 103.92,104.87 103.92,104.7 104,104.62 104.33,104.62 104.41,104.54 104.41,102.74 104.33,102.66 103.98,102.66 103.9,102.58 103.9,102.4 103.98,102.32 104.33,102.32 104.41,102.24 104.41,102.07 104.33,101.99 103.98,101.99 103.9,101.9 103.9,101.73 103.98,101.65 104.33,101.65 104.41,101.57 104.41,99.38 104.67,99.12 105.66,99.12 106.3,98.48 107.68,98.48 108.09,98.89 108.4,98.89 108.58,98.7 109.61,98.7 109.79,98.89 110.1,98.89 110.28,98.7 111.82,98.7 112.5,98.02 112.5,96.74 112.32,96.56 111.69,96.56 111.38,96.87 110.79,96.87 110.56,96.64 110.56,95.52 110.19,95.15 110.19,94.18 110.68,93.68 110.68,92.24 111.6,91.32 114.3,91.32 114.72,90.9 115.85,90.9 116.59,90.16 116.59,87.59 115.14,86.13 115.14,85.97 115.14,85.37 115.14,85.37 115.14,85.02 115.14,84.81 115.06,84.73 114.69,84.73 114.6,84.64 114.6,84.47 114.69,84.39 115.06,84.39 115.14,84.31 115.14,84.14 115.06,84.06 114.69,84.06 114.6,83.97 114.6,83.8 114.69,83.72 115.06,83.72 115.14,83.64 115.14,81.66 115.32,81.48 115.32,78.92 v1(115.53,78.71)
DDR4_DDIMM2_ACT_N: length 85.2
  L07_SIG3 w0.089: v1(117.92,74.57) 118.34,74.99 118.34,76.1 118.36,76.13 118.36,76.69 118.34,76.71 118.34,77.02 118.36,77.05 118.36,78.53 118.34,78.55 118.34,80.7 118.58,80.95 118.58,84.22 119.39,85.04 119.39,87.5 119.64,87.75 119.77,87.75 120.27,87.25 120.4,87.25 120.52,87.36 120.52,87.49 120.01,88 120.01,88.42 120.3,88.71 120.44,88.71 120.53,88.8 120.53,89.4 120.62,89.49 120.79,89.49 120.88,89.4 120.88,88.8 120.96,88.71 121.13,88.71 121.22,88.8 121.22,89.4 121.31,89.49 121.47,89.49 121.56,89.4 121.56,88.8 121.65,88.71 122.55,88.71 122.73,88.89 122.73,89.01 121.65,90.09 121.65,90.21 121.76,90.33 121.89,90.33 122.97,89.25 123.09,89.25 123.21,89.37 123.21,89.5 122.13,90.57 122.13,90.7 122.25,90.82 122.38,90.82 123.45,89.74 123.58,89.74 123.69,89.86 123.69,89.98 122.62,91.06 122.62,91.18 122.73,91.3 122.86,91.3 123.94,90.22 124.06,90.22 124.18,90.34 124.18,90.47 123.1,91.54 123.1,91.67 123.22,91.79 123.35,91.79 124.42,90.71 124.55,90.71 124.66,90.83 124.66,90.95 123.59,92.03 123.59,92.15 123.7,92.27 123.83,92.27 124.91,91.19 125.03,91.19 125.15,91.31 125.15,91.44 124.07,92.51 124.07,92.64 124.19,92.76 124.32,92.76 125.39,91.68 125.52,91.68 125.63,91.8 125.63,91.92 124.56,93 124.56,93.12 124.67,93.24 124.8,93.24 125.88,92.16 126,92.16 126.12,92.28 126.12,92.41 125.04,93.48 125.04,93.61 125.16,93.73 125.29,93.73 126.36,92.65 126.49,92.65 126.6,92.76 126.6,92.89 125.53,93.97 125.53,94.09 125.64,94.21 125.77,94.21 125.9,94.08 126.03,94.08 126.53,94.58 126.66,94.58 126.78,94.46 126.78,94.34 126.27,93.83 126.27,93.71 126.85,93.13 126.97,93.13 128.5,94.66 128.5,94.79 128.09,95.2 128.09,95.32 128.21,95.44 128.34,95.44 128.74,95.03 128.87,95.03 128.99,95.15 128.99,95.27 128.58,95.68 128.58,95.81 128.7,95.92 128.82,95.92 129.23,95.52 129.36,95.52 129.47,95.63 129.47,95.76 129.06,96.17 129.06,96.29 129.18,96.41 129.31,96.41 129.71,96 129.84,96 130.33,96.49 130.33,96.62 129.89,97.06 129.89,97.19 130.01,97.3 130.13,97.3 130.57,96.86 130.7,96.86 130.82,96.98 130.82,97.1 130.37,97.54 130.37,97.67 130.49,97.79 130.62,97.79 131.06,97.34 131.18,97.34 131.59,97.75 135.29,97.75 136.34,98.8 137.74,98.8 137.88,98.66 140.72,98.66 140.95,98.89 140.95,99.49 141.18,99.72 143.51,99.72 v1(143.89,99.34)
DDR4_DDIMM2_ALERT_N: length 83.6
  L07_SIG3 w0.089: v1(125.23,103.74) 113.92,103.74 113.48,103.3 112.77,103.3 112.65,103.42 106,103.42 104.58,101.99 104.58,101.02 104.14,100.59 104.14,99.68 103.49,99.02 103.49,96.27 103.67,96.09 103.67,95.78 103.49,95.6 103.49,87.66 104.21,86.95 112.49,86.95 v1(112.53,86.91)
  BOTTOM w0.149: v1(110.74,78.71) 111.14,79.1 111.14,79.34 111.38,79.57 111.71,79.57 112.02,79.88 112.02,80.24 111.83,80.43 111.83,80.69 112.02,80.88 112.02,81.72 113.38,83.08 113.38,84.74 113.68,85.04 113.68,86.24 113.01,86.91 v1(112.53,86.91) ; v1(125.23,103.74) 125.23,101.97 124.5,101.24 124.5,100.62 124.71,100.41 125.72,100.41 125.83,100.29 125.83,99.86 125.95,99.74 126.12,99.74 126.24,99.86 126.24,100.29 126.35,100.41 126.52,100.41 126.64,100.29 126.64,99.86 126.76,99.74 126.92,99.74 127.04,99.86 127.04,100.29 127.16,100.41 138.79,100.41 140.27,98.93 140.27,96.84 142.08,95.03 142.08,94.6 v1(142.24,94.44)
DDR4_DDIMM2_BA0: length 77.4
  L07_SIG3 w0.089: v1(116.32,78.25) 116.32,79.42 115.95,79.79 115.95,80.31 116.26,80.62 116.26,81.25 116.28,81.26 116.28,84.81 116.04,85.05 116.04,90.51 115.62,90.92 114.8,90.92 114.71,91.01 114.71,92.01 114.62,92.1 114.45,92.1 114.36,92.01 114.36,91.01 114.27,90.92 114.11,90.92 114.02,91.01 114.02,92.16 113.91,92.27 113.77,92.27 113.68,92.18 113.68,91.01 113.59,90.92 113.42,90.92 113.34,91.01 113.34,92.06 113.24,92.15 113.08,92.15 112.99,92.07 112.99,91.01 112.9,90.92 112.74,90.92 112.65,91.01 112.65,92.23 112.56,92.32 112.41,92.32 112.31,92.22 112.31,91.01 112.22,90.92 112.05,90.92 111.96,91.01 111.96,92.07 111.87,92.16 111.71,92.16 111.62,92.07 111.62,91.01 111.53,90.92 111.37,90.92 111.28,91.01 111.28,92.27 111.19,92.36 111.03,92.36 110.93,92.27 110.93,91.01 110.85,90.92 110.65,90.92 110.49,91.09 110.49,91.44 110.36,91.57 110.36,91.74 110.27,91.83 109.64,91.83 109.55,91.92 109.55,92.08 109.64,92.17 110.27,92.17 110.36,92.26 110.36,92.43 110.27,92.52 109.64,92.52 109.55,92.6 109.55,92.77 109.64,92.86 110.27,92.86 110.36,92.95 110.36,93.64 110.27,93.73 109.95,93.73 109.86,93.82 109.86,93.99 109.95,94.08 110.27,94.08 110.36,94.17 110.36,94.29 110.59,94.52 110.59,94.72 110.68,94.8 111.26,94.8 111.35,94.89 111.35,95.06 111.26,95.15 110.68,95.15 110.59,95.24 110.59,96.02 110.68,96.11 112.01,96.11 112.1,96.2 112.1,96.36 112.01,96.45 110.68,96.45 110.59,96.54 110.59,96.71 110.68,96.79 111.45,96.79 111.54,96.88 111.54,97.05 111.45,97.14 110.68,97.14 110.59,97.23 110.59,97.39 110.68,97.48 111.33,97.48 111.41,97.57 111.41,97.73 111.33,97.82 110.68,97.82 110.59,97.91 110.59,98.56 110.81,98.78 114.47,98.78 114.55,98.87 114.55,99.64 114.64,99.73 114.81,99.73 114.9,99.64 114.9,98.87 114.99,98.78 115.15,98.78 115.24,98.87 115.24,99.64 115.33,99.73 115.49,99.73 115.58,99.64 115.58,98.87 115.67,98.78 115.84,98.78 115.93,98.87 115.93,99.64 116.01,99.73 116.18,99.73 116.27,99.64 116.27,98.87 116.36,98.78 116.52,98.78 116.61,98.87 116.61,99.64 116.7,99.73 116.87,99.73 116.95,99.64 116.95,98.87 117.04,98.78 117.21,98.78 117.3,98.87 117.3,99.64 117.39,99.73 117.55,99.73 117.64,99.64 117.64,98.87 117.73,98.78 118.76,98.78 118.85,98.87 118.85,99.66 118.94,99.75 119.11,99.75 119.2,99.66 119.2,98.87 119.28,98.78 120.46,98.78 120.55,98.87 120.55,99.67 120.64,99.76 120.8,99.76 120.89,99.67 120.89,98.87 120.98,98.78 121.14,98.78 121.23,98.87 121.23,99.67 121.32,99.76 121.49,99.76 121.58,99.67 121.58,98.87 121.67,98.78 122.31,98.78 v1(122.69,99.16)
DDR4_DDIMM2_BA1: length 77.6
  TOP w0.149: J1.224 123.54,92.99 122.64,92.08 v1(121.54,92.08)
  L05_SIG2 w0.081: v1(121.54,92.08) 121.2,92.42 120.72,92.42 120.58,92.28 120.58,92.15 120.92,91.81 120.92,91.69 120.8,91.57 120.68,91.57 120.43,91.82 120.32,91.82 120.16,91.67 119.83,91.67 119.72,91.77 119.36,91.77 119.28,91.85 119.28,92.02 119.36,92.11 119.46,92.11 119.54,92.19 119.54,92.36 119.46,92.44 119.36,92.44 119.28,92.52 119.28,92.59 119.19,92.68 119.02,92.68 118.94,92.6 118.94,91.85 118.86,91.77 118.69,91.77 118.61,91.85 118.61,92.05 118.52,92.13 118.35,92.13 118.27,92.05 118.27,91.85 118.19,91.77 118.01,91.77 117.93,91.85 117.93,92.3 117.85,92.39 117.7,92.39 117.6,92.29 117.6,91.85 117.52,91.77 117.13,91.77 116.94,91.58 116.94,91.5 117.06,91.38 119.61,91.38 119.69,91.3 119.69,91.13 119.6,91.04 117.75,91.04 117.67,90.96 117.67,90.79 117.75,90.71 119.08,90.71 119.17,90.62 119.17,90.45 119.08,90.37 117.75,90.37 117.67,90.29 117.67,90.12 117.75,90.04 119.08,90.04 119.17,89.95 119.17,89.78 119.08,89.7 117.75,89.7 117.67,89.62 117.67,89.45 117.75,89.37 119.08,89.37 119.17,89.28 119.17,89.11 119.08,89.03 117.75,89.03 117.67,88.95 117.67,88.78 117.75,88.69 119.08,88.69 119.17,88.61 119.17,88.44 119.08,88.36 117.75,88.36 117.67,88.28 117.67,88.11 117.75,88.02 119.08,88.02 119.17,87.94 119.17,87.77 119.08,87.69 117.75,87.69 117.67,87.61 117.67,87.43 117.75,87.35 119.17,87.35 119.25,87.27 119.25,87.1 119.08,86.94 119.08,86.61 119.01,86.53 118.84,86.53 118.73,86.64 118.73,86.94 118.65,87.02 118.43,87.02 118.35,86.94 118.35,86.6 118.26,86.52 118.09,86.52 118.01,86.6 118.01,86.94 117.93,87.02 117.57,87.02 117.48,86.94 117.48,86.65 117.4,86.56 117.2,86.56 117.12,86.48 117.12,86.31 117.2,86.23 117.4,86.23 117.48,86.15 117.48,85.98 117.4,85.89 117.2,85.89 117.12,85.81 117.12,85.64 117.2,85.56 117.42,85.56 117.5,85.48 117.5,85.31 117.42,85.22 117.2,85.22 117.12,85.14 117.12,84.97 117.2,84.89 117.4,84.89 117.48,84.81 117.48,84.06 117.6,83.94 118.24,83.94 118.33,83.86 118.33,83.16 118.24,83.08 117.16,83.08 117.08,83.16 117.08,83.39 117.16,83.47 117.22,83.47 117.3,83.55 117.3,83.73 117.22,83.81 117.16,83.81 117.08,83.89 117.08,84.54 117,84.62 116.82,84.62 116.74,84.54 116.74,83.96 116.66,83.88 116.46,83.88 116.38,83.8 116.38,83.63 116.46,83.54 116.66,83.54 116.74,83.46 116.74,83.16 116.66,83.08 116.5,83.08 116.42,83 116.42,82.82 116.5,82.74 118.55,82.74 118.64,82.65 118.64,82.49 118.56,82.41 116.5,82.41 116.42,82.33 116.42,82.15 116.5,82.07 118.67,82.07 118.75,81.99 118.75,81.84 118.65,81.74 116.5,81.74 116.42,81.66 116.42,81.48 116.5,81.4 117.07,81.4 117.16,81.32 117.16,81.06 117.07,80.98 116.64,80.98 116.56,80.9 116.56,80.73 116.64,80.65 117.07,80.65 117.16,80.56 117.16,79.42 117.24,79.34 117.39,79.34 117.49,79.44 117.49,81.32 117.57,81.4 118.24,81.4 118.33,81.31 118.33,81.11 118.37,81.07 118.37,80.97 arc(118.35,80.87) 118.31,80.78 arc(118.25,80.57) 118.3,80.35 118.32,80.31 arc(118.38,80.09) 118.31,79.86 arc(118.25,79.63) 118.31,79.4 118.32,79.4 arc(118.38,79.17) 118.31,78.94 arc(118.25,78.71) 118.31,78.48 118.31,78.48 arc(118.38,78.25) 118.31,78.02 arc(118.25,77.79) 118.31,77.56 118.32,77.56 arc(118.38,77.33) 118.31,77.1 118.3,77.08 arc(118.14,76.92) 117.92,76.87 arc(117.69,76.81) 117.52,76.65 117.51,76.63 arc(117.35,76.47) 117.12,76.41 117.11,76.41 arc(116.89,76.47) 116.72,76.64 arc(116.55,76.81) 116.33,76.87 116.32,76.87 v1(115.53,76.87)
DDR4_DDIMM2_BG0: length 75.9
  L14_SIG5 w0.081: v1(143.09,99.34) 143.09,97.68 142.49,97.08 142.38,97.08 141.15,98.31 141.04,98.31 140.92,98.18 140.92,98.07 143.31,95.68 143.31,95.56 143.18,95.44 143.07,95.44 140.68,97.83 140.56,97.83 140.44,97.71 140.44,97.59 142.87,95.17 142.87,95.05 142.75,94.93 142.63,94.93 140.2,97.36 140.09,97.36 139.97,97.24 139.97,97.12 141.19,95.9 141.19,95.78 140.92,95.51 140.92,93.61 141,93.53 142.57,93.53 142.66,93.45 142.66,93.28 142.57,93.2 141,93.2 140.92,93.11 140.92,92.94 141,92.86 142.57,92.86 142.66,92.78 142.66,92.61 142.57,92.52 141,92.52 140.92,92.44 140.92,92.22 140.65,91.94 140.65,91.83 141.03,91.45 141.03,91.33 140.9,91.21 140.79,91.21 140.41,91.59 140.29,91.59 140.17,91.47 140.17,91.35 140.55,90.97 140.55,90.86 140.43,90.74 140.31,90.74 139.93,91.12 139.82,91.12 136.81,88.11 136.81,80.33 136.71,80.23 136.71,77.09 136.03,76.41 133.05,76.41 arc(132.82,76.35) 132.66,76.18 arc(132.49,76.01) 132.26,75.95 132.26,75.95 arc(132.03,75.89) 131.86,75.73 131.86,75.72 arc(131.69,75.55) 131.46,75.49 arc(131.23,75.55) 131.06,75.72 131.06,75.72 arc(130.89,75.89) 130.66,75.95 arc(130.44,75.89) 130.27,75.72 arc(130.1,75.55) 129.87,75.49 arc(129.64,75.55) 129.47,75.71 129.47,75.72 arc(129.3,75.89) 129.07,75.95 129.06,75.95 arc(128.84,75.89) 128.67,75.72 arc(128.5,75.55) 128.27,75.49 arc(128.05,75.55) 127.88,75.71 127.88,75.72 arc(127.71,75.89) 127.48,75.95 127.47,75.95 arc(127.24,75.89) 127.08,75.72 arc(126.91,75.55) 126.68,75.49 arc(126.46,75.55) 126.29,75.71 126.28,75.72 arc(126.11,75.89) 125.88,75.95 125.87,75.95 arc(125.65,75.89) 125.49,75.72 arc(125.32,75.55) 125.09,75.49 arc(124.86,75.55) 124.69,75.71 124.69,75.72 arc(124.52,75.89) 124.29,75.95 124.28,75.95 arc(124.05,75.88) 123.89,75.72 arc(123.72,75.55) 123.49,75.49 arc(123.27,75.55) 123.1,75.71 123.09,75.72 arc(122.93,75.89) 122.7,75.95 122.68,75.95 arc(122.46,75.88) 122.3,75.72 arc(122.13,75.55) 121.9,75.49 arc(121.68,75.55) 121.51,75.71 121.5,75.72 arc(121.33,75.89) 121.1,75.95 121.09,75.95 arc(120.87,75.88) 120.7,75.72 arc(120.54,75.55) 120.31,75.49 arc(120.08,75.55) 119.92,75.7 119.91,75.72 arc(119.74,75.89) 119.51,75.95 119.49,75.95 arc(119.27,75.88) 119.11,75.72 arc(118.94,75.55) 118.71,75.49 arc(118.49,75.55) 118.32,75.7 118.3,75.74 arc(118.14,75.89) 117.92,75.95 117.9,75.95 arc(117.68,76.02) 117.52,76.18 arc(117.36,76.34) 117.14,76.41 117.11,76.41 arc(116.89,76.47) 116.72,76.64 v1(116.32,77.33)
DDR4_DDIMM2_BG1: length 88.5
  L07_SIG3 w0.089: v1(143.09,94.69) 143.09,95.56 143.31,95.78 143.6,95.78 143.68,95.87 143.68,96.86 143.77,96.95 143.94,96.95 144.03,96.86 144.03,95.87 144.12,95.78 144.28,95.78 144.37,95.87 144.37,96.86 144.46,96.95 144.62,96.95 144.71,96.86 144.71,95.87 144.8,95.78 144.97,95.78 145.06,95.87 145.06,96.86 145.15,96.95 145.31,96.95 145.4,96.86 145.4,95.87 145.49,95.78 145.86,95.78 145.98,95.91 145.98,96.12 146.07,96.21 146.59,96.21 146.68,96.3 146.68,96.46 146.59,96.55 146.07,96.55 145.98,96.64 145.98,96.81 146.07,96.9 146.59,96.9 146.72,97.03 146.72,97.28 147.28,97.83 147.48,97.83 147.81,98.16 147.81,99.97 148.57,100.73 148.57,103.37 147.93,104.01 147.53,104.01 147.44,103.92 147.44,103.53 147.35,103.44 147.18,103.44 147.09,103.53 147.09,103.92 147.01,104.01 146.84,104.01 146.75,103.92 146.75,103.53 146.66,103.44 146.5,103.44 146.41,103.53 146.41,103.92 146.32,104.01 146.15,104.01 146.07,103.92 146.07,103.53 145.98,103.44 145.81,103.44 145.72,103.53 145.72,103.92 145.63,104.01 145.47,104.01 145.38,103.92 145.38,103.53 145.29,103.44 145.13,103.44 145.04,103.53 145.04,103.92 144.95,104.01 144.78,104.01 144.69,103.92 144.69,103.53 144.61,103.44 144.44,103.44 144.35,103.53 144.35,103.92 144.26,104.01 144.1,104.01 144.01,103.92 144.01,103.53 143.92,103.44 143.75,103.44 143.67,103.53 143.67,103.92 143.58,104.01 143.41,104.01 143.32,103.92 143.32,103.53 143.23,103.44 143.07,103.44 142.98,103.53 142.98,103.92 142.89,104.01 142.73,104.01 142.64,103.92 142.64,103.53 142.55,103.44 142.38,103.44 142.29,103.53 142.29,103.92 142.2,104.01 142,104.01 141.77,103.78 141.77,102.71 141.94,102.53 146.62,102.53 146.88,102.27 146.88,98.1 146.57,97.8 143.2,97.8 143.02,97.62 139.23,97.62 138.84,98.01 138.02,98.01 137.38,97.37 135.71,97.37 135.23,96.9 133.32,96.9 131.76,95.34 130.04,95.34 121.82,87.11 121.38,87.11 119.94,85.67 119.94,80.71 119.93,80.7 119.93,80.39 119.94,80.39 119.94,79.79 119.93,79.78 119.93,79.47 119.94,79.47 119.94,78.87 119.93,78.86 119.93,78.55 119.94,78.55 119.94,77.06 119.67,76.78 119.19,76.78 118.71,76.31 v1(118.71,75.95)
DDR4_DDIMM2_C0: length 79.8
  L05_SIG2 w0.081: v1(113.93,78.71) 114.61,79.39 114.61,79.74 114.4,79.95 114.4,80.23 114.56,80.39 114.56,82.51 114.46,82.6 113.47,83.6 113.47,84.17 113.55,84.26 113.81,84.26 113.89,84.34 113.89,84.51 113.81,84.59 113.48,84.59 113.4,84.67 113.4,84.84 113.48,84.93 113.81,84.93 113.89,85.01 113.89,85.18 113.81,85.26 113.64,85.26 113.56,85.34 113.56,85.52 113.64,85.6 113.81,85.6 113.89,85.68 113.89,85.85 113.81,85.93 113.55,85.93 113.47,86.01 113.47,86.25 113.07,86.64 113.07,87.01 113.15,87.09 113.43,87.09 113.51,87.18 113.51,87.78 113.59,87.86 113.77,87.86 113.85,87.78 113.85,86.83 113.93,86.74 114.1,86.74 114.18,86.82 114.18,87.78 114.26,87.86 114.44,87.86 114.52,87.78 114.52,87.13 114.6,87.05 114.77,87.05 114.85,87.13 114.85,87.78 114.93,87.86 115.11,87.86 115.19,87.78 115.19,87.2 115.27,87.12 115.39,87.12 116.1,87.84 116.1,88.09 115.97,88.22 115.22,88.22 115.14,88.3 115.14,88.6 115.22,88.68 115.93,88.68 116.01,88.76 116.01,88.94 115.93,89.02 115.22,89.02 115.14,89.1 115.14,89.27 115.22,89.35 115.93,89.35 116.01,89.43 116.01,89.61 115.93,89.69 115.22,89.69 115.14,89.77 115.14,89.94 115.22,90.02 115.51,90.02 115.6,90.12 115.6,90.28 115.52,90.36 114.99,90.36 114.81,90.18 114.8,90.18 114.8,88.3 114.72,88.22 114.55,88.22 114.47,88.3 114.47,90.34 114.39,90.42 114.22,90.42 114.13,90.34 114.13,88.3 114.05,88.22 113.88,88.22 113.8,88.3 113.8,90.63 113.72,90.71 113.54,90.71 113.46,90.63 113.46,88.3 113.38,88.22 113.21,88.22 113.13,88.3 113.13,90.63 113.05,90.71 112.87,90.71 112.79,90.63 112.79,87.59 112.69,87.48 112.54,87.48 112.46,87.56 112.46,90.63 112.38,90.71 112.2,90.71 112.12,90.63 112.12,90.55 112.04,90.47 111.49,90.47 111.41,90.38 111.41,90.21 111.49,90.13 112.04,90.13 112.12,90.05 112.12,89.88 112.04,89.8 111.49,89.8 111.41,89.71 111.41,89.54 111.49,89.46 112.04,89.46 112.12,89.38 112.12,89.21 112.04,89.12 111.49,89.12 111.41,89.04 111.41,88.87 111.49,88.79 112.04,88.79 112.12,88.71 112.12,88.11 111.91,87.9 111.79,87.9 111.03,88.67 111.03,90.92 110.26,91.69 109.69,91.69 109.57,91.8 109.57,93.43 107.82,95.18 107.01,95.18 105.93,96.26 105.93,97.25 106.06,97.38 106.27,97.38 106.35,97.46 106.35,97.71 106.43,97.79 106.6,97.79 106.69,97.71 106.69,97.46 106.77,97.38 106.94,97.38 107.02,97.46 107.02,97.71 107.1,97.79 107.27,97.79 107.36,97.71 107.36,97.46 107.44,97.38 107.61,97.38 107.69,97.46 107.69,97.71 107.77,97.79 107.94,97.79 108.03,97.71 108.03,97.46 108.11,97.38 108.28,97.38 108.36,97.46 108.36,97.71 108.44,97.79 108.62,97.79 108.7,97.71 108.7,97.36 108.78,97.28 108.93,97.28 109.03,97.38 109.03,97.71 109.11,97.79 109.29,97.79 109.37,97.71 109.37,97.46 109.45,97.38 109.62,97.38 109.7,97.46 109.7,97.71 109.78,97.79 109.96,97.79 110.04,97.71 110.04,97.63 110.12,97.54 111.77,97.54 111.86,97.45 v1(111.86,97.33)
  BOTTOM w0.149: R1074.1 112.43,98 111.86,97.43 v1(111.86,97.33)
DDR4_DDIMM2_C0_CS_N2: length 0.8
  BOTTOM w0.149: R1075.2 112.43,99.41 v1(112.49,99.34)
DDR4_DDIMM2_C1: length 87.7
  BOTTOM w0.149: R1076.1 112.44,93.45 112.16,93.73 112.16,93.8 111.89,94.07 111.33,94.07 110.74,93.48 110.43,93.48 109.68,94.23 108.35,94.23 107.53,93.41 107.17,93.41 106.49,94.09 105.76,94.09 104.91,93.24 103.53,93.24 102.78,93.99 98.59,93.99 96.97,92.36 86.51,92.36 85.95,91.8 85.95,89.94 86.5,89.39 87.54,89.39 88.53,88.4 90.33,88.4 90.45,88.52 90.45,89.49 90.56,89.61 90.73,89.61 90.85,89.49 90.85,88.52 90.97,88.4 91.13,88.4 91.25,88.52 91.25,89.49 91.37,89.61 91.54,89.61 91.65,89.49 91.65,88.52 91.77,88.4 91.94,88.4 92.06,88.52 92.06,89.49 92.17,89.61 92.34,89.61 92.46,89.49 92.46,88.52 92.58,88.4 92.74,88.4 92.86,88.52 92.86,89.49 92.98,89.61 93.15,89.61 93.26,89.49 93.26,88.52 93.38,88.4 93.55,88.4 93.67,88.52 93.67,89.49 93.78,89.61 93.95,89.61 94.07,89.49 94.07,88.52 94.19,88.4 95.7,88.4 95.82,88.52 95.82,88.98 95.94,89.1 96.1,89.1 96.22,88.98 96.22,88.52 96.34,88.4 102.18,88.4 103.04,87.54 108.16,87.54 108.84,86.86 110.81,86.86 112.84,84.82 112.84,83.34 110.34,80.83 110.34,80.38 110.49,80.23 110.49,79.95 110.34,79.8 110.34,79.46 110.5,79.3 110.5,79.04 110.34,78.88 110.34,78.54 110.5,78.38 110.5,78.12 110.34,77.96 110.34,77.62 110.49,77.47 110.49,77.19 110.34,77.04 110.34,76.7 110.58,76.46 110.91,76.46 111.28,76.83 111.8,76.83 112.17,76.46 112.51,76.46 112.87,76.83 113.27,76.83 113.82,77.39 114.1,77.39 114.34,77.62 114.34,77.86 v1(114.73,78.25)
DDR4_DDIMM2_C1_CS_N3: length 1.1
  TOP w0.149: v1(112.55,94.39) 112.55,94.1 J1.237
  BOTTOM w0.149: v1(112.55,94.39) 112.53,94.41 R1077.2
DDR4_DDIMM2_CS_N2: length 48.1
  L05_SIG2 w0.081: v1(113.14,77.33) 113.14,77 112.58,76.45 112.03,76.45 111.95,76.53 111.95,78.76 111.97,78.77 111.97,78.86 112.18,79.08 112.28,79.08 112.29,79.09 112.91,79.09 113.48,79.65 113.48,80.61 113.22,80.87 113.22,81.08 113.31,81.17 113.31,82.12 111.68,83.75 111.68,86.1 111.31,86.47 111.31,86.75 109.79,88.27 109.79,89.66 107.57,91.88 107.57,92.87 105.32,95.12 101.46,95.12 v1(100.6,95.98)
  BOTTOM w0.149: v1(100.6,95.98) 101.22,95.36 103.73,95.36 103.88,95.51 103.88,96.53 103.36,97.04 103.36,98.96 104.48,100.08 111.6,100.08 112.08,100.56 112.95,100.56 113.32,100.18 R1075.1
DDR4_DDIMM2_CS_N3: length 35
  L05_SIG2 w0.081: v1(103.95,97.21) 103.95,96.88 107.96,92.88 107.96,92.03 110.02,89.96 110.02,88.36 111.54,86.85 111.54,86.57 111.91,86.2 111.91,86.17 112.16,85.93 112.16,85.14 112.47,84.83 112.47,83.3 113.54,82.22 113.54,81.26 113.54,81.26 113.78,81.02 113.78,79.51 112.76,78.49 112.76,77.29 v1(112.34,76.87)
  BOTTOM w0.149: v1(103.95,97.21) 104.31,97.57 105.42,97.57 105.81,97.95 111.15,97.95 111.44,97.66 111.44,97.11 R1077.1
DDR4_DDIMM2_DBI_N0: length 120.5
  L12_SIG4 w0.076: v1(108.36,77.33) 108.1,77.18 arc(108.04,77.17) 108,77.21 107.96,77.27 arc(107.96,77.27) 107.96,77.27 arc(107.94,77.3) 107.92,77.32 107.87,77.37 arc(107.81,77.42) 107.74,77.45 arc(107.7,77.45) 107.67,77.46 107.57,77.46 arc(107.43,77.48) 107.31,77.56 arc(107.25,77.64) 107.21,77.74 arc(107.21,77.81) 107.23,77.88 107.31,78.05 arc(107.33,78.14) 107.33,78.23 107.31,78.35 arc(107.28,78.44) 107.24,78.52 arc(107.2,78.62) 107.18,78.74 107.18,78.93 arc(107.21,79.08) 107.29,79.21 107.52,79.43 arc(107.61,79.57) 107.64,79.72 107.64,81.07
  L12_SIG4 w0.089: v1(190.69,99.34) 190.46,99.34 190.37,99.26 190.37,98.74 190.48,98.63 190.48,98.35 190.37,98.24 190.37,97.84 190.17,97.64 189.57,97.64 189.37,97.84 189.37,98.8 188.89,99.28 188.89,99.81 189.14,100.06 190,100.06 190.09,100.15 190.09,100.41 190,100.5 188.7,100.5 188.38,100.82 188.38,101.37 188.73,101.71 188.73,101.94 187.2,103.47 186.5,103.47 186.22,103.19 185.89,103.19 185.61,103.47 185.44,103.47 185.16,103.19 184.83,103.19 184.55,103.47 184.37,103.47 184.09,103.19 183.76,103.19 183.48,103.47 179.54,103.47 179.53,103.46 178.28,103.46 178.28,103.47 171.9,103.47 171.7,103.66 164.88,103.66 162.04,103.66 161.24,104.46 160.02,104.46 159.93,104.37 159.93,104.03 159.73,103.83 159.41,103.83 159.21,104.03 159.21,104.37 159.12,104.46 154.59,104.46 153.8,103.67 150.16,103.67 149.96,103.87 149.96,104.33 149.88,104.42 149.71,104.42 149.44,104.15 149.08,104.15 148.81,104.42 148.64,104.42 148.55,104.33 148.55,103.87 148.35,103.67 148.03,103.67 147.83,103.87 147.83,104.33 147.74,104.42 147.58,104.42 147.49,104.33 147.49,103.87 147.29,103.67 145.89,103.67 145.71,103.48 144.77,103.48 140.68,103.48 140.58,103.38 129.91,103.38 129.47,102.93 129.18,102.93 127.73,101.48 125.94,101.48 124.82,102.61 123.92,102.61 123.72,102.81 123.72,103.09 123.63,103.18 123.46,103.18 123.37,103.09 123.37,102.81 123.13,102.56 120.69,102.56 120.49,102.76 120.49,103.14 120.4,103.23 120.24,103.23 120.15,103.14 120.15,102.76 119.95,102.56 119.14,102.56 117.84,101.26 117.44,101.26 117.33,101.16 117.33,100.75 116.92,100.34 116.36,100.34 114.03,98.01 114.03,97.12 113.58,96.67 112.87,96.67 111.91,95.72 111.91,95.3 111.44,94.83 111.44,93.81 111.22,93.59 111.22,93.07 107.64,89.49 107.64,81.07 107.64,81.07
DDR4_DDIMM2_DBI_N1: length 94.7
  L12_SIG4 w0.076: v1(122.7,77.33) 122.43,77.17 arc(122.37,77.19) 122.32,77.22 122.26,77.28 arc(122.1,77.38) 121.92,77.42 121.9,77.42 arc(121.64,77.35) 121.44,77.16 121.4,77.1 arc(121.36,76.98) 121.35,76.85 121.36,76.81 arc(121.36,76.8) 121.36,76.79 121.36,76.79 arc(121.36,76.76) 121.37,76.72 arc(121.38,76.67) 121.4,76.63 121.42,76.6 arc(121.47,76.52) 121.54,76.45 arc(121.6,76.4) 121.68,76.35 arc(121.75,76.33) 121.83,76.32 121.92,76.32 arc(122.1,76.27) 122.22,76.14 arc(122.25,76.08) 122.28,76.03 122.31,76 arc(122.43,75.92) 122.56,75.86 arc(122.64,75.85) 122.71,75.86 arc(122.73,75.86) 122.76,75.86 arc(122.77,75.86) 122.79,75.86 arc(122.91,75.8) 123,75.7 123.01,75.69 123.03,75.66 arc(123.23,75.47) 123.49,75.4 arc(123.68,75.35) 123.81,75.22 123.82,75.21 arc(124.02,75.01) 124.29,74.94 124.29,74.94 arc(124.48,74.89) 124.61,74.75 124.66,74.66 arc(124.79,74.53) 124.97,74.48 125.09,74.48 125.1,74.48 arc(125.28,74.43) 125.41,74.29 arc(125.6,74.1) 125.87,74.02 125.89,74.02 arc(126.16,74.09) 126.36,74.29 arc(126.5,74.43) 126.69,74.48 arc(126.83,74.5) 126.97,74.55 arc(127.07,74.62) 127.15,74.73 127.16,74.75 arc(127.21,74.83) 127.28,74.89 arc(127.38,74.93) 127.48,74.94 127.49,74.94 arc(127.76,75.02) 127.95,75.21 arc(128.09,75.35) 128.27,75.4 128.28,75.4 arc(128.55,75.48) 128.75,75.67 arc(128.88,75.81) 129.07,75.86 129.07,75.86 arc(129.34,75.93) 129.54,76.13 129.55,76.14 arc(129.68,76.27) 129.87,76.32 arc(130.14,76.39) 130.34,76.59 130.41,76.7 arc(130.46,76.76) 130.54,76.78 130.67,76.78 arc(130.85,76.73) 130.99,76.59 arc(131.18,76.4) 131.45,76.32 131.46,76.32 arc(131.65,76.27) 131.78,76.14 131.78,76.13 arc(131.99,75.93) 132.26,75.86 132.27,75.86 arc(132.54,75.94) 132.73,76.13 arc(132.87,76.27) 133.05,76.32 133.11,76.32 133.11,76.32 133.28,76.32 133.74,76.78 133.84,76.78 138.45,76.78 arc(138.59,76.81) 138.72,76.89 139.01,77.18 arc(139.07,77.23) 139.15,77.24 139.41,77.24 arc(139.46,77.24) 139.51,77.25 139.67,77.3 139.97,77.6 arc(140.08,77.67) 140.22,77.7 140.29,77.7 arc(140.39,77.68) 140.47,77.62 140.7,77.39 arc(140.75,77.35) 140.81,77.31 140.83,77.3 arc(141.1,77.26) 141.35,77.39 141.5,77.55 arc(141.53,77.57) 141.55,77.59 arc(141.55,77.59) 141.55,77.59 arc(141.57,77.6) 141.58,77.61 arc(141.58,77.61) 141.59,77.61 arc(141.61,77.63) 141.64,77.65 arc(141.64,77.66) 141.65,77.67 arc(141.66,77.67) 141.66,77.67 arc(141.73,77.69) 141.81,77.7 arc(141.81,77.7) 141.81,77.7 arc(141.86,77.7) 141.91,77.69 arc(141.91,77.69) 141.91,77.69 arc(142.09,77.58) 142.18,77.4 arc(142.22,77.28) 142.3,77.19 arc(142.39,77.14) 142.49,77.12 142.78,77.12 arc(143.17,77.2) 143.5,77.42 143.71,77.62 arc(143.83,77.7) 143.96,77.73 143.98,77.72 144.43,77.72
  L12_SIG4 w0.089: 144.43,77.72 144.48,77.67 147.12,77.67 149.14,75.64 149.3,75.64 156.11,75.64 157.16,76.69 161.79,76.69 166.64,81.53 166.64,85.46 172.11,90.93 173.98,90.93 174.86,91.81 180.1,91.81 181.18,92.89 181.18,93.72 180.83,94.07 179.51,94.07 179.01,93.58 177.87,93.58 177.47,93.98 177.47,94.24 177.27,94.44 176.26,94.44 176.17,94.53 176.17,94.7 176.26,94.79 177.27,94.79 177.47,94.99 177.47,95.68 177.72,95.92 177.84,95.92 178.39,95.38 178.67,95.38 178.9,95.6 178.9,95.89 178.35,96.43 178.35,96.72 178.57,96.94 179.6,96.94 179.69,96.85 179.69,95.57 179.89,95.37 180.22,95.37 180.42,95.57 180.42,96.85 180.5,96.94 180.7,96.94 181.01,97.26 181.01,97.62 v1(181.34,97.95)
DDR4_DDIMM2_DBI_N2: length 97.7
  L14_SIG5 w0.076: v1(112.34,72.27) 112.08,72.53 arc(112.07,72.55) 112.07,72.57 arc(112.09,72.72) 112.07,72.87 arc(112.05,72.94) 112.02,73 112.01,73.01 arc(111.81,73.21) 111.54,73.28 111.51,73.28 arc(111.26,73.2) 111.07,73.01 111.06,73 arc(110.99,72.73) 111.07,72.45 111.12,72.37 arc(111.26,72.22) 111.45,72.16 111.47,72.16 arc(111.5,72.16) 111.52,72.16 111.57,72.15 arc(111.72,72.09) 111.85,72 arc(111.86,71.98) 111.88,71.96 111.88,71.96 arc(111.89,71.93) 111.89,71.9 111.88,71.88 arc(111.88,71.83) 111.87,71.78 arc(111.86,71.74) 111.85,71.7 arc(111.84,71.65) 111.83,71.61 111.79,71.46 arc(111.79,71.29) 111.83,71.12 arc(111.84,71.11) 111.85,71.1 arc(111.85,71.08) 111.86,71.07 arc(111.9,71.01) 111.94,70.97 arc(112.01,70.91) 112.09,70.86 arc(112.18,70.83) 112.27,70.81 arc(112.28,70.8) 112.29,70.8 112.41,70.78 arc(112.44,70.76) 112.48,70.75 112.53,70.72 arc(112.57,70.68) 112.6,70.63 arc(112.67,70.53) 112.76,70.44 arc(112.89,70.37) 113.03,70.35 113.18,70.35 arc(113.22,70.34) 113.26,70.33 arc(113.32,70.3) 113.38,70.25 113.64,69.98 arc(113.71,69.92) 113.79,69.89 114.06,69.81 arc(114.16,69.76) 114.23,69.69 arc(114.46,69.5) 114.75,69.42 arc(114.92,69.37) 115.04,69.25 115.06,69.22 arc(115.26,69.03) 115.52,68.96 115.55,68.96 arc(115.81,69.04) 116,69.23 arc(116.13,69.37) 116.3,69.42 116.32,69.42 arc(116.51,69.37) 116.64,69.24 116.64,69.23 arc(116.84,69.03) 117.12,68.96 117.14,68.96 arc(117.4,69.04) 117.59,69.23 arc(117.72,69.37) 117.9,69.42 117.92,69.42 arc(118.1,69.37) 118.24,69.23 118.24,69.23 arc(118.4,69.06) 118.61,68.97 arc(118.61,68.97) 118.62,68.97 arc(118.66,68.96) 118.71,68.96 118.72,68.96 arc(118.9,69.01) 119.04,69.14 119.05,69.14 119.21,69.33 arc(119.27,69.39) 119.34,69.43 arc(119.39,69.44) 119.44,69.44 arc(119.5,69.44) 119.56,69.44 arc(119.61,69.44) 119.65,69.42 arc(119.73,69.37) 119.8,69.3 arc(120.09,69.04) 120.48,68.98 120.51,68.98 arc(120.51,68.98) 120.51,68.98 120.53,68.98 arc(120.54,68.99) 120.55,68.99 120.57,69 arc(120.67,69.05) 120.74,69.14 120.76,69.2 arc(121.04,69.42) 121.38,69.31 arc(121.91,69.09) 122.43,69.31 arc(122.54,69.39) 122.68,69.42 122.72,69.42 arc(122.88,69.38) 123.01,69.25 123.03,69.22 arc(123.23,69.03) 123.49,68.96 123.51,68.96 arc(123.77,69.04) 123.97,69.23 arc(124,69.27) 124.03,69.31 124.09,69.37 arc(124.12,69.4) 124.16,69.4 124.37,69.4 arc(124.41,69.4) 124.44,69.39 arc(124.53,69.33) 124.6,69.25 124.62,69.22 arc(124.82,69.03) 125.09,68.96 125.1,68.96 arc(125.37,69.04) 125.56,69.23 arc(125.69,69.37) 125.87,69.42 126.04,69.42 126.15,69.31 arc(126.18,69.27) 126.2,69.23 126.21,69.22 arc(126.41,69.03) 126.68,68.96 126.69,68.96 arc(126.96,69.04) 127.16,69.23 arc(127.29,69.37) 127.47,69.42 127.49,69.42 arc(127.66,69.37) 127.79,69.25 127.8,69.23 arc(128,69.03) 128.27,68.96 128.28,68.96 arc(128.55,69.04) 128.75,69.23 arc(128.88,69.37) 129.06,69.42 129.07,69.42 arc(129.25,69.37) 129.39,69.24 129.4,69.23 arc(129.6,69.03) 129.87,68.96 129.88,68.96 arc(130.15,69.04) 130.34,69.23 arc(130.48,69.37) 130.66,69.42 130.66,69.42 arc(130.85,69.37) 130.98,69.24 130.99,69.23 arc(131.46,68.96) 131.94,69.23 131.94,69.24 arc(132.07,69.37) 132.26,69.42 arc(132.44,69.37) 132.57,69.24 arc(132.78,69.02) 133.06,68.93 arc(133.07,68.93) 133.08,68.93 arc(133.09,68.93) 133.1,68.93 arc(133.11,68.93) 133.12,68.93 133.18,68.93 arc(133.28,68.95) 133.37,69 arc(133.4,69.02) 133.43,69.04 133.68,69.23 arc(133.75,69.28) 133.82,69.34 133.88,69.4 arc(133.99,69.49) 134.12,69.55 arc(134.28,69.61) 134.42,69.69 arc(134.47,69.73) 134.51,69.77 134.65,69.9 arc(134.71,69.95) 134.78,69.97
  L14_SIG5 w0.081: v1(171.99,99.34) 171.88,99.34 171.66,99.13 171.66,95.13 171.47,94.94 171.47,93.9 171.74,93.63 171.74,92.38 169.96,90.6 169.41,90.6 169.03,90.23 162.5,90.23 160.32,88.05 155.5,88.05 155.42,87.97 155.42,87.36 155.23,87.17 154.91,87.17 154.72,87.36 154.72,87.97 154.64,88.05 154.47,88.05 154.38,87.97 154.38,87.36 154.2,87.17 153.87,87.17 153.68,87.36 153.68,87.97 153.6,88.05 149.9,88.05 145.33,83.48 145.33,72.27 144.81,71.76 144.81,70.54 144.3,70.03 143.3,70.03 143.16,69.78 arc(142.66,69.49) 142.16,69.78 142.15,69.8 arc(142,69.95) 141.8,70.01 arc(141.79,70.01) 141.79,70.01 arc(141.59,69.95) 141.44,69.81 141.44,69.8 arc(141.23,69.59) 140.94,69.51 140.93,69.51 arc(140.63,69.59) 140.42,69.8 140.42,69.81 arc(140.27,69.95) 140.06,70.01 arc(140.06,70.01) 140.06,70.01 arc(139.86,69.95) 139.71,69.81 139.71,69.8 arc(139.5,69.59) 139.21,69.51 139.19,69.51 arc(138.9,69.59) 138.69,69.8 138.68,69.81 arc(138.54,69.95) 138.33,70.01 arc(138.33,70.01) 138.33,70.01 arc(138.13,69.95) 137.98,69.81 137.98,69.8 arc(137.77,69.59) 137.47,69.51 137.47,69.51 arc(137.47,69.51) 137.46,69.51 137.46,69.51 arc(137.17,69.59) 136.95,69.8 arc(136.6,70.01) 136.25,69.8 arc(136.23,69.77) 136.2,69.74 136.17,69.7 arc(135.97,69.56) 135.73,69.51 135.73,69.51 arc(135.44,69.59) 135.22,69.8 135.22,69.81 arc(135.09,69.94) 134.92,70 arc(134.88,70) 134.84,69.99 arc(134.81,69.98) 134.78,69.97
