# Allegro board FM85_AGILEX_PCIE_DK_CMC_ADI_REVC.brd (continued)
## Nets (continued)
N31559457: R63.1 U11.E9(ZQ1)
N32052935: C563.1 EU1.2 R454.1
N32053041: C563.2 EU1.3 R455.1
N32230321: R480.1 U45.4 U47.5
N32230341: R479.2 R484.2 U47.3
N32230392: R484.1 R486.1 U47.2
N32230759: U44.4 U46.3
N32232827: U49.4 U51.3
N32233406: R493.1 U50.4 U52.5
N32233436: R492.2 R496.2 U52.3
N32233467: R491.2 R495.1 U52.8
N32233496: R496.1 R497.1 U52.2
N32233958: R501.1 SW6.4
N32406903: R503.1 SW6.6
N32408103: R478.2 R482.1 U47.8
N32408438: R500.2 R502.2 U53.3
N32408441: R502.1 R505.1 U53.4
N33771526: D6.C(CATHODE) Q8.3 R358.2
N33771550: D6.A R357.1
N34054433: D9.A R362.1
N34315909: C491.2 R368.2
N34315982: C492.2 R369.2
N34474357: R313.1 U27.2
N34474360: R314.1 U27.3
N36112579: R207.2 SW2.6
N36112582: R206.2 SW2.7
N36112585: R204.2 SW2.8
N36226098: C493.2 R370.2
N36270051: R324.1 U28.13
N36270054: R325.1 U28.12
N36270340: R320.2 SW4.8
N36315991: R815.2 U84.9
N36316045: R816.2 R817.1 R818.2 U84.7
N36316148: C985.1 R819.1 R820.1 U84.1
N36316409: R821.2 U85.9
N36316465: R822.2 R823.1 R824.2 U85.7
N36316589: C998.1 R825.1 R826.1 U85.1
N36344563: R284.2 SW3.5(B4)
N36344586: R285.2 SW3.6
N36344607: R286.2 SW3.7
N36348634: R837.1 U87.4 U88.5
N36348657: R836.2 U88.4
N36348739: R838.1 R839.1 R840.2 U88.8
N36541668: D1.A R338.1
N36541743: D2.3 R342.1
N36541790: D2.1 R343.1
N36541991: D3.A R350.1
N36542034: D4.3 R354.1
N36542055: D4.1 R355.1
N36542312: D1.C(CATHODE) Q1.3
N36542538: D2.4 Q2.3
N36542543: D2.2 Q3.3
N36542635: D3.C(CATHODE) Q4.3
N36542846: D4.4 Q5.3
N36542851: D4.2 Q6.3
N37651435: C319.2 R159.2
N37651438: C321.2 R160.2
N37651441: C323.2 R161.2
N37651444: C324.2 R162.2
N37651447: C325.2 R163.2
N37651450: C327.2 R164.2
N37651453: C329.2 R165.2
N37651456: C330.2 R166.2
N37651459: C331.2 R167.2
N37651462: C333.2 R168.2
N37651465: C335.2 R169.2
N37925832: C579.2 R480.2
N37926031: C589.2 R493.2
N39073276: R39.1 U7.F9
N39073371: R40.1 U8.F9
N39073461: R41.1 U7.E9(ZQ1)
N39073464: R42.1 U8.E9(ZQ1)
N39075525: R45.1 U9.F9
N39075684: R46.1 U10.F9
N39075769: R47.1 U9.E9(ZQ1)
N39075772: R48.1 U10.E9(ZQ1)
N39077807: C98.1 R35.1 R36.1
N39077887: R24.1 U5.F9
N39077990: R13.2 U5.A3
N39077991: R14.2 U5.B8
N39077992: R15.2 U5.C3
N39077993: R16.2 U5.C7
N39077994: R17.2 U5.C2
N39077995: R18.2 U5.C8
N39077996: R19.2 U5.D3
N39077997: R20.2 U5.D7
N39078014: R21.2 U5.E2
N39078018: R22.2 U5.B7
N39078019: R23.2 U5.A7
N39078023: R25.1 U5.E9(ZQ1)
N40033287: R210.2 U6.LP71
N40033916: C392.1 R209.2 R213.1 U6.KW68 U21.1(VO)
N40168095: R194.2 U6.EP26
N40168098: R194.1 U6.EU27
N40226134: R141.1 U6.HP73
N40226137: R141.2 U6.HU74
N40226161: R139.1 U6.EK74
N40226164: R139.2 U6.EF73
N40287496: C455.1 U23.3 Y2.3
N40287524: C464.1 U23.4(XOUT) Y2.1
N40288703: R258.2 U23.10
N40288707: R261.2 U23.9
N40297214: R182.1 U6.EA68
N40297218: R182.2 U6.DV70
N40355462: R208.2 SW2.5(B4)
N40362320: R440.2 U39.6
N40362341: R443.2 U39.4
N40362434: R446.2 U41.6
N40362458: R447.2 U41.4
N40423539: R184.1 R6297.2 U17.4(Y)
N40460971: R197.1 U6.GL27
N40460975: R197.2 U6.GH26
N40489939: R444.2 U40.10
N40492779: R457.2 U42.10
N40558736: R171.1 R175.2 U16.3
N40558738: R172.1 R176.2 U16.2
N40558740: R170.1 R177.2 U16.1
N40558777: R173.1 R174.2 U16.7(WP)
N40559506: R462.1 R467.2 U43.3
N40559508: R463.1 R468.2 U43.2
N40559510: R464.1 R469.2 U43.1
N40559585: R466.1 U43.7(WC_N)
N40562266: C305.2 U14.32
N40564050: J3.8 R121.1 R122.1
N40564634: J4.8 R126.1 R127.1
N40632752: R145.1 R146.1 U6.JH62
N40710074: C821.1 U69.25
N40710102: C822.2 R669.2 U69.24
N40710172: R670.1 U69.27
N40710190: C824.1 R674.2 R675.2 U69.23
N40710194: C824.2 R674.1 R678.2
N40710315: R675.1 R677.2 U69.22(VOUTM)
N40710340: TP15.1 U69.1
N40710582: L21.1 U69.9 U69.10 U69.11 U69.12 U69.13 U69.14
N40803427: J1.235 R79.2
N40814737: J2.1 J2.145 R95.2 R96.2
N40815384: J2.235 R97.2
N40816526: J2.288 R107.2
N41064371: C804.1 U68.25
N41064404: C805.2 R657.2 U68.24
N41064465: R658.1 U68.27
N41064483: C807.1 R659.2 R661.2 U68.23
N41064487: C807.2 R659.1 R666.2
N41064609: R661.1 R665.2 U68.22(VOUTM)
N41064634: TP14.1 U68.1
N41064896: L20.1 U68.9 U68.10 U68.11 U68.12 U68.13 U68.14
N41103719: R287.2 SW3.8
N41105372: C564.1 EU1.4 R456.1
N41105376: C564.2 EU1.5 R458.1
N41105458: C566.1 EU1.6 R459.1
N41105462: C566.2 EU1.7 R461.1
N41106635: EU1.10 R460.1
N41107356: C568.2 EU2.3 R471.1
N41107358: C568.1 EU2.2 R470.1
N41107415: C569.2 EU2.5 R473.1
N41107417: C569.1 EU2.4 R472.1
N41107474: C571.2 EU2.7 R475.1
N41107476: C571.1 EU2.6 R474.1
N41107506: EU2.10 R476.1
N41802473: J9.3(TACH) R414.1
N42584695: C1286.2 R854.2
N42710822: R859.1 U30.13
N42710832: R858.1 U30.12
N42980348: R865.1 R866.2 U6.JU61
N42980629: R867.1 U6.HR63
N44631565: R927.1 U19.1
N45051576: C1327.1 U71.25
N45051609: C1328.2 R943.1 U71.24
N45051685: R944.1 U71.27
N45051689: C1330.1 R945.2 R947.1 U71.23
N45051693: C1330.2 R945.1 R952.2
N45051842: TP18.1 U71.1
N45051844: R947.2 R951.2 U71.22(VOUTM)
N45052102: L22.1 U71.9 U71.10 U71.11 U71.12 U71.13 U71.14
N45054348: C1345.1 U66.E2
N45054411: C1346.1 R955.1 R957.2 U66.B3
N45054431: TP20.1 U66.F2
N45054433: TP19.1 U66.B7
N45054462: R956.1 U66.A6
N45054466: C1347.1 R958.2 R959.2 U66.D1
N45054537: R957.1 R960.2 U66.G5
N45054575: R978.1 U66.E1
N45054598: R958.1 U66.F1
N45054604: C1348.1 R959.1
N45054651: R980.1 U66.D2
N45054838: C1356.2 R964.2 U66.C1
N45056577: C1366.1 U67.E2
N45056642: C1367.1 R965.1 R967.2 U67.B3
N45056662: TP21.1 U67.F2
N45056664: TP22.1 U67.B7
N45056693: R966.1 U67.A6
N45056697: C1368.1 R969.2 R971.2 U67.D1
N45056768: R967.1 R972.2 U67.G5
N45056806: R970.1 U67.E1
N45056829: R969.1 U67.F1
N45056835: C1369.1 R971.1
N45056882: R981.1 U67.D2
N45057066: C1388.2 R976.2 U67.C1
N45214136: R982.2 U42.14
N45280572: C1393.2 R985.2 R986.2
N45280837: C1394.2 R987.2 R988.2
N45286790: C1399.2 R993.2 R996.2
N45286851: C1400.2 R997.2 R998.2
N45349000: R1000.2 R1001.1 U17.1
N46887455: R2692.1 U103.D3
N46887476: R2691.1 U103.D2
N46887502: R2693.1 U103.C4
N46887527: R2694.1 U103.D4
N46887553: R2695.1 U103.D5
N46887581: R2696.1 U103.E3
N46887604: R2697.1 U103.E2
N46887630: R2698.1 U103.E1
N46986379: C494.1 MTH1.1(GND) MTH4.1(GND) R371.2
N46987350: R2715.2 U107.18
N46987353: R2716.2 U107.23
N46993584: J10.8 R2734.1
N46996106: J10.2 R6183.1
N46996953: J10.7 R2735.2
N47009841: R2738.2 R2739.1 TP951.1 U6.J35
N47015448: D14.C(CATHODE) Q15.3
N47015450: D14.A R2741.1
N47031477: R384.1 Y4.1
N47031519: R385.2 Y4.3
N47056010: R2779.2 U108.9
N47056063: R2780.2 R2781.1 R2782.2 U108.7
N47056195: C7434.1 R2783.1 R2784.1 U108.1
N47788591: C1714.1 U119.31
N47788598: C1716.1 U119.30
N47788631: C1715.1 U119.28
N47788711: R6026.2 U119.22
N47788713: R5870.2 U119.23
N47788715: R5871.2 U119.24
N47788717: R5873.2 U119.25
N47790152: C7669.2 C7670.2 C7671.2 C7672.2 R5881.1 R5882.1 R5883.1 R6035.1 R6194.1
N47791843: R6040.2 U120.35
N47793696: R5886.2 U121.35
N47795663: R5891.2 U125.35
N47798128: R5894.2 U126.35
N47813492: R6008.2 U128.A4
N47813514: C7522.2 U128.A2
N47814473: C1309.2 C1310.1 FB40.2 U132.1 U132.2
N47814553: R923.1 R925.2 U132.6
N47814610: C1313.1 R921.2 U132.7(SET)
N47814650: R917.1 U132.5
N47815277: R6002.2 U133.A4
N47815307: R6003.2 R6004.1 R6005.2 U133.A3
N47815315: C7518.2 U133.A2
N47816801: R2786.2 U134.A4
N47816829: R6171.2 R6172.1 R6173.2 U134.A3
N47816837: C7439.2 U134.A2
N47816940: C7725.1 R2785.2 U134.B1
N47819054: TP1001.1(TP) U135.D12
N47819056: TP1002.1(TP) U135.E8
N47819060: C7464.2 R5952.1 U135.K1
N47819062: C7464.1 R5953.1 U135.J1
N47819276: R5949.2 U135.F12
N47819301: R5955.2 U135.D1
N47819873: U135.J8 U135.J11
N47819899: U135.D8 U135.J10
N47819921: R768.1 U135.E11 U135.E12
N47819951: R5950.2 U135.C12 U135.E10
N47819992: R6165.1 R6283.1 R6284.2 U135.F11 U135.G12
N47820049: R6169.2 U135.F8
N47820094: R6170.2 U135.E9
N47820137: C7461.1 U135.D10 U135.J9
N47820145: R5956.2 U135.G11
N47820149: C7462.1 U135.C10 U135.H9
N47820157: R5957.2 U135.H12
N47820167: R5958.2 U135.D11
N47820169: R5959.2 U135.K12
N47820215: R5948.1 U135.C11(WP)
N47824485: U118.J3 U118.K3
N47824624: R5836.2 U118.J6
N47824941: R5837.1 U118.F7 U118.G7
N47824971: R5838.2 R6054.2 U118.F9
N47825075: R5839.1 U118.E5
N47825077: R5840.1 U118.H5
N47825108: R5845.1 R5847.1 U118.E3
N47825137: D17.2 R6146.1 U118.E2
N47825141: U118.C3 U118.D3
N47825168: R5848.2 U118.K4(WP)
N47825183: R5841.1 R5850.1 R6148.2 U118.F3 U118.F4
N47825220: TP1006.1 U118.J4
N47825281: R5923.2 U118.G2
N47825319: R5924.1 U118.H2
N47825365: R5853.2 U118.G3 U118.G4
N47825375: R5854.2 U118.H3 U118.H4
N47828123: U136.J3 U136.K3
N47828262: R5926.2 U136.J6
N47828572: R5927.1 U136.F7 U136.G7
N47828706: R5929.1 U136.E5
N47828708: R5930.1 U136.H5
N47828718: R5940.1 R5941.2 R6147.1 U136.F3 U136.F4
N47828739: R5934.1 R5937.1 U136.E3
N47828768: D18.2 R5936.1 U136.E2
N47828772: U136.C3 U136.D3
N47828796: R5938.2 U136.K4(WP)
N47828848: TP1007.1 U136.J4
N47828909: R5944.2 U136.G2
N47828945: R5945.1 U136.H2
N47828991: R5946.2 U136.G3 U136.G4
N47829001: R5947.2 U136.H3 U136.H4
N47866759: C7563.1 U131.7
N47871117: C7718.1 R6051.1 U129.B1
N47871122: C7569.1 R6051.2
N47871485: C7566.2 R6048.2 R6049.2 U129.C1
N47872099: L26.1 R6050.1 U129.A2
N47874483: C7567.1 U129.C2(SS/REFIN)
N47990323: R6166.1 R6167.2 R6168.1 U117.C3 U117.C5 U117.E3 U117.E5
N48002409: R5928.2 R6056.2 U136.F9
N48253770: TP1000.1(TP) U118.J5
N48264639: C7715.2 R6082.2 U138.A7 U138.D7 U138.G7 U138.J7
N48264690: C7721.1 U138.B7 U138.E7 U138.H7 U138.L7
N48264694: U138.B6 U138.C4
N48264698: C1967.2 U138.A6 U138.D6 U138.G6 U138.K6
N48264773: U138.E6 U138.F4
N48264853: U138.H6 U138.J4
N48264943: U138.K5 U138.L6
N48264979: R6043.1 R6082.1
N48265099: R6044.1 U138.F3
N48270066: C7716.2 R6087.2 U139.A7 U139.D7 U139.G7 U139.J7
N48270081: C7722.1 U139.B7 U139.E7 U139.H7 U139.L7
N48270093: U139.B6 U139.C4
N48270097: C7615.2 U139.A6 U139.D6 U139.G6 U139.K6
N48270166: U139.E6 U139.F4
N48270246: U139.H6 U139.J4
N48270336: U139.K5 U139.L6
N48270376: R6087.1 R6088.1
N48273834: C7717.2 R6013.1 U114.A7 U114.D7 U114.G7 U114.J7
N48273885: C7720.1 U114.B7 U114.E7 U114.H7 U114.L7
N48273889: U114.B6 U114.C4
N48273893: C7625.2 U114.A6 U114.D6 U114.G6 U114.K6
N48273968: U114.E6 U114.F4
N48274048: U114.H6 U114.J4
N48274138: U114.K5 U114.L6
N48274174: R6013.2 R6095.1
N48274294: R6096.1 U114.F3
N48280620: R6098.2 U124.A4
N48280647: C7627.2 U124.A2
N48285679: R6108.2 U123.C5
N48285771: R6101.2 U123.A4
N48285810: C7631.2 U123.A2
N48285872: R6102.1 U123.A3
N48285918: C7698.1 R6103.2 U123.B1
N48287444: R6104.2 U142.A4
N48287466: C7637.2 U142.A2
N48350242: R6061.1 U141.5
N48490558: C7560.1 U130.7
N48495332: R6077.2 R6078.2 U117.E4
N48553342: R6076.1 TP1004.1 U116.B4 U116.D4
N48553533: R6069.1 U116.B2 U116.D2
N48553549: U116.A5 U116.E5
N48553573: R6075.1 U116.C5
N48553577: C7665.1 U116.A3 U116.E3
N48553581: C7683.1 R6053.1 U116.A4 U116.E4
N48553597: R6074.1 U116.C4
N48746840: R6109.2 U123.C4
N48746952: R6110.2 U123.B2
N48746955: R6109.1 R6110.1 R6111.1 R6112.2
N48747048: C7642.1 R6112.1 U123.A1
N48779487: C7643.1 R6116.1 U124.A1
N48779506: R6115.1 R6116.2 R6117.1 R6118.1
N48779510: R6117.2 U124.B2
N48779522: R6118.2 U124.C4
N48779884: R6119.2 U124.C5
N48784258: R6121.2 U128.C5
N48784266: R6122.1 R6123.2 R6124.1 R6125.1
N48784300: C7644.1 R6123.1 U128.A1
N48784323: R6124.2 U128.B2
N48784335: R6125.2 U128.C4
N48786358: R6127.2 U142.C5
N48786366: R6128.2 R6129.2 R6130.1 R6131.1
N48786400: C7645.1 R6129.1 U142.A1
N48786423: R6130.2 U142.B2
N48786435: R6131.2 U142.C4
N48792622: R6132.1 U124.A3
N48792865: R6133.1 U128.A3
N48792977: R6134.1 U142.A3
N48794434: R6136.1 R6137.2 R6138.1 R6139.1
N48794462: C7651.1 R6137.1 U133.A1
N48794485: R6138.2 U133.B2
N48794497: R6139.2 U133.C4
N48795285: C7652.1 R6142.1 U134.A1
N48795308: R6143.2 U134.B2
N48795320: R6144.2 U134.C4
N48795608: R6141.1 R6142.2 R6143.1 R6144.1
N48797650: C7702.1 R6100.2 U124.B1
N48797862: C7706.1 R6106.2 U142.B1
N48798047: C7707.1 R6012.2 U128.B1
N48798268: C7711.1 R6006.2 U133.B1
N48809318: R5842.1 U118.F2
N48810027: R5931.1 U136.F2
N48818747: C2004.1 R6156.2
N48818862: C7660.1 R6154.2
N48819944: R5939.2 U136.D6
N48819947: R5939.1 R6158.2 U136.E6
N48820208: R5849.2 U118.D6
N48820211: R5849.1 R6159.2 U118.E6
N49230432: J8.4 R373.2
N49230501: S4.1 U33.3
N49230785: R378.2 U143.13
N49281976: R2707.2 U105.10
N49282986: R412.2 SW8.6
N49300504: R6186.1 U34.E8
N49304849: R6187.2 R6188.1 U34.F8
N49308651: R2714.2 U106.10
N49328720: R6185.1 U34.F7
N49421487: R6196.2 U119.21
N49460376: C7681.1 U121.36
N49467702: C7682.1 U120.36
N49512760: C7691.1 U126.36
N49513184: C7692.1 U125.36
N49539229: R6201.2 U118.E7
N49540456: TP29.1(TP) U136.J5
N49541279: R6202.2 U136.E7
N49586047: R6089.1 U139.F3
N49664632: C7723.1 R2794.1 U117.C1
N49665924: R6219.2 U123.C2
N49666814: R6220.2 U124.C2
N49667985: R6221.2 U142.C2
N49668581: R6222.2 U128.C2
N49934644: R6255.2 U120.34
N49934684: R6256.2 U121.34
N49934953: R6257.2 U125.34
N49934989: R6258.2 U126.34
N49972833: R6260.2 U129.B2
N50006329: C7761.1 U137.25
N50006362: C7781.1 R6262.1 U137.24
N50006438: R6263.1 U137.27
N50006442: C7764.1 R6264.2 R6266.2 U137.23
N50006446: C7764.2 R6266.1 R6271.2
N50006595: TP1005.1 U137.1
N50006597: R6270.2 R6288.1 U137.22(VOUTM)
N50006631: C7765.1 R6268.1 U137.3
N50006855: L30.1 U137.9 U137.10 U137.11 U137.12 U137.13 U137.14
N50087078: R6273.2 U120.32
N50087130: R6274.2 U121.32
N50087259: R6275.2 U125.32
N50087315: R6276.2 U126.32
N50532265: C7780.1 R6262.2
N51024969: R2794.2 R6287.2
N51025331: R6264.1 R6288.2
N51307354: R6195.1 U119.27
N51308385: R6065.2 U119.19
N51791916: R6279.2 U119.13
N51798670: R6292.1 U119.35
N51913133: R196.1 R6299.2 U19.4(Y)
N51915113: R6304.1 R6305.1 U6.JP26
N51915123: R6302.1 R6303.1 U6.JL27
N51917930: R6306.1 R6307.1 U6.HM26
N51946602: R6309.1 R6310.1 U6.FM26
N51951812: R6312.1 R6313.1 U6.CN68
N363486630: C1006.1 R837.2
N403487415: J10.1 R2736.1
N410618580: C823.1 R669.1
N410644160: C806.1 R657.1
N450516220: C1329.1 R943.2
N478710411: C7568.1 R6050.2

Pads without a net: J1 144 205 227; J2 144 205 227; J3 46 47 49 50 65 66 69 77 78; J4 46 47 49 50 65 66 69 77 78; J6 A26 A27 B8 B26 B27 B29 B30; J7 A8 A9 A26 A27 B8 B9 B26 B27; J10 6; MTH2 1; MTH5 1; NOREF#10 1; NOREF#12 1; NOREF#18 1; NOREF#21 1; NOREF#27 1; NOREF#49 1; NOREF#51 1; NOREF#60 1; NOREF#71 1; NOREF#82 1; NOREF#83 1; NOREF#92 1; NOREF#94 1; NOREF#105 1; NOREF#109 1; NOREF#118 1; NOREF#119 1; NOREF#120 1; SW5 1 8; SW6 1 2 3; SW8 4 5; U6 AB1 AB6 AB14 AB18 AE3 AE16 AK36 AK42 AK48 AK54 AK60 AT26 AT36 B43 B47 B49 B51 B53 B55 B57 BC33 BF30 BF36 BF42 BF48 BF54 BF60 BJ27 BJ31 BJ33 BM26 BM28 BM32 BM34 BM66 BR63 BR65 BV26 BV28 BV30 BV32 BV34 BV60 BV64 BV70 CA27 CA29 CA31 CA33 CA35 CD26 CD28 CD30 CD32 CD34 CD56 CD70 CG27 CG29 CG31 CG33 CG35 CG57 CG59 CG68 CK56 CN27 CN29 CN31 CN33 CN35 CN57 CR26 CR30 CR32 CR34 CR36 CU27 CU31 CU33 CU35 CY26 CY28 CY32 CY34 CY36 CY70 D7 D40 D48 D50 D52 D54 D56 D58 D62 DC27 DC29 DC31 DC35 DC68 DF26 DF28 DF70 DJ27 DJ68 DM26 DR27 DU82 DV26 DY73 DY81 EA27 EC74 EJ26 EK72 EK82 EL27 EN73 EN81 FB82 FE73 FE81 FG10 FG22 FK8 FK20 FL73 FM70 FN1 FN14 FP72 FP82 FT3 FT16 FU81 FV26 FV70 FW10 FW22 FY72 GA27 GB8 GB20 GD26 GE1 GE14 GF27 GJ3 GJ16 GM10 GM22 GP26 GP70 GR8 GR20 GU27 GV1 GV14 GY26 GY70 H15 H26 H32 H50 H52 H54 H56 H58 H62 HA3 HA16 HC27 HC59 HC68 HD10 HD22 HF26 HF58 HF70 HG8 HG20 HJ27 HJ61 HJ63 HJ65 HK1 HK14 HM58 HM64 HN3 HN16 HR57 HR61 HR65 HR68 HT10 HT22 HV32 HV60 HV62 HV64 HW8 HW20 HY31 HY33 HY35 HY61 HY68 J5 J39 J47 J51 J53 J55 J57 J63 JB28 JB32 JB34 JB62 JB64 JB70 JC1 JC14 JE29 JE31 JE33 JE35 JE63 JE65 JE68 JF3 JF16 JH60 JH64 JJ10 JJ22 JL29 JL31 JL37 JL63 JL65 JM8 JM20 JP28 JP30 JP36 JP66 JR1 JR14 JU63 JU65 JV3 JV16 JY28 JY30 JY32 JY34 JY60 JY62 JY66 KA10 KA22 KC31 KC35 KC68 KD8 KD20 KF26 KF28 KF56 KF58 KF62 KF64 KF70 KG1 KG14 KJ29 KJ31 KJ57 KJ65 KK3 KK16 KN10 KN22 KR27 KR31 KR57 KR61 KR65 KT8 KT20 KU26 KU28 KU30 KU56 KU58 KU60 KU66 KW65 KY1 KY14 L23 L26 L28 L48 L50 L52 LB56 LC3 LC16 LF10 LF22 LH56 LJ20 LJ24 LL57 LN50 LR49 LW51 LW53 MA52 MF2 ML81 N13 N21 N25 N27 N47 N49 N51 U13 U17 U27 U45 U47 U49 U51 W7 W26 W28 W38 W48 W50 W52 W56; U12 6 9; U13 4 5 6 9 10 11; U14 3 6 7 8 10 11 12 13 14 15 16 17 18 19 29 30 31 33 34 37 42 44 45 46 47 48 49 50 51 52 53; U15 2 3 6 9 12 13; U18 6 9; U21 3; U22 1 2 5 12 14 15 25 47 48 50 58 61 62 63 64; U23 20 28 30; U24 5 6 21 22 26 27 28 29 30 33 34 35 38 39 40; U25 5 6 10 23 24 26 27 28 29 30 33 34 35 38 39 40; U28 4 5 6 9 10 11; U29 4 5 6 9 10 11; U30 4 5 6 9 10 11; U31 6 9; U32 6 9; U34 A10 A13 G12; U36 A2 A3 A5 B1 B5 C1 C3 C5 D1 D5 E1 E2 E3 E4 E5; U42 8 13; U46 5; U48 3 7; U51 5; U68 21; U69 21; U71 21; U88 7; U103 A2 A5 B5 C2 C5; U104 A2 A3 A5 B1 B5 C1 C3 C5 D1 D5 E1 E2 E3 E4 E5; U105 6 9 12 15; U106 1 3 5 16 18 20; U114 C2 C7 F2 J2 J3; U117 D1 D6 D7; U118 B8 D8 E8 J7 L8; U119 26 34 36 37 38 39 42 45 46 49; U120 23 24 25 26; U121 23 24 25 26; U123 A5 B5; U124 A5 B5; U125 23 24 25 26; U126 23 24 25 26; U128 A5 B5; U130 8; U131 8; U133 A5 B5; U134 A5 B5; U135 A1 A2 B2 L2 M1 M2; U136 B8 D8 E8 J7 L8; U137 21; U138 C2 C7 F2 J2 J3; U139 C2 C7 F2 J2 J3; U142 A5 B5; U143 54

## Via types
v1: diameter 0.406, hole 0.203, TOP to BOTTOM, 8219 vias
v2: diameter 0.406, hole 0.254, TOP to L03_SIG1, 342 vias
v3: diameter 0.508, hole 0.254, TOP to BOTTOM, 264 vias
v4: diameter 0.559, hole 0.305, TOP to BOTTOM, 786 vias
v5: diameter 0.406, hole 0.254, L16_SIG6 to BOTTOM, 80 vias
v6: diameter 0.399, hole 0.203, TOP to BOTTOM, 32 vias
v7: diameter 0.6, hole 0.254, TOP to BOTTOM, 192 vias
v8: diameter 0.762, hole 0.508, TOP to BOTTOM, 101 vias
v9: diameter 0.406, hole 0.254, TOP to L02_GND1, 178 vias
v10: diameter 0.406, hole 0.254, L17_GND8 to BOTTOM, 246 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
5V: length 2.1
  BOTTOM w0.305: R357.2 249.07,45.93 v1(248.81,45.67)
  BOTTOM w0.381: R6056.1 71.52,76.56 v1(71.94,76.14)
  vias: v1(5.75,44.73) v1(5.93,42.73) v1(5.93,41.46) v1(8.49,36.78) v1(15.42,41.43) v1(15.42,39.35) v1(16.43,57.01) v1(17.18,42.9) v1(17.18,41.63) v1(19.72,36.93) v1(23.32,57.1) v1(23.88,55.91) v1(24.59,57.1) v1(24.58,55.77) v1(24.57,55.07) v1(25.35,55.83) v1(27.31,39.53) v1(27.59,44) v1(27.59,42.98) v1(27.57,41.79) v1(27.57,40.77) v1(29.06,43) v1(29.06,41.73) v1(34.35,85.87) v1(34.36,84.5) v1(35.11,84.47) v1(71.97,74.04) v1(192.91,80.72) v1(195.32,81.99) v1(196.27,81.85) v1(233.15,60.05) v1(234.42,61.32) v1(234.42,60.05) v1(235.69,61.32) v1(235.69,60.05) v1(238.26,58.12) v1(238.89,58.12) v1(239.53,58.12) v1(240.8,58.14) v1(241.43,58.14) v1(242.07,58.14)
5V_AGND: length 0.5
  BOTTOM w0.381: R588.2 v1(231.88,63.86)
  vias: v1(228.92,61.32) v1(228.92,60.51) v1(229.03,63.86)
5V_PG: length 288.2
  L12_SIG4 w0.127: v1(233.15,61.32) 233.15,60.76 235.7,58.22 236.13,58.22 237.66,56.68 237.85,56.68 239.62,54.91 239.62,49.75 234.54,44.67 234.54,44.41 234.44,44.31 234.44,44.03 234.54,43.94 234.54,43.59 234.44,43.5 234.44,42.99 234.54,42.9 234.54,42.55 234.44,42.46 234.44,42.18 234.54,42.09 234.54,41.74 234.44,41.65 234.44,39.37 234.64,39.17 234.64,38.1 234.27,37.72 234.27,36.41 234.89,35.78 235.34,35.78 241.94,29.18 241.94,18.8 241.05,17.91 241.05,16.43 240.53,15.91 229.62,15.91 228.73,15.02 227.59,15.02 225.97,16.64 224.77,16.64 224.3,16.17 221.74,16.17 220.43,17.48 213.69,17.48 211.61,15.4 206.69,15.4 206.45,15.64 197.91,15.64 197.34,16.21 194.88,16.21 194.34,15.66 193.99,15.66 193.28,16.37 187.06,16.37 186.87,16.18 183.82,16.18 183.43,16.57 180.43,16.57 179.96,17.04 175.77,17.04 175.51,16.77 172.23,16.77 171.79,16.33 169.88,16.33 169.46,16.75 168.94,16.75 168.66,16.47 164.75,16.47 164.47,16.75 164.14,16.75 163.86,16.47 159.49,16.47 159.17,16.79 158.68,16.79 158.36,16.47 149.23,16.47 148.95,16.75 148.62,16.75 148.34,16.47 139.07,16.47 138.79,16.75 138.46,16.75 138.17,16.46 136.19,16.46 134.07,14.33 128.43,14.33 128.18,14.58 114.49,14.58 113.49,13.58 66.69,13.58 65.78,14.49 65.78,17.35 64.01,19.12 61.38,19.12 59.75,17.48 51.91,17.48 51.5,17.89 47.98,17.89 47.51,18.36 45.46,18.36 44.7,19.12 44.7,19.37 43.25,20.82 39.23,20.82 38.54,21.51 35.33,21.51 35.1,21.74 35.1,21.85 34.62,22.33 32.51,22.33 31.96,22.88 31.96,22.99 31.66,23.3 31.6,23.3 31.1,23.79 31.1,27.95 31.96,28.81 31.96,30.37 v1(32.5,30.9)
  BOTTOM w0.254: R578.1 232.52,61.29 R579.1 v1(233.15,61.32)
12V_AUX: length 0.7
  TOP w0.229: U46.2 v1(227.21,91.77)
  vias: v4(228.22,94.03) v4(228.22,93.14) v4(229.74,94.03) v4(229.74,93.14) v8(223.78,97.36) v8(223.78,95.96) v8(225.18,97.36) v8(225.18,95.96) v8(226.58,97.36) v8(226.58,95.96) v8(228.1,97.36) v8(228.1,95.96) v8(229.51,97.33) v8(230.88,97.37) v8(232.29,91.14) v8(232.29,90.12) v8(232.29,89.11) v8(232.67,97.36) v8(233.56,92.92) v8(233.56,91.65) v8(233.56,90.38) v8(233.56,89.11) v8(236.92,100) v8(236.99,98.86) v8(238.72,99.99) v8(238.77,98.86) v8(240.55,98.86) v8(242.32,98.38) v8(242.32,96.6) v8(242.32,94.82) v8(242.32,93.04) v8(242.32,91.26) v8(242.32,89.49) v8(242.32,87.71) v8(242.32,85.93) v8(243.97,98.38) v8(243.97,96.6) v8(243.97,94.82) v8(243.97,93.04) v8(243.97,91.26) v8(243.97,89.49) v8(243.97,87.71) v8(243.97,85.93)
12V_G1: length 5.2
  TOP w0.149: U119.32 184.19,59.34 184.24,59.39
  TOP w0.381: R6069.2 196.45,64.14 arc(196.45,64.14) v1(196.45,64.14) ; 238.13,80.85 240.42,80.85 240.67,80.6 R500.1
  BOTTOM w0.254: U47.6 241.06,77.68 v1(241.22,77.84)
  vias: v1(185.2,60.02) v1(185.94,59.98) v1(186.87,60.03) v1(188.14,60.03) v1(196.43,59.15) v1(197.21,98.05) v1(197.29,97.44) v1(197.64,105.02) v1(197.66,105.61) v1(197.67,103.54) v1(197.67,102.58) v1(197.67,96.17) v1(197.67,95.2) v4(171.66,74.97) v4(171.72,57.49) v4(171.75,47.87) v4(171.72,42.64) v4(171.73,41.65) v4(171.73,41.09) v4(171.73,40.05) v4(171.76,85.48) v4(171.77,84.49) v4(171.77,83.93) v4(171.75,82.95) v4(171.81,56.45) v4(171.81,55.9) v4(171.8,54.86) v4(171.77,43.19) v4(171.88,71.44) v4(171.88,70.45) v4(171.88,69.89) v4(171.88,68.85) v4(172.21,33.18) v4(172.34,82.95) v4(172.26,75.32) v4(172.25,74.64) v4(172.31,57.44) v4(172.31,47.87) v4(172.32,40.05) v4(172.43,84.48) v4(172.43,83.92) v4(172.39,54.86) v4(172.39,41.63) v4(172.39,41.07) v4(172.47,71.44) v4(172.54,70.43) v4(172.54,69.88) v4(172.47,68.85) v4(172.54,63.19) v4(172.47,56.44) v4(172.47,55.88) v4(172.51,32.64) v4(172.77,33.18) v4(172.9,47.87) v4(173.1,63.19) v4(173.33,33.18) v4(173.66,63.19) v4(231.27,75.14) v4(231.27,73.87) v4(231.27,72.34) v4(231.27,70.56) v4(231.27,69.04) v4(231.53,81.49) v4(231.53,80.22) v4(231.53,78.95) v4(232.8,84.03) v4(232.8,83.26) v4(232.8,82.5) v4(232.8,81.49) v4(232.8,80.22) v4(232.8,78.95) v4(232.8,75.14) v4(232.8,73.87) v4(232.8,72.34) v4(232.8,70.56) v4(232.8,69.04) v4(234.45,70.56) v4(234.45,69.04) v4(235.85,80.22) v4(235.85,78.95) v4(235.97,70.56) v4(235.97,69.04) v4(237.37,80.22) v4(237.37,78.95) v8(232.8,86.06) v8(232.8,85.04) v8(234.32,81.49) v8(234.32,80.22) v8(234.32,78.95) v8(234.32,75.14) v8(234.32,73.87) v8(234.32,72.6) v8(235.85,81.49) v8(235.85,75.14) v8(235.85,73.87) v8(235.85,72.6) v8(237.37,81.49)
12V_G1_OV_PG: length 342.7
  TOP w0.254: v1(238.13,72.6) 238.13,73.23 238.45,73.55 R499.1 238.89,74.67 U53.6
  L05_SIG2 w0.127: v1(60.21,106) 56.47,106 53.99,103.52 53.99,99.81 52.24,98.06 46.51,98.06 43.3,94.85 43.3,92.34 42.37,91.41 32.65,91.41 28.04,86.81 28.04,77.26 28.94,76.37 28.94,68.24 28.02,67.33 28.02,64.01 29.04,62.99 29.04,60.04 30.3,58.78 30.3,52.81 30.9,52.2 30.9,45.24 31.69,44.45 33.57,44.45 35.81,42.2 35.81,37.7 34.69,36.57 34.69,35.78 35.03,35.44 35.03,35.02 33.08,33.08 33.08,32.49 v1(32.5,31.9)
  L14_SIG5 w0.127: v1(238.13,72.6) 239.01,71.72 240.83,71.72 241.43,72.32 241.43,75.01 241.94,75.52 243.36,75.52 245.63,77.79 248.74,77.79 250.81,79.86 250.81,96.68 237.72,109.77 196.63,109.77 195.89,109.03 190.38,109.03 189.23,110.18 64.05,110.18 62.53,108.65 61.24,108.65 60.21,107.62 v1(60.21,106)
12V_G1_PG: length 325.8
  L05_SIG2 w0.127: v1(34.5,29.9) 34.93,30.34 34.93,31.37 36.08,32.52 36.08,32.98 35.65,33.41 35.65,33.76 37.18,35.28 37.18,36.05 36.99,36.24 36.99,42.72 36.06,43.65 35.72,43.65 32.94,46.43 32.94,52.33 31.96,53.3 31.96,62.04 31.68,62.32 31.68,76.08 32.59,76.99 32.59,83.29 32.3,83.58 32.3,84.55 31.1,85.75 31.1,86.75 32.34,87.98 40.71,87.98 40.75,88.01 40.78,88.01 47.39,94.63 50.48,94.63 54.91,99.05 54.91,102.94 56.14,104.17 59.15,104.17 59.83,104.85 60.46,104.85 60.84,105.23 v1(60.84,106.35)
  L14_SIG5 w0.127: v1(60.84,106.35) 61.45,106.35 64.99,109.9 188.94,109.9 190.27,108.57 196.08,108.57 196.94,109.42 237.67,109.42 250.01,97.08 250.01,82.84 248.1,80.93 246.9,80.93 244.79,78.82 241.37,78.82 v1(241.31,78.76)
  BOTTOM w0.254: v1(241.31,78.76) 241.31,78.64 241.72,78.23 241.72,77.64 241.57,77.5 241.57,77.04 U47.7
12V_G1_UV_PG: length 343.3
  TOP w0.254: U53.1 241.88,74.95 242.07,74.75 v1(242.07,74.25) 242.07,73.68 R498.1
  L05_SIG2 w0.127: v1(59.62,105.21) 59.31,104.9 56.11,104.9 54.47,103.26 54.47,99.49 52.65,97.67 46.64,97.67 44.57,95.59 44.57,92.2 40.66,88.29 31.69,88.29 29.76,86.37 29.76,83.3 29.76,83.29 29.76,83.26 29.54,83.04 29.54,81.88 29.85,81.57 29.85,68.46 28.56,67.17 28.56,64.66 30.14,63.08 30.14,60.04 31.27,58.91 31.27,53.19 31.92,52.54 31.92,46.86 33.7,45.08 33.7,44.73 36.65,41.78 36.65,36.36 36.34,36.05 36.34,35.74 35.89,35.28 35.89,34.9 33.91,32.92 33.91,29.76 33.5,29.35 v1(33.5,28.9)
  L14_SIG5 w0.127: v1(242.07,74.25) 243.43,74.25 246.25,71.43 250.25,71.43 251.71,72.9 251.71,96.57 237.83,110.45 63.44,110.45 62.34,109.35 61.49,109.35 59.19,107.05 59.19,105.64 v1(59.62,105.21)
12V_G2: length 15.5
  TOP w0.381: v1(199.98,45.73) 199.99,45.74 R966.2 ; C597.2 238.13,75.07 238.13,75.36 238.67,75.9 U53.5 ; U134.D5 v1(207.75,22.53) ; v1(211.59,99.3) 211.48,99.41 C7608.1 211.48,100.47 v1(211.59,100.57) ; U136.M9 v1(77.22,75.28) ; U134.C5 v1(206.48,22.78) ; v1(71.28,38.66) v1(71.28,39.46)
  BOTTOM w0.254: 207.01,101.02 206.86,101.16 205.97,101.16 205.63,100.82
  BOTTOM w0.381: v1(186.21,21.29) C1960.1 v1(186.21,20.02) ; v1(77.22,75.28) 77.22,75.44 77.86,76.09 C1891.2 ; FB40.1 64.01,43 v1(63.41,43.61) ; C7656.2 67.68,76.03 68.23,76.57 R5928.1
  vias: v1(63.68,75.71) v1(64.95,75.71) v1(65.65,58.23) v1(65.66,57.05) v1(65.65,55.69) v1(66.22,75.71) v1(66.71,87.38) v1(67.49,75.71) v1(69.46,58.23) v1(69.46,56.96) v1(69.46,55.69) v1(70.97,40.11) v1(71.28,35.46) v1(71.28,34.66) v1(71.58,40.11) v1(71.99,89.27) v1(73.26,89.27) v1(73.27,58.23) v1(73.27,56.96) v1(73.27,55.69) v1(73.84,75.71) v1(74.53,89.27) v1(75.11,75.71) v1(76.38,75.71) v1(77.08,58.23) v1(77.08,56.96) v1(77.08,55.69) v1(182.4,22.56) v1(182.4,21.29) v1(182.4,20.02) v1(186.21,22.56) v1(190.02,22.56) v1(190.02,21.29) v1(190.02,20.02) v1(193.75,51.47) v1(193.83,21.29) v1(193.83,20.02) v1(194.27,51.55) v1(194.54,87.72) v1(194.54,86.45) v1(194.54,85.18) v1(194.54,83.91) v1(194.54,77.56) v1(194.54,76.29) v1(194.54,75.02) v1(194.54,73.75) v1(195.31,37.67) v1(195.55,45.68) v1(196.14,45.8) v1(196.1,45.22) v1(198.95,55.02) v1(202.19,53.42) v1(202.19,52.62) v1(202.99,53.42) v1(202.99,52.62) v1(203.79,53.42) v1(204.1,45.04) v1(204.1,44.24) v1(204.63,100.15) v1(204.63,99.65) v1(204.59,53.42) v1(204.9,45.04) v1(204.9,44.24) v1(205.26,100.15) v1(205.26,99.65) v1(205.52,53.09) v1(205.7,45.04) v1(205.9,100.15) v1(205.9,99.65) v1(206.31,52.63) v1(206.5,45.04) v1(207.09,52.63) v1(207.14,51.87) v1(207.25,50.96) v1(207.78,101.84) v1(207.78,100.57) v1(207.78,99.3) v1(208.52,22.02) v1(208.69,43.94) v1(208.69,43.18) v1(209.13,44.68) v1(209.18,43.56) v1(209.66,43.92) v1(210.27,50.05) v1(211.59,101.84) v1(215.4,101.84) v1(215.4,100.57) v1(215.4,99.3) v1(219.21,101.84) v1(219.21,100.57) v1(219.21,99.3) v1(220.04,100.15) v1(220.04,99.65) v1(220.67,100.15) v1(220.67,99.65) v1(221.31,100.15) v1(221.31,99.65) v1(226.12,43.55) v1(226.14,42.96) v1(226.09,42.15) v1(226.12,41.57) v1(226.88,43.55) v1(226.88,42.96) v1(226.85,42.15) v1(226.85,41.57) v1(227.72,43.54) v1(227.74,42.95) v1(227.67,42.18) v1(227.69,41.59) v1(228.43,42.18) v1(228.43,41.59) v1(228.48,43.54) v1(228.48,42.95) v1(228.99,62.63) v1(229.5,43.7) v1(230.26,43.7) v1(234.42,65.13) v1(235.69,65.13) v1(236.66,43.93) v1(236.68,43.35) v1(237.42,43.93) v1(237.42,43.35) v1(238.56,43.94) v1(238.59,43.36) v1(239.33,43.94) v1(239.33,43.36) v1(239.35,42.56) v1(239.38,41.9) v1(239.35,41.11) v1(239.38,40.37) v1(240.11,42.56) v1(240.11,41.9) v1(240.11,41.11) v1(240.11,40.37) v1(240.16,43.9) v1(240.19,43.32) v1(240.93,43.9) v1(240.93,43.32) v1(240.93,42.56) v1(240.93,41.11) v1(240.95,41.9) v1(240.95,40.37) v1(241.69,42.56) v1(241.69,41.9) v1(241.69,41.11) v1(241.69,40.37) v1(242.53,42.56) v1(242.53,41.9) v1(242.53,41.11) v1(242.53,40.37) v4(32.67,101.88) v4(32.67,101.12) v4(32.67,100.36) v4(33.94,101.88) v4(33.94,101.12) v4(33.94,100.36) v4(35.08,101.12) v4(42.83,101.37) v4(42.83,100.36) v4(44.1,101.37) v4(44.1,100.36) v4(45.37,101.37) v4(45.37,100.36) v4(46.24,101.93) v4(46.24,101.17) v4(46.24,100.41) v4(47.51,101.93) v4(47.51,101.17) v4(47.51,100.41) v4(48.65,101.17) v4(56.4,101.68) v4(56.4,100.41) v4(57.67,101.68) v4(57.67,100.41) v4(58.94,101.68) v4(58.94,100.41) v4(203.93,39.83) v4(204.04,39.25) v4(204.22,31.34) v4(204.31,30.67) v4(204.52,39.83) v4(204.61,39.26) v4(204.77,38.7) v4(204.82,31.03) v4(205.06,39.68) v4(205.17,39.12) v4(205.34,31.36) v4(205.36,30.68) v4(234.6,67.16) v4(236,67.16) v4(237.12,67.13) v4(237.09,66.17) v4(237.62,74.63) v4(238.21,67.19) v4(238.26,66.25) v4(239.5,67.16) v4(239.53,66.25) v4(240.77,67.06) v4(240.8,66.25) v4(241.1,52.9) v4(241.1,51.88) v4(241.82,52.9) v4(241.82,51.88) v4(241.89,67.08) v4(242.07,66.25) v7(195.41,87.79) v7(195.41,86.82) v7(195.43,85.85) v7(195.43,84.89) v7(195.41,83.92) v7(195.51,79.68) v7(195.51,78.72) v7(195.51,77.75) v7(195.54,76.79) v7(195.54,76.02) v7(195.54,75.26) v7(195.54,74.5) v7(195.54,73.74) v7(196.32,87.79) v7(196.32,86.82) v7(196.35,85.85) v7(196.32,83.52) v7(196.32,79.66) v7(196.32,78.69) v7(196.27,77.75) v7(196.48,76.86) v7(196.45,76.1) v7(197.24,77.75) v7(197.29,83.52) v7(197.29,82.55) v7(197.29,79.66) v7(197.29,78.69) v7(198.2,77.75) v7(198.25,83.52) v7(198.25,82.55) v7(198.25,79.66) v7(198.25,78.69) v7(199.22,83.52) v7(199.22,82.55) v7(199.22,81.59) v7(199.22,80.62) v7(199.22,79.66) v7(199.22,78.69) v7(199.17,77.75) v7(200.95,87.73) v7(201.91,87.73) v7(207.8,84.64) v7(207.81,83.2) v7(207.8,82.35) v7(207.8,78.31) v7(207.8,77.35) v7(208.19,80.93) v7(208.19,79.96) v7(208.16,76) v7(208.16,75.03) v7(208.52,84.63) v7(208.77,83.2) v7(208.77,82.35) v7(208.77,78.31) v7(208.77,77.35) v7(209.13,76) v7(209.13,75.03) v7(209.25,84.65) v7(209.15,80.93) v7(209.15,79.96)
12V_G2_PG: length 327.5
  TOP w0.254: v1(210.74,84.29) 210.93,84.29 210.99,84.36 211.58,84.36 R494.1
  L03_SIG1 w0.127: v1(35.5,30.9) 34.89,31.51 34.33,31.51 34.1,31.74 34.1,33.09 31.73,35.46 31.72,35.46 31.48,35.7 30.4,35.7 29.56,36.54 29.56,51.06 29.99,51.49 29.99,52.05 30.29,52.35 30.29,58.97 29.03,60.23 29.03,64.22 28.04,65.22 28.04,78.01 28.37,78.34 28.37,80.71 29.08,81.42 29.08,83.05 28.87,83.26 28.87,88.2 35.8,95.13 35.8,95.96 36.57,96.73 36.57,102.13 35.01,103.69 35.01,104.72 36.13,105.83 39.94,105.83 40.49,106.39 49.41,106.39 50.86,104.95 51.28,104.95 51.66,104.56 51.66,104.15 52.4,103.4 54.44,103.4 57.39,106.36 59.45,106.36 63.22,110.12 194.64,110.12 195.46,109.3 228.25,109.3 230.46,107.1 233.02,107.1 233.46,106.65 233.46,105.42 231.93,103.89 223.48,103.89 v1(222.21,102.62)
  L14_SIG5 w0.127: v1(222.21,102.62) 221.18,101.59 219.62,101.59 218.6,100.58 218.6,99.26 210.19,90.84 210.19,85.77 210.71,85.25 210.71,84.32 v1(210.74,84.29)
  BOTTOM w0.254: v1(210.74,84.29) 210.88,84.15 U52.7
12V_GROUP1: length 4.8
  BOTTOM w0.254: v1(239.85,73.36) 239.85,73.93 240.56,74.64 U47.4 ; R478.1 v1(242.2,80.93)
  BOTTOM w0.381: R501.2 244.74,80.11 v1(244,80.85)
  vias: v1(212.61,86.96) v4(218.45,89.74) v4(218.45,88.22) v4(218.45,86.69) v4(218.45,85.17) v4(219.97,89.74) v4(219.97,88.22) v4(219.97,86.69) v4(219.97,85.17) v4(221.5,89.74) v4(221.5,88.22) v4(221.5,86.69) v4(221.5,85.17) v4(223.02,89.74) v4(223.02,88.22) v4(223.02,86.69) v4(223.02,85.17) v4(223.02,83.64) v4(224.54,89.74) v4(224.54,88.22) v4(224.54,86.69) v4(224.54,85.17) v4(224.54,83.64) v4(226.07,89.74) v4(226.07,88.22) v4(226.07,86.69) v4(226.07,85.17) v4(226.07,83.64) v4(227.59,89.74) v4(227.59,88.22) v4(227.59,86.69) v4(228.86,85.3) v4(228.86,84.53) v4(228.86,83.77) v4(228.99,90.25) v4(228.99,89.49) v4(229.62,85.3) v4(229.62,84.53) v4(229.62,83.77) v4(229.75,90.25) v4(229.75,89.49) v4(230.51,90.25) v4(230.51,89.49)
12V_GROUP2: length 0
  BOTTOM w0.305: R491.1 v1(211.68,86.54)
  vias: v4(213.11,77.42) v4(213.11,76.15) v4(213.24,80.85) v4(213.24,80.09) v4(213.24,79.33) v4(213.24,74.63) v4(213.24,73.87) v4(213.24,73.1) v4(214,80.85) v4(214,80.09) v4(214,79.33) v4(214,74.63) v4(214,73.87) v4(214,73.1) v4(214.64,77.42) v4(214.64,76.15) v4(215.65,79.96) v4(215.65,78.44) v4(215.65,76.91) v4(215.65,75.39) v4(215.65,73.87) v4(215.65,72.34) v4(217.18,79.96) v4(217.18,78.44) v4(217.18,76.91) v4(217.18,75.39) v4(217.18,73.87) v4(217.18,72.34) v4(218.7,79.96) v4(218.7,78.44) v4(218.7,76.91) v4(218.7,75.39) v4(218.7,73.87) v4(218.7,72.34) v4(220.23,79.96) v4(220.23,78.44) v4(220.23,76.91) v4(220.23,75.39) v4(220.23,73.87) v4(220.23,72.34) v4(221.75,79.96) v4(221.75,78.44) v4(221.75,76.91) v4(221.75,75.39) v4(221.75,73.87) v4(221.75,72.34)
AGND_1P2V_PRE: length 2.7
  BOTTOM w0.203: C7644.2 16.39,63.95 16.66,64.21 ST23.1
  BOTTOM w0.381: C7644.2 16.63,62.93 R6012.1
AGND_1P8V_PRE: length 3.1
  TOP w0.203: ST29.1 13.47,38.23
  BOTTOM w0.203: R6106.1 v1(12.62,39.26) 13.18,39.26 13.47,38.97 C7645.2
AGND_2P5V_PRE: length 3.4
  BOTTOM w0.203: v1(35.92,36.91) 37.42,36.91 37.75,37.24 ST1.1
  BOTTOM w0.381: R6100.1 v1(35.92,36.91)
AGND_3P3V_STBY: length 3.5
  BOTTOM w0.203: C7642.2 25.38,38.15 25.38,39.12 25.18,39.32 ST2.1 24.45,39.51 R6103.1
AGND_VCCFUSEWR_SDM: length 2.6
  TOP w0.203: v1(68.19,83) 68.17,83 67.88,82.71 ST24.1
  BOTTOM w0.381: R6006.1 69.64,82.71 C7651.2 68.48,82.71 v1(68.19,83)
GND: length 869.2
  TOP w0.191: v1(174.1,85.23) 174.1,85.23 174.07,85.2 U120.31 ; ST27.2 v1(204.45,14.68) ; 237.28,37.56 237.37,37.46 ST3.2 237.37,36.35 v1(237.4,36.32) ; v1(44.42,27.13) U84.8 ; v1(174.4,68.79) 174.03,69.16 U121.27 ; U120.9 U120.8 U120.7 ; v1(193.76,67.69) 192.36,67.69 U130.6 ; U125.31 173.96,57.16 174.13,57.34 v9(174.52,57.34) ; U71.8 50.43,99.55 50.33,99.64 ; U71.17 54.67,100.55 54.66,100.53 ; U120.27 173.77,83.2 174.11,82.86 174.17,82.86 v1(174.17,82.43) ; 43.23,27.04 43.23,26.99 42.86,26.62 42.32,26.62 U84.4
  TOP w0.203: U38.13 17.03,16.28 16.81,16.06 v1(16.81,15.33) ; U38.6 18.13,19.61 v1(18.3,19.78) ; v1(174.21,71.17) 174.2,71.16 U121.31 ; U126.31 173.95,42.35 174.04,42.27 174.51,42.27 174.74,42.49 174.74,42.92 174.94,43.12 v9(175.27,43.12) ; ST13.2 176.51,34.32 v1(176.89,34.32) ; ST29.2 13.47,39.09 v1(13.8,39.42) ; ST34.1 175.04,46.1 v1(174.85,46.3) ; v1(14.36,29.11) v1(15.63,30.38) v1(16.77,31.52) 17.6,32.35 18.25,32.35 U143.28 ; v1(66.35,82.87) 66.52,82.71 ST24.2 ; U125.27 173.84,55.16 174.09,54.92 174.09,54.83 174.34,54.57 v1(174.49,54.57) ; ST26.2 v9(212.86,94.99) ; C7568.2 182.64,66.11 U129.A1
  TOP w0.225: U46.4 224.42,92.27 224.54,92.15 v1(224.54,91.65)
  TOP w0.253: v1(12.07,31.65) 11.87,31.65 11.61,31.91 U143.41 ; U143.6 13.61,26.6 13.51,26.7 v1(13.09,26.7) ; U143.14 v3(17.61,24.46) ; U143.10 15.61,26.68 v1(15.63,26.7) ; U143.56 10.33,25.86 10.08,25.61 10.08,25.31 v1(10.07,25.31) ; U143.26 16.93,31.36 v1(16.77,31.52) ; U143.12 16.61,26.54 v1(16.77,26.7) ; U143.53 v1(9.7,27.36)
  TOP w0.254: v1(217.07,45.29) J7.B1 v1(215.15,45.29) ; v1(215.15,65.09) 215.15,65.09 J7.B34 217.07,65.09 v1(217.07,65.09) ; v1(215.15,50.69) 215.15,50.69 J7.B10 ; 41.03,37.61 40.96,37.67 Y2.4 40.87,38.69 v1(40.14,38.69) ; v1(219.75,23.78) 219.75,23.78 J6.A13 v1(222.08,23.78) ; v1(215.25,57.89) 215.27,57.89 J7.B22 217.07,57.89 v1(217.07,57.89) ; J7.B28 215.34,61.49 215.12,61.27 v1(215.12,61.14) ; v1(219.72,61.49) 219.72,61.49 J7.A28 ; v3(44.71,36.53) 44.99,36.81 U23.8 ; v1(76,12.47) 75.88,12.35 75.45,12.35 ; U126.27 173.85,40.35 174.07,40.13 174.94,40.13 v1(174.95,40.14) ; v1(219.75,54.29) 219.75,54.29 J7.A16 v1(222.08,54.29) ; v1(217.07,38.18) 217.07,38.18 J6.B37 215.15,38.18 v1(215.15,38.18) ; v1(219.75,57.89) 219.75,57.89 J7.A22 v1(222.08,57.89) ; v1(45.85,41.73) 46.14,41.45 U23.32 ; v1(217.07,56.09) 217.07,56.09 J7.B19 v1(215.25,56.09) ; v1(219.75,29.18) 219.75,29.18 J6.A22 v1(222.08,29.18) ; v1(222.08,18.38) J6.A4 219.75,18.38 v1(219.75,18.38) ; v1(215.15,27.38) 215.15,27.38 J6.B19 217.07,27.38 v1(217.07,27.38) ; R159.1 v1(59.77,10.56) R166.1 ; v1(219.72,32.34) 219.72,32.59 219.91,32.78 J6.A28 ; v1(217.07,29.18) 217.07,29.18 J6.B22 215.15,29.18 v1(215.15,29.18) ; v1(215.15,25.58) 215.15,25.58 J6.B16 217.07,25.58 v1(217.07,25.58) ; v1(219.75,45.29) J7.A1 v1(222.08,45.29) ; v1(222.08,66.89) J7.A37 219.75,66.89 v1(219.75,66.89) ; v1(219.75,65.09) 219.75,65.09 J7.A34 v1(222.08,65.09) ; v1(75.43,79.33) 75.27,79.49 EU1.8 ; v1(222.08,36.38) J6.A34 219.75,36.38 v1(219.75,36.38) ; v1(222.08,38.18) J6.A37 219.75,38.18 v1(219.75,38.18) ; v1(222.08,25.58) J6.A16 219.75,25.58 v1(219.75,25.58) ; v1(222.08,59.69) J7.A25 219.75,59.69 v1(219.75,59.69) ; v1(215.15,66.89) 215.15,66.89 J7.B37 217.07,66.89 v1(217.07,66.89) ; v1(217.07,30.98) 217.07,30.98 J6.B25 215.15,30.98 v1(215.15,30.98) ; J6.B31 v1(215.17,34.58) ; v1(215.15,20.18) J6.B7 v1(217.07,20.18) ; v1(215.15,21.98) J6.B10 v1(217.07,21.98) ; v9(51.92,15.67) v9(51.92,16.82) v9(51.92,17.5) ; v1(217.07,48.89) 217.07,48.89 J7.B7 215.15,48.89 v1(215.15,48.89) ; v1(217.07,16.58) J6.B1 v1(215.15,16.58) ; v1(222.08,48.89) J7.A7 219.75,48.89 v1(219.75,48.89) ; v1(222.08,52.49) J7.A13 219.75,52.49 v1(219.75,52.49) ; v1(219.75,20.18) 219.75,20.18 J6.A7 v1(222.08,20.18) ; v1(222.08,63.29) J7.A31 219.75,63.29 v1(219.75,63.29) ; v1(222.08,56.09) J7.A19 219.75,56.09 v1(219.75,56.09) ; v1(217.07,47.09) 217.07,47.09 J7.B4 215.15,47.09 v1(215.15,47.09) ; v1(222.08,27.38) J6.A19 219.75,27.38 v1(219.75,27.38) ; C7747.2 76.39,17.64 v1(76.3,17.73) ; v1(215.15,36.38) 215.15,36.38 J6.B34 217.07,36.38 v1(217.07,36.38) ; v1(215.15,52.49) 215.15,52.49 J7.B13 217.07,52.49 v1(217.07,52.49) ; v1(219.75,34.58) 219.75,34.58 J6.A31 v1(222.08,34.58) ; v1(219.75,16.58) J6.A1 v1(222.08,16.58) ; v3(200.59,67.43) 199.97,67.43 199.72,67.67 U131.6 ; v1(222.08,30.98) J6.A25 219.75,30.98 v1(219.75,30.98) ; J7.A10 219.91,50.69 v1(219.59,50.37) ; J6.B28 v1(215.17,32.78) ; v1(219.75,47.09) 219.75,47.09 J7.A4 v1(222.08,47.09) ; v9(57.03,16.36) v9(57.03,17.5) v9(57.03,18.19) 56.42,18.8 v1(55.89,18.8) ; v1(217.07,54.29) 217.07,54.29 J7.B16 215.15,54.29 v1(215.15,54.29) ; v1(219.03,22.39) 219.12,22.39 219.53,21.98 J6.A10 ; v1(215.25,59.69) 215.27,59.69 J7.B25 217.07,59.69 v1(217.07,59.69) ; v1(217.07,23.78) J6.B13 v1(215.15,23.78)
  TOP w0.305: C581.2 216.58,88.15 v1(216.26,87.84) ; v1(217.07,18.38) 217.07,18.38 J6.B4 215.15,18.38 v1(215.15,18.38) ; v1(44.33,39.73) 44.08,39.98 44.08,40.21 43.89,40.4 C455.2 42.47,40.4 Y2.2 v1(42.11,40.97) 40.49,40.97 v1(40.14,40.62) v1(40.14,38.69) 40.14,37.71 40.24,37.61 v3(42.68,37.61) C464.2 43.89,37.61 44.05,37.77 v1(44.05,38.31)
  TOP w0.381: U32.7 12.92,100.84 v1(12.45,101.3) ; v1(42.45,19.63) C7575.1 41.26,19.63 41.05,19.43 C7402.2 ; C7743.2 68.86,24.8 v1(68.99,24.93) ; C7727.2 169.98,27.19 v1(169.91,27.26) ; v1(75.39,27.33) 75.46,27.26 C7749.2 ; v1(162.82,95.29) 162.64,95.11 J1.184 ; v1(237.42,40.04) 237.7,40.32 R6267.1 ; v3(149.87,42.86) 150.1,42.62 C1120.2 ; J2.4 193.24,105.08 v1(193.17,105.01) ; v1(168.31,16.86) 168.31,15.74 C7726.2 ; v9(163.51,21.66) 163.41,21.76 C7731.2 ; C1045.2 84.84,53.16 v1(85.3,53.62) ; v4(78.82,51.56) 78.7,51.44 C7621.1 ; Q12.2 v1(245.8,42.75) ; C7615.1 214.17,99.3 v1(214.13,99.3) ; v1(134.04,36.22) 134.25,36.02 C7399.2 ; C7745.2 68.96,16.9 v1(68.99,16.93) ; v1(103.92,103.04) 104.63,103.04 104.84,102.83 J2.246 ; v1(200.26,60.33) 200.25,60.33 R6074.2 ; C424.2 v3(116.46,86.11) ; v1(150.17,48.08) 150.12,48.14 C1265.1 ; C1716.2 186.9,58.13 C1714.2 ; J2.191 156.69,101.02 v1(156.64,100.96) ; C1256.1 C1255.1 ; v1(191.22,95.46) 191.07,95.46 190.69,95.07 J1.151 ; U6.LR2 v1(143.89,77.33) ; v1(194.04,101.48) v1(194.04,100.54) ; v9(10.28,21.35) 10.28,20.22 C7192.1 9.81,19.5 C7676.2 8.33,19.5 v9(7.8,20.02) 7.42,20.4 v9(7.42,21.16) v9(7.42,22.3) 7.42,23.15 v9(7.52,23.25) 8.11,23.84 v9(8.11,23.9) 8.87,23.9 v9(9.1,23.68) v9(10.24,23.68) v9(11.61,23.68) ; C7732.2 170,21.76 v9(169.91,21.66) ; v1(120.43,10.04) 120.8,10.4 R169.1 ; C7744.2 68.9,21.83 v1(68.99,21.73) ; v9(41.49,34.04) 40.94,33.49 R6254.2 ; v9(13.67,23.68) v9(13.67,22.84) v9(12.99,22.15) 12.77,21.93 v9(12.22,21.93) ; v1(19.77,99.52) U31.7 ; v1(163.51,24.86) 163.37,24.73 C7728.2 ; J1.149 192.39,95.34 v1(192.51,95.46) ; v1(190.68,100.33) 190.68,101.66 J2.151 ; U134.B3 v1(205.2,19.87) ; C7750.2 75.5,23.23 v1(75.39,23.33) ; v1(210.32,99.3) 210.6,99.58 C7608.2 210.6,100.3 v1(210.32,100.57) ; C7436.2 v3(118.97,86.1) ; C497.2 11.46,21.32 v1(11.35,21.21) ; C7751.2 75.49,21.83 v9(75.39,21.73) ; J8.5 v1(3,27) ; C7729.2 163.47,16.83 v1(163.51,16.86) ; 43.23,27.04 v1(43.23,27.1) ; C1222.2 C1227.2 ; v4(242.39,103.73) 242.39,104.43 R371.1 ; C7671.1 175.75,62.32 v1(175.76,62.33) ; C7733.2 170.01,23.15 v1(169.91,23.26) ; C7748.2 v1(67.37,28.08) ; Q9.2 v1(245.8,38.69) ; Q11.2 v1(245.8,34.62) ; U136.B2 v1(65.41,66.35) ; v1(3.24,19.56) 3.73,20.06 U36.B3 ; C7394.2 C7395.2 ; C1715.2 v1(187.68,54.14)
  TOP w0.483: J5.B7 51.65,6.17 v4(51.65,6.17)
  TOP w0.508: J5.A4 48.65,6.13 v4(48.7,6.17) ; v4(56.4,95.35) 56.24,95.2 48.95,95.2 v4(48.78,95.38) ; v4(208.97,40.59) 207.84,40.59 C825.2 ; 37.12,95.15 40.93,95.15
  L03_SIG1 w0.203: v1(115.52,66.75) 116.56,66.75 116.95,66.35 117.28,66.35 117.67,66.75 118.15,66.75 118.55,66.35 118.87,66.35 119.27,66.75 v1(120.31,66.75) 121.34,66.75 121.74,66.35 122.06,66.35 122.46,66.75 122.94,66.75 123.33,66.35 123.66,66.35 124.05,66.75 v1(125.09,66.75) 126.12,66.75 126.52,66.35 126.85,66.35 127.31,65.89 127.51,65.89 128.1,65.3 128.44,65.3 128.9,64.84 129.38,64.84 129.7,64.51 130.03,64.51 130.36,64.84 130.97,64.84 131.3,64.51 131.62,64.51 131.95,64.84 132.42,64.84 132.75,64.51 133.98,64.51 134.45,64.99 135.03,64.99 135.32,64.7 135.9,64.7 136,64.6 136,64.5 136.3,64.2 136.8,64.2 137.3,63.7 137.67,63.7 138.17,63.2 138.54,63.2 139.04,62.7 139.36,62.7 139.65,62.99 140.48,62.99 140.77,62.7 141.09,62.7 141.5,63.11 143.6,63.11 arc(143.73,63.16) 143.85,63.11 arc(143.97,63.01) 144.1,62.92 arc(144.18,62.87) 144.27,62.84 arc(144.37,62.81) 144.47,62.8 145.08,62.8 arc(145.18,62.8) 145.28,62.82 arc(146.01,63.06) 146.62,63.52 arc(147.28,63.96) 148.06,64.11 148.35,64.11 148.37,64.13 148.75,64.13 148.77,64.11 164.21,64.11 164.82,64.72 166.19,64.72 166.61,65.14 168.03,65.14 169.53,66.63 172.53,66.63 173.51,67.62 173.51,72.34 174.33,73.15 189.53,73.15 193.27,76.89 v1(193.27,77.56)
  L07_SIG3 w0.203: v1(174.85,46.3) 174.5,45.95 171.17,45.95 160,57.11 160,64.77 154.8,69.98 149.1,69.98 147.7,68.58 147.7,54.3 146.9,53.49 144.23,53.49 143.73,53.99 143.38,53.99 142.88,54.49 142.5,54.49 142.06,54.05 141.59,54.05 141.12,54.53 140.75,54.53 140.7,54.52 140.38,54.2 139.9,54.2 139.61,54.49 138.64,54.49 137.85,53.7 137.3,53.7 137.02,53.99 134.67,53.99 134.17,54.49 133.84,54.49 133.61,54.26 132.89,54.26 132.43,53.8 132.08,53.8 131.62,54.26 131.3,54.26 130.84,53.8 130.49,53.8 130.03,54.26 129.7,54.26 129.24,53.8 128.9,53.8 128.27,54.42 v1(128.27,54.79)
  L12_SIG4 w0.203: v1(80.16,74.69) 80.46,74.39 83.67,74.39 85.32,72.73
  L12_SIG4 w0.229: v1(109.15,69.51) v1(107.56,69.51) 107.56,69.83 106.97,70.41 106.54,70.41 105.7,69.58 arc(105.58,69.5) 105.44,69.47 105.04,69.47 104.63,69.87 104.63,70.12 104.77,70.26 104.77,70.6 104.54,70.84 104.25,70.84 104.08,70.93 103.88,71.28 103.68,71.39 103.38,71.39 103.02,71.76 102.61,71.76 102.15,72.22 101.76,72.22 101.41,71.86 101.01,71.86 100.59,72.28 100.25,72.28 100.07,72.18 99.88,71.85 99.73,71.77 98.88,71.77 98.56,72.09 97.32,72.8 96.97,73.15 96.41,73.15 95.99,72.73 95.66,72.73 94.63,71.7 93.81,71.7 93.46,72.05 93.06,72.05 92.64,71.63 92.33,71.63 91.57,72.06 91.28,72.06 90.79,72.55 90.3,72.55 89.42,71.67 88.58,71.67 88.2,72.06 86,72.06 85.32,72.73
  L14_SIG5 w0.203: v1(175.76,62.33) 175.76,62.12 175.33,61.69 144.25,61.69 143.76,61.2 143.37,61.2 142.88,61.69 142.45,61.69 141.96,61.2 141.63,61.2 141.15,61.69 140.72,61.69 140.23,61.2 139.9,61.2 139.41,61.69 138.98,61.69 138.5,61.2 138.17,61.2 137.68,61.69 137.25,61.69 136.76,61.2 136.44,61.2 135.95,61.69 135.52,61.69 135.03,61.2 134.59,61.2 134.1,61.69 132.82,61.69 132.42,61.29 132.09,61.29 131.7,61.69 131.22,61.69 130.83,61.29 130.5,61.29 130.1,61.69 129.63,61.69 129.23,61.29 128.91,61.29 128.51,61.69 128.15,61.69 127.75,61.29 127.31,61.29 126.99,61.62 126.52,61.62 126.19,61.29 125.72,61.29 125.39,61.62 124.95,61.62 124.42,62.15 v1(123.49,62.15)
  L16_SIG6 w0.203: v1(125.09,67.67) 125.52,67.67 125.58,67.73 126.06,67.73 126.52,67.27 126.84,67.27 127.3,67.73 127.65,67.73 128.11,67.27 128.44,67.27 128.9,67.73 129.24,67.73 129.7,67.27 130.03,67.27 130.49,67.73 130.84,67.73 131.3,67.27 131.62,67.27 132.04,67.69 arc(132.05,67.7) 132.06,67.7 132.44,67.7 arc(132.45,67.7) 132.46,67.71 132.91,68.15 arc(132.92,68.16) 132.93,68.16 133.1,68.16 arc(133.12,68.16) 133.13,68.16 133.22,68.18 arc(133.23,68.19) 133.24,68.19 arc(133.36,68.27) 133.44,68.37 133.49,68.46 arc(133.51,68.48) 133.53,68.5 133.55,68.51 133.97,68.51 134.67,69.21 135.03,69.21 135.53,69.71 135.9,69.71 136.4,70.21 136.76,70.21 137.26,70.71 137.63,70.71 138.13,71.21 138.5,71.21 139,71.71 139.36,71.71 139.86,72.21 140.23,72.21 140.73,72.71 141.29,72.71 141.68,73.1 141.93,73.1 142.42,73.59 142.71,73.59 143.28,74.16 143.73,74.16 144.43,74.85 146.18,74.85 148.01,76.68 150.22,76.68 150.99,77.46 153.14,77.46 155.82,80.14 174.07,80.14 174.24,79.96 174.62,79.96 174.79,80.14 180.54,80.14 180.97,79.71 185.81,79.71 185.95,79.85 186.46,79.85 186.94,79.36 189.65,79.36 189.92,79.09 190.05,79.09 191.58,77.56 v1(193.27,77.56)
  BOTTOM w0.127: 122.36,68.47 122.27,68.38 122.27,68.25 122.1,68.08 121.63,68.08 121.58,68.02 arc(121.57,68.01) 121.56,68
  BOTTOM w0.191: ST28.1 186.58,65.85 v1(187.15,65.85) ; U26.4 19.2,109.17 v1(19.25,109.22) ; v3(206.84,61.47) 207.21,61.1 U25.11 ; U27.4 18.91,104.85 v1(19.22,105.16) ; v1(174.4,68.79) 174.19,68.57 C1728.1 ; ST2.2 v1(24.65,38.53)
  BOTTOM w0.203: v1(101.18,66.75) 100.85,67.08 100.85,67.33 100.77,67.47 100.57,67.67 100.26,67.67 100.05,67.79 99.92,68.02 99.72,68.14 99.26,68.14 98.91,68.49 98.91,68.79 98.59,69.11 98.31,69.11 98.08,69.34 98.08,69.34 97.97,69.45 97.97,69.83 98.08,69.93 98.08,70.34 97.97,70.44 97.97,70.84 98.08,70.94 98.08,71.33 97.97,71.43 97.97,71.83 98.08,71.94 98.08,72.34 97.97,72.44 97.97,72.82 98.08,72.93 98.08,73.33 97.97,73.43 97.97,73.84 98.08,73.94 98.08,74.35 97.92,74.5 97.92,74.86 98.03,74.96 98.03,75.31 97.24,76.1 95.94,76.64 95.66,76.64 95.36,76.94 95.36,78.31 95.49,78.44 95.49,78.84 95.33,79 95.33,79.43 95.5,79.6 95.5,79.83 95.37,79.96 95.37,80.39 95.46,80.48 95.46,80.85 95.26,81.05 R665.1 ; ST30.1 52.45,107.34 v10(52.4,107.29) ; ST20.2 66.54,34.95 C483.2 ; ST31.1 197.18,56.02 v1(196.83,56.37) ; ST23.2 v1(17.51,64.72) ; ST1.2 v1(37.75,38.31) ; v1(123.49,50.19) 124.34,50.19 124.58,50.09 124.65,50.01 124.76,49.84 124.94,49.74 125.2,49.74 125.42,49.61 125.57,49.35 125.72,49.27 126.03,49.27 126.21,49.17 126.35,48.92 126.35,48.65 126.24,48.53 126.24,48.16 126.33,48.07 126.33,47.7 126.24,47.61 126.24,47.24 126.33,47.15 126.33,46.78 126.24,46.69 126.24,46.33 126.34,46.23 126.34,45.87 126.24,45.77 126.24,45.4 126.34,45.3 126.34,44.98 126.23,44.87 126.23,44.47 126.33,44.36 126.33,44.01 126.25,43.93 126.25,43.57 126.33,43.49 126.33,43.47 126.33,43.47 126.33,43.09 126.25,43.01 126.25,42.65 126.35,42.54 126.35,42.21 126.24,42.09 126.24,41.72 126.33,41.63 126.33,41.26 126.24,41.17 126.24,40.8 126.33,40.71 126.33,40.35 126.2,40.22 126.2,39.93 126.34,39.78 126.34,39.44 126.2,39.29 126.2,39 126.33,38.87 126.33,38.48 126.25,38.41 126.25,38.05 126.43,37.87 126.43,37.28 R975.1 ; v1(103.57,50.65) 103.22,50.3 103.22,50 103.13,49.91 103.13,49.54 103.39,49.28 103.72,49.28 104.02,48.99 104.02,48.89 104.13,48.78 104.55,48.78 104.8,48.53 104.8,48.17 104.72,48.08 104.72,47.69 104.8,47.61 104.8,47.25 104.72,47.16 104.72,46.77 104.8,46.69 104.8,46.33 104.72,46.24 104.72,45.87 104.81,45.77 104.81,45.4 104.72,45.31 104.72,44.93 104.8,44.85 104.8,44.49 104.72,44.4 104.72,44.01 104.8,43.93 104.8,43.57 104.55,43.31 104.55,43.26 104.8,43.01 104.8,42.65 104.55,42.39 104.23,42.39 104.02,42.18 104.02,42.18 103.76,41.92 103.39,41.92 103.22,41.75 103.22,41.72 102.96,41.46 102.62,41.46 102.33,41.17 102.13,40.97 101.79,40.97 101.64,40.81 101.52,40.81 101.23,40.65 100.9,40.65 100.34,40.08 100.04,40.08 99.89,40.02 99.7,39.83 99.67,39.74 99.52,39.6 99.09,39.6 98.84,39.35 98.84,38.94 98.91,38.86 98.91,38.61 98.76,38.24 98.76,38.05 98.84,37.87 98.84,37.85 98.89,37.8 98.89,36.95 R963.1 ; U108.4 188.72,91.3 U108.11 ; C7439.1 205.2,19.19 v1(205.2,19.87) ; ST18.2 70.73,62.14 ; ST25.2 187.04,26.62 187.02,26.6 v10(187,26.6) ; v1(46.21,104.75) 46.21,104.42 ST9.1 ; ST17.2 78.54,66.83 ; R213.2 99.24,82.03 99.24,81.82 99.83,81.23 99.83,80.95 99.7,80.83 99.7,80.47 99.85,80.32 99.85,78.97 99.7,78.82 99.7,78.46 99.85,78.31 99.85,77.98 99.7,77.83 99.7,77.47 99.85,77.32 99.85,76.96 99.7,76.81 99.7,76.46 99.85,76.3 99.85,75.29 v1(99.59,75.03) ; v1(174.21,71.17) C1729.1 ; C1367.2 202.63,43.55 202.78,43.55 202.78,43.56 202.8,43.56 R981.2 ; v1(113.93,53.87) 113.6,53.54 113.6,53.29 113.47,53.06 113.27,52.95 113,52.95 112.8,52.83 112.67,52.6 112.47,52.49 112.2,52.49 112.01,52.37 111.87,52.14 111.67,52.03 111.41,52.03 111.21,51.91 111.07,51.68 110.88,51.57 110.61,51.57 110.41,51.45 110.28,51.22 110.08,51.11 109.82,51.11 109.61,50.98 109.48,50.76 109.28,50.65 109.02,50.65 108.82,50.53 108.68,50.3 108.49,50.19 108.22,50.19 108.02,50.07 107.89,49.84 107.69,49.73 107.42,49.73 107.29,49.65 107.16,49.52 107.09,49.35 107.09,49.11 107.21,48.99 107.21,48.63 107.09,48.5 107.09,48.19 107.22,48.06 107.22,47.72 107.11,47.61 107.11,47.24 107.21,47.14 107.21,46.79 107.11,46.69 107.11,46.32 107.2,46.23 107.2,45.86 107.11,45.77 107.11,45.4 107.2,45.31 107.2,44.94 107.11,44.85 107.11,44.85 107.07,44.81 107.07,44.53 107.11,44.49 107.11,44.48 107.23,44.36 107.23,44.05 107.11,43.93 107.11,43.89 107.09,43.86 107.09,43.59 107.26,43.42 107.26,43.16 107.11,43.01 107.11,42.64 107.2,42.55 107.2,42.26 107.14,42.11 106.92,41.89 106.61,41.89 106.42,41.78 106.29,41.56 106.07,41.43 105.81,41.43 105.62,41.32 105.48,41.07 105.32,40.98 104.99,40.98 104.85,40.9 104.7,40.65 104.52,40.54 104.22,40.54 104.06,40.45 103.89,40.15 103.74,40.07 103.4,40.07 103.13,39.79 103.13,39.42 103.22,39.33 103.22,38.96 102.96,38.7 102.64,38.7 102.46,38.6 102.3,38.32 102.16,38.24 101.82,38.24 101.12,37.54 R677.1 ; 121.56,68 121.44,67.79 arc(121.43,67.78) 121.42,67.77 121.24,67.67 arc(121.23,67.67) 121.22,67.66 120.98,67.66 arc(120.97,67.66) 120.95,67.66 120.78,67.56 arc(120.77,67.55) 120.76,67.54 120.63,67.31 arc(120.62,67.3) 120.61,67.3 120.46,67.21 120.17,67.21 119.97,67.09 119.84,66.86 119.64,66.75 119.4,66.75 119.16,66.61 119.04,66.4 118.85,66.29 118.58,66.29 118.38,66.17 117.92,65.37 v1(117.92,65.37) ; v4(200.21,40.16) 200.27,40.22 ST32.1 ; R951.1 108.76,81.39 108.76,81.23 arc(108.81,81) 108.75,80.78 arc(108.69,80.57) 108.73,80.36 108.76,80.31 arc(108.82,80.09) 108.75,79.86 arc(108.69,79.63) 108.75,79.4 108.76,79.4 arc(108.82,79.17) 108.75,78.94 arc(108.69,78.71) 108.75,78.48 108.75,78.48 arc(108.82,78.25) 108.75,78.02 arc(108.69,77.79) 108.75,77.56 108.76,77.56 arc(108.82,77.33) 108.75,77.1 108.74,77.07 arc(108.69,76.85) 108.75,76.64 arc(108.81,76.42) 108.76,76.2 108.75,76.18 arc(108.69,75.95) 108.75,75.72 108.76,75.7 arc(108.93,75.54) 109.15,75.49 arc(109.38,75.43) 109.55,75.27 109.55,75.25 arc(109.72,75.09) 109.95,75.03 109.95,75.03 arc(110.18,74.97) 110.35,74.8 arc(110.51,74.63) 110.74,74.57 110.77,74.57 arc(110.98,74.5) 111.14,74.34 arc(111.3,74.18) 111.52,74.11 111.55,74.11 arc(111.77,74.05) 111.94,73.88 111.94,73.87 arc(112.11,73.71) 112.34,73.65 112.34,73.65 arc(112.57,73.59) 112.74,73.42 arc(112.9,73.25) 113.13,73.19 113.13,73.19 arc(113.36,73.13) 113.52,72.98 113.54,72.94 arc(113.71,72.79) 113.93,72.73 113.95,72.73 arc(114.17,72.66) 114.33,72.5 arc(114.49,72.34) 114.71,72.27 114.73,72.27 arc(114.95,72.33) 115.12,72.48 115.14,72.52 arc(115.3,72.67) 115.52,72.73 115.54,72.73 arc(115.76,72.66) 115.92,72.5 arc(116.08,72.34) 116.3,72.27 116.32,72.27 arc(116.54,72.33) 116.71,72.48 116.73,72.52 arc(116.9,72.67) 117.12,72.73 117.14,72.73 arc(117.36,72.66) 117.52,72.5 arc(117.68,72.34) 117.9,72.27 117.92,72.27 arc(118.14,72.33) 118.3,72.48 118.32,72.51 arc(118.49,72.67) 118.71,72.73 118.73,72.73 arc(118.95,72.79) 119.11,72.96 arc(119.27,73.12) 119.49,73.19 119.51,73.19 arc(119.73,73.13) 119.9,72.97 119.92,72.94 arc(120.08,72.79) 120.31,72.73 120.32,72.73 arc(120.54,72.79) 120.7,72.96 arc(120.87,73.13) 121.1,73.19 arc(121.33,73.13) 121.49,72.97 121.49,72.97 121.71,72.74 122.11,72.74 122.22,72.86 arc(122.26,72.91) 122.3,72.96 122.48,73.15 122.52,73.16 122.75,73.16 arc(123.02,73.05) 123.13,72.79 123.13,72.63 123.13,72.52 123.06,72.45 123.06,72.09 123.32,71.83 123.37,71.83 arc(123.43,71.81) 123.5,71.81 123.51,71.81 arc(123.73,71.74) 123.89,71.58 arc(124.06,71.41) 124.29,71.35 124.41,71.33 124.47,71.33 124.7,71.11 124.72,71.1 124.72,71.09 124.73,71.07 124.73,69.82 124.62,69.62 124.42,69.51 124.16,69.51 123.96,69.39 123.82,69.16 123.63,69.05 123.36,69.05 123.16,68.93 123.03,68.7 122.83,68.59 122.56,68.59 122.36,68.47
  BOTTOM w0.229: U51.4 213.23,72.21 v1(212.73,71.71)
  BOTTOM w0.254: R216.1 101.93,81.05 v1(101.98,81.01) ; v1(46.49,37.16) 46.17,37.48 C460.2 ; v1(46.49,38.56) 46.43,38.5 C457.2 ; U88.2 32.52,85.55 v1(32.27,85.8) 32.02,85.56 U88.1 ; C456.2 46.62,40.08 v1(46.49,39.96) ; EU2.8 172.51,92.14 172.8,92.43 v1(172.8,92.75) ; v1(47.89,39.96) 47.63,40.21 C459.2 ; v1(16.14,85.9) U14.28 ; U52.1 212.62,84.65 v1(212.48,84.79) ; C462.2 49.16,37.04 v1(49.28,37.16) ; U107.9 v1(195.56,19.17) ; v1(49.28,39.96) 49.54,40.21 C458.2 ; Q8.2 245.05,45.73 244.04,44.72 R360.2 ; U21.2 99.84,84.98 99.14,84.27 C392.2 R213.2 ; R460.2 75.72,79.03 v1(75.43,79.33) ; C1399.1 217.37,57.59 v1(217.07,57.89) ; v1(16.44,81.82) 16.44,82.17 16.67,82.4 U14.21 ; 207.14,34.24 ST10.1 ; v10(57.6,16.72) v10(57.6,15.7) ; C461.2 49.41,37.8 ; R995.2 203.46,68.48 203.02,68.93 202.17,68.93 D13.2 ; v1(231.88,62.59) 231.59,62.3 R589.2 ; v10(216.73,90.38) v10(216.73,89.49) 216.21,89.49 ; U132.11 U132.8 ; U14.27 v1(17.66,85.4) ; R210.1 97.29,81.4 v1(97.56,81.14) ; U47.1 v1(242.58,75.03)
  BOTTOM w0.305: R1034.1 97.87,34.79 98.21,34.45 U15.7 ; v1(129.87,52.95) 129.41,52.95 129.23,52.77 C1247.2 ; v1(32.5,26.9) 32.54,26.95 C514.2 ; R448.1 v1(243.66,51.39) ; R358.1 v1(249.1,45.04)
  BOTTOM w0.381: U15.7 99.69,34.87 v1(100.08,35.26) ; v1(184.94,21.29) 184.94,21.08 C1960.2 ; C984.2 39,27.04 v10(39.02,27.05) ; v10(109.07,30.65) 108.47,30.65 C308.2 ; v1(33.41,36.71) 33.18,36.48 C7627.1 ; R179.2 98.6,51.46 v1(98.42,51.64) ; U103.B3 v1(15.35,19.21) ; v1(208.52,19.48) 208.52,19.4 208.13,19.01 C7650.2 ; v1(174.1,85.23) 174.1,85.23 174.1,85.16 C7578.1 ; v1(26.5,21.9) 26.41,21.98 C532.2 ; C978.2 v10(39.12,25.73) ; U33.1 40.47,36.43 v3(40.47,36.45) ; R6314.2 98.94,48.16 v1(98.42,47.64) ; v1(174.17,82.43) 174.09,82.34 C7579.1 173.51,81.45 C7686.1 ; C1293.2 57.41,37.87 v1(57.67,38.13) ; U103.C1 13.85,16.61 v1(13.37,16.13) ; C1168.1 v1(125.88,54.33) ; v1(58.55,41.18) 58.43,41.3 C1294.2 ; v1(29.5,23.9) 29.74,24.15 C519.2 ; C236.2 v1(139.69,107.59) ; U18.7 v1(199.7,93.58) ; v1(131.13,32.2) 131.2,32.13 131.2,31.4 130.82,31.02 U105.11 ; v1(71.34,88.6) 71.09,88.85 C7526.2 ; C520.2 33.11,24.44 C516.2 ; v1(41.94,95.23) 41.76,95.41 C819.2 ; C495.1 36.42,34.99 v1(36.3,35.11) ; v1(59.7,39.14) 60,39.45 C1391.2 ; v1(204.59,55.02) R980.2 ; R6168.2 64.12,36.86 v1(63.81,36.55) ; v1(215.25,59.69) 215.24,59.69 C1397.2 ; C507.2 v1(19.97,33.39) ; R6195.2 182.58,58.02 v1(182.58,58.14) ; C47.2 79.06,19.22 v1(79.18,19.34) ; v1(204.71,20.75) 204.67,20.79 R2786.1 ; v1(52.59,22.18) 52,22.76 C426.2 ; R353.2 v1(16.52,98.71) ; C471.2 v1(207.92,58.8) ; R374.2 v10(41.94,33.31) ; C1389.2 59.95,37.87 v1(59.7,38.13) ; v1(68.99,23.33) 68.84,23.33 68.51,23.66 C7757.2 ; C389.1 v1(138.61,36.62) ; v1(103.92,103.04) C231.2 ; v10(98.57,21.01) v10(98.57,22.53) C86.2 v10(98.57,24.06) 98.57,27.15 v10(98.66,27.24) ; C7664.1 178.89,57.48 v1(179.53,57.48) ; U25.12 206.97,61.6 v3(206.84,61.47) ; v1(59.7,41.18) 59.9,40.97 C1390.2 ; R346.2 v1(23.38,98.53) ; v1(234.12,42.73) 234.47,42.37 C7765.2 ; v3(245.16,46.69) Q8.2 ; v1(23.49,23.9) 23.17,23.57 C555.2 ; U103.E5 v1(11.35,21.21) ; C463.2 44.77,43.64 v1(44.84,43.7) ; C531.2 31.44,30.19 30.73,30.9 v1(30.5,30.9) C554.2 ; v1(234.42,63.86) 234.33,63.77 C716.1 ; v1(52.59,23.45) 52.2,23.83 C437.2 ; C1175.1 125.9,63.54 v1(125.88,63.53) ; C310.2 v10(109.05,31.32) ; R476.2 v1(174.68,91.01) ; C1392.2 56.14,37.62 v1(56.65,38.13) ; v1(3.24,19.56) 3.73,19.08 3.73,19.07 U104.B3 ; R351.2 v1(14.49,98.76) ; R352.2 v1(15.5,98.71) ; C715.1 v1(235.69,62.59) ; 216.21,89.49 215.54,89.49 v10(214.59,88.54) ; v1(188.84,95.48) C7434.2 ; v3(96.92,31.11) 96.92,30.89 C309.2 ; v1(145.65,103.01) 145.8,103.16 R104.1 ; R504.1 v1(244.36,71.52) ; v1(179.53,63.22) 178.95,63.22 C1719.2 ; Q7.2 v1(245.16,42.75) ; R486.2 v1(243.09,73.36) ; C7756.2 C7755.2 ; C535.2 v1(20.57,21.61) ; Q10.2 v1(245.16,38.69)
  BOTTOM w0.483: v4(48.7,6.17) 48.65,6.13 J5.A4
  BOTTOM w0.508: v1(72.57,75.71) 72.57,75.53 72.3,75.25 C7574.2 ; C988.2 28.19,105.4 v1(27.99,105.19) ; v10(151.39,97.89) 151.39,96.69 150.57,95.87 v10(150.57,95.17) ; R672.1 207.91,37.61 207.4,37.1 207.4,36.15 ; C7565.1 v1(178.87,66.58) ; C252.1 C255.2
  vias: v1(1.85,54.66) v1(1.82,52.83) v1(1.84,49.03) v1(2.36,75.39) v1(2.67,63.39) v1(2.67,61.61) v1(2.67,59.83) v1(2.67,58.05) v1(2.7,44.73) v1(5.21,40.38) v1(5.32,28.63) v1(5.72,36.02) v1(5.72,31.26) v1(6.36,24.8) v1(6.88,34.02) v1(6.88,32.21) v1(7.12,43.68) v1(7.2,41.46) v1(7.2,38.92) v1(7.2,36.74) v1(7.31,23.9) v1(8.26,18.23) v1(8.47,42.73) v1(8.47,41.46) v1(8.47,40.19) v1(8.47,38.92) v1(9.71,36.74) v1(12.07,30.38) v1(12.07,29.11) v1(12.07,27.84) v1(12.07,26.72) v1(13.09,31.52) v1(13.09,30.38) v1(13.09,29.11) v1(13.09,27.84) v1(13.34,44.78) v1(14.44,81.21) v1(14.36,31.52) v1(14.36,30.38) v1(14.36,27.84) v1(14.74,56.57) v1(14.8,79.33) v1(14.8,77.93) v1(14.8,76.66) v1(15.31,90.63) v1(15.31,89.61) v1(15.31,88.6) v1(15.31,87.58) v1(15.42,35.61) v1(15.48,102.82) v1(15.63,31.52) v1(15.63,29.11) v1(15.63,27.84) v1(15.75,103.34) v1(15.74,102.3) v1(15.65,44.83) v1(16.08,53.77) v1(16.08,52.5) v1(16.43,58.77) v1(16.77,30.38) v1(16.77,29.11) v1(16.77,27.84) v1(17.43,36.91) v1(17.53,100.28) v1(17.53,93.93) v1(18.35,44.64) v1(18.36,77.38) v1(18.45,41.63) v1(18.45,39.09) v1(18.8,85.17) v1(18.8,84.15) v1(18.8,83.14) v1(19.51,45.85) v1(19.72,42.9) v1(19.72,41.63) v1(19.72,40.36) v1(19.72,39.09) v1(19.82,85.17) v1(19.82,84.15) v1(19.82,83.14) v1(20.01,26.75) v1(20.57,20.01) v1(20.57,19.21) v1(20.84,85.17) v1(20.84,84.15) v1(20.84,83.14) v1(20.78,59.64) v1(20.78,58.37) v1(21.43,106.06) v1(21.55,36.08) v1(21.6,97.17) v1(21.65,108.33) v1(21.85,85.17) v1(21.85,84.15) v1(21.85,83.14) v1(22.04,77.38) v1(22.05,59.64) v1(22.56,108.33) v1(22.61,97.17) v1(22.75,106.06) v1(22.87,85.17) v1(22.87,84.15) v1(22.87,83.14) v1(23.32,59.64) v1(23.32,58.37) v1(23.46,107.44) v1(23.49,32.9) v1(23.49,17.9) v1(23.92,104.94) v1(23.88,85.17) v1(23.88,84.15) v1(23.88,83.14) v1(24.16,44.22) v1(24.16,43.61) v1(24.39,100.28) v1(24.39,93.93) v1(24.49,29.9) v1(24.49,28.9) v1(24.59,59.64) v1(24.57,41.25) v1(24.57,40.64) v1(24.68,106.21) v1(24.68,105.45) v1(24.9,85.17) v1(24.9,84.15) v1(24.9,83.14) v1(25.5,29.9) v1(25.5,27.9) v1(25.5,26.9) v1(25.5,23.9) v1(25.5,19.9) v1(25.72,77.38) v1(25.92,85.17) v1(25.92,84.15) v1(25.92,83.14) v1(25.86,51.79) v1(25.95,105.7) v1(26.13,102.42) v1(26.46,106.21) v1(26.46,105.19) v1(26.63,100.06) v1(26.82,48.95) v1(26.91,63.06) v1(27.63,56.34) v1(27.68,58.14) v1(27.99,106.21) v1(27.97,63.03) v1(28,51.79) v1(28.5,29.9) v1(28.5,28.9) v1(29.41,77.38) v1(29.5,25.9) v1(29.5,19.9) v1(29.73,55.03) v1(30.21,44.74) v1(30.33,41.73) v1(30.33,39.19) v1(30.33,37.02) v1(30.42,73.36) v1(30.53,102.42) v1(30.49,51.96) v1(30.5,26.9) v1(31.12,100.15) v1(31.12,94) v1(31.06,80.09) v1(31.5,23.9) v1(31.5,20.9) v1(31.6,43) v1(31.6,41.73) v1(31.6,40.46) v1(31.6,39.19) v1(31.88,84.03) v1(32.11,15.34) v1(32.27,63.13) v1(32.52,51.96) v1(32.5,24.9) v1(32.59,15.12) v1(32.77,84.03) v1(33.22,77.38) v1(33.54,51.96) v1(33.5,30.9) v1(34.5,20.9) v1(35.5,28.9) v1(36.14,16.02) v1(36.23,95.47) v1(36.35,106.26) v1(36.49,31.9) v1(36.49,25.9) v1(36.9,104.14) v1(37.5,27.9) v1(38.03,102.52) v1(38.03,101.88) v1(38.03,100.69) v1(38.03,100.05) v1(38.67,102.52) v1(38.67,101.88) v1(38.67,100.69) v1(38.67,100.05) v1(39.38,102.52) v1(39.38,101.88) v1(39.38,100.69) v1(39.38,100.05) v1(40.01,102.52) v1(40.01,101.88) v1(40.01,100.69) v1(40.01,100.05) v1(42.05,53.52) v1(42.25,24.18) v1(42.49,36.65) v1(42.74,87.71) v1(43.23,28.04) v1(43.28,26.19) v1(43.54,31.42) v1(43.63,52.12) v1(43.84,27.13) v1(44.33,81.1) v1(44.37,28.04) v1(44.4,26.22) v1(46.11,82.63) v1(46.11,81.1) v1(46.87,55.45) v1(47.65,51.25) v1(47.9,76.04) v1(47.9,73.64) v1(47.9,48.85) v1(47.89,43.7) v1(47.89,38.56) v1(47.89,37.16) v1(48.05,15.11) v1(48.46,103.58) v1(49.1,88.04) v1(49.1,85.64) v1(49.1,83.24) v1(49.1,78.44) v1(49.1,76.04) v1(49.1,73.64) v1(49.1,63.25) v1(49.1,60.85) v1(49.1,58.45) v1(49.1,53.65) v1(49.1,51.25) v1(49.1,48.85) v1(49.28,38.56) v1(50.43,106.31) v1(50.58,31.93) v1(50.71,58.45) v1(50.71,51.25) v1(50.83,85.64) v1(50.83,83.24) v1(50.83,73.64) v1(50.83,60.85) v1(50.83,48.85) v1(50.91,32.81) v1(51.01,104.3) v1(51.16,29.39) v1(51.59,100.1) v1(52.03,88.04) v1(52.03,85.64) v1(52.03,83.24) v1(52.03,78.44) v1(52.03,76.04) v1(52.03,73.64) v1(52.03,63.25) v1(52.03,60.85) v1(52.03,58.45) v1(52.03,53.65) v1(52.03,51.25) v1(52.03,48.85) v1(52.14,42.62) v1(52.23,102.57) v1(52.23,101.93) v1(52.23,100.74) v1(52.23,100.1) v1(52.59,25.99) v1(52.59,24.72) v1(52.94,102.57) v1(52.94,101.93) v1(52.94,100.74) v1(52.94,100.1) v1(53.03,40.59) v1(53.4,32.1) v1(53.58,102.57) v1(53.58,101.93) v1(53.58,100.74) v1(53.58,100.1) v1(53.64,74.04) v1(53.73,39.83) v1(53.73,38.31) v1(53.73,37.8) v1(53.73,36.27) v1(53.76,83.64) v1(53.76,61.25) v1(53.76,51.65) v1(53.76,49.25) v1(53.86,25.99) v1(53.86,24.72) v1(53.86,23.45) v1(53.86,22.18) v1(54.02,78.84) v1(54.02,76.44) v1(54.93,44.66) v1(54.96,88.44) v1(54.96,86.04) v1(54.96,83.64) v1(54.96,78.84) v1(54.96,76.44) v1(54.96,74.04) v1(54.96,63.65) v1(54.96,61.25) v1(54.96,58.85) v1(54.96,54.05) v1(54.96,51.65) v1(54.96,49.25) v1(54.97,35.49) v1(55.13,25.99) v1(55.13,24.72) v1(55.13,23.45) v1(55.13,22.18) v1(56.44,61.25) v1(56.4,25.99) v1(56.4,24.72) v1(56.4,23.45) v1(56.4,22.18) v1(56.45,20.6) v1(56.65,41.18) v1(56.65,40.16) v1(56.65,39.14) v1(56.69,88.44) v1(56.69,86.04) v1(56.69,78.84) v1(56.69,76.44) v1(56.69,74.04) v1(56.69,63.65) v1(56.69,54.05) v1(56.69,51.65) v1(56.69,49.25) v1(56.95,83.64) v1(57.73,102.69) v1(57.67,41.18) v1(57.67,40.16) v1(57.67,39.14) v1(57.89,88.44) v1(57.89,86.04) v1(57.89,83.64) v1(57.89,78.84) v1(57.89,76.44) v1(57.89,74.04) v1(57.89,63.65) v1(57.89,61.25) v1(57.89,58.85) v1(57.89,54.05) v1(57.89,51.65) v1(57.89,49.25) v1(58.55,40.16) v1(58.55,39.14) v1(58.55,38.13) v1(59.15,5.94) v1(59.15,2.2) v1(59.7,40.16) v1(60.15,5.94) v1(60.15,2.2) v1(60.65,8.21) v1(61.15,5.94) v1(61.15,2.2) v1(61.75,37.24) v1(61.65,8.21) v1(62.17,11) v1(62.15,5.94) v1(62.15,2.2) v1(62.32,28.61) v1(62.26,26.62) v1(62.26,24.51) v1(62.52,22.82) v1(62.57,20.46) v1(63.15,5.94) v1(63.15,2.2) v1(63.36,26.61) v1(63.36,24.55) v1(63.53,84.62) v1(63.5,84.04) v1(63.46,30.84) v1(63.56,85.23) v1(63.68,74.44) v1(63.68,73.17) v1(63.68,71.9) v1(63.68,70.63) v1(63.68,69.36) v1(63.68,68.09) v1(63.68,66.82) v1(64.14,85.23) v1(64.11,84.62) v1(64.09,84.04) v1(64.15,11) v1(64.15,5.94) v1(64.15,2.2) v1(64.38,58.23) v1(64.38,56.96) v1(64.65,84.6) v1(64.62,84.01) v1(64.67,85.2) v1(64.95,73.17) v1(64.95,71.9) v1(64.95,70.63) v1(64.95,69.36) v1(64.95,68.09) v1(64.97,45.93) v1(65.08,41.25) v1(65.15,5.94) v1(65.15,2.2) v1(65.65,54.42) v1(65.65,53.15) v1(65.65,8.21) v1(65.82,39.32) v1(66.22,74.44) v1(66.22,73.17) v1(66.22,71.9) v1(66.22,70.63) v1(66.22,69.36) v1(66.22,66.82) v1(66.15,5.94) v1(66.15,2.2) v1(66.49,35.05) v1(66.65,8.21) v1(66.92,58.23) v1(67.17,11) v1(67.15,5.94) v1(67.15,2.2) v1(67.29,92.13) v1(67.29,91.23) v1(67.54,103.14) v1(67.49,70.63) v1(67.49,66.82) v1(67.6,88.19) v1(67.6,86.55) v1(67.77,32.67) v1(67.92,95.69) v1(67.93,33.43) v1(68.13,103.14) v1(68.19,58.23) v1(68.19,56.96) v1(68.19,55.69) v1(68.15,5.94) v1(68.15,2.2) v1(68.51,95.69) v1(68.66,103.11) v1(68.76,75.71) v1(68.76,49.35) v1(69.04,95.67) v1(68.99,25.73) v1(68.99,19.33) v1(69.15,5.94) v1(69.15,2.2) v1(69.3,11.03) v1(69.43,48.08) v1(69.43,46.23) v1(69.46,54.42) v1(69.46,53.15) v1(69.68,39.46) v1(69.68,38.66) v1(69.68,37.86) v1(69.68,36.26) v1(69.68,35.46) v1(69.68,34.66) v1(69.65,8.21) v1(69.79,28.93) v1(69.79,28.13) v1(69.79,26.53) v1(69.99,104.99) v1(70.03,74.44) v1(70.03,65.55) v1(70.15,5.94) v1(70.15,2.2) v1(70.31,48.08) v1(70.31,46.23) v1(70.48,39.46) v1(70.48,38.66) v1(70.48,37.06) v1(70.48,35.46) v1(70.48,34.66) v1(70.59,25.73) v1(70.72,88) v1(70.72,86.73) v1(70.73,58.23) v1(70.67,49.35) v1(70.65,8.21) v1(70.82,97.37) v1(71.17,11) v1(71.15,5.94) v1(71.15,2.2) v1(71.3,75.71) v1(71.25,74.53) v1(71.3,65.55) v1(71.28,37.06) v1(71.99,86.73) v1(72,58.23) v1(72,56.96) v1(72,55.69) v1(72.08,39.46) v1(72.08,38.66) v1(72.08,37.06) v1(72.15,5.94) v1(72.15,2.2) v1(72.52,107.84) v1(72.61,81.26) v1(72.61,80.05) v1(72.61,79.1) v1(72.63,74.45) v1(72.88,39.46) v1(72.88,38.66) v1(72.88,37.86) v1(72.88,36.26) v1(72.88,35.46) v1(72.88,34.66) v1(73.15,11) v1(73.15,5.94) v1(73.15,2.2) v1(73.26,88) v1(73.26,86.73) v1(73.27,54.42) v1(73.27,53.15) v1(73.43,102.31) v1(73.39,100.96) v1(73.39,93.34) v1(73.48,100.03) v1(73.63,81.26) v1(73.62,80.05) v1(73.63,79.1) v1(73.65,8.21) v1(73.84,74.44) v1(73.84,66.82) v1(73.79,16.93) v1(73.98,46.56) v1(74.24,105.57) v1(74.24,98.73) v1(74.15,5.94) v1(74.15,2.2) v1(74.53,86.73) v1(74.5,72.79) v1(74.59,28.93) v1(74.59,26.53) v1(74.59,25.73) v1(74.59,24.13) v1(74.65,8.21) v1(74.78,41.28) v1(75.09,102.31) v1(75.09,93.34) v1(75.11,74.44) v1(75.11,73.17) v1(75.11,71.9) v1(75.11,70.63) v1(75.11,66.82) v1(75.19,91.92) v1(75.19,91.02) v1(75.18,57.94) v1(75.17,11) v1(75.15,5.94) v1(75.15,2.2) v1(75.3,96.7) v1(75.3,95.8) v1(75.5,104.65) v1(75.5,103.75) v1(75.81,56.96) v1(75.81,55.69) v1(75.94,106.14) v1(75.94,98.58) v1(76.13,82.81) v1(76.15,5.94) v1(76.15,2.2) v1(76.38,73.17) v1(76.38,69.36) v1(76.38,66.82) v1(76.51,32.43) v1(76.78,101.04) v1(76.79,94.17) v1(77.08,54.42) v1(77.08,53.15) v1(77.15,11) v1(77.15,5.94) v1(77.15,2.2) v1(77.64,106.26) v1(77.69,99.34) v1(77.65,74.44) v1(77.65,73.17) v1(77.65,69.36) v1(77.65,66.82) v1(78.15,5.94) v1(78.15,2.2) v1(78.75,10.56) v1(79.18,25.74) v1(79.18,24.94) v1(79.18,23.34) v1(79.18,16.94) v1(79.15,5.94) v1(79.15,2.2) v1(79.33,102.21) v1(79.33,94.15) v1(79.37,12.58) v1(79.65,8.21) v1(79.98,28.94) v1(79.98,28.14) v1(79.98,26.54) v1(80.19,106.26) v1(80.19,98.52) v1(80.24,91.27) v1(80.25,90.26) v1(80.19,89.06) v1(80.19,87.61) v1(80.15,5.94) v1(80.15,2.2) v1(80.48,72.83) v1(80.53,10.56) v1(80.65,8.21) v1(80.78,25.74) v1(80.91,66.37) v1(81.01,102.36) v1(81.04,94.36) v1(81.17,11) v1(81.15,5.94) v1(81.15,2.2) v1(81.89,106.2) v1(81.89,98.58) v1(81.89,70.29) v1(81.89,69.01) v1(81.89,52.14) v1(82.15,5.94) v1(82.15,2.2) v1(82.56,59.87) v1(82.74,101.73) v1(82.77,67.71) v1(82.77,66.27) v1(82.77,64.14) v1(82.84,51.14) v1(82.84,49.14) v1(82.84,47.14) v1(82.84,46.26) v1(82.84,42.95) v1(82.89,75.14) v1(82.89,72.89) v1(82.89,71.39) v1(82.89,63.06) v1(82.89,56.14) v1(82.89,55.14) v1(83.01,44.27) v1(83.15,11) v1(83.15,5.94) v1(83.15,2.2) v1(83.59,106.2) v1(83.59,98.58) v1(83.65,8.21) v1(83.89,70.29) v1(83.89,69.01) v1(83.98,16.94) v1(84.15,5.94) v1(84.15,2.2) v1(84.44,101.73) v1(84.65,8.21) v1(84.78,28.94) v1(84.78,26.54) v1(84.78,25.74) v1(84.78,24.14) v1(85.03,55.14) v1(85.17,11) v1(85.15,5.94) v1(85.15,2.2) v1(85.29,106.14) v1(85.29,98.58) v1(85.46,64.14) v1(85.58,27.34) v1(85.58,23.34) v1(85.89,72.89) v1(86.14,101.78) v1(86.14,94.04) v1(86.15,5.94) v1(86.15,2.2) v1(86.99,105.64) v1(86.99,98.52) v1(87.15,11) v1(87.15,5.94) v1(87.15,2.2) v1(87.65,8.21) v1(88.03,71.64) v1(88.03,69.64) v1(88.03,67.64) v1(88.03,66.64) v1(88.03,65.64) v1(88.03,64.64) v1(88.03,63.64) v1(88.03,62.64) v1(88.03,51.64) v1(88.03,50.64) v1(88.03,49.64) v1(88.03,48.64) v1(88.03,47.64) v1(88.03,46.64) v1(88.15,5.94) v1(88.15,2.2) v1(88.69,101.73) v1(88.69,94.04) v1(88.65,8.21) v1(88.89,80.14) v1(88.89,79.14) v1(88.89,78.14) v1(88.89,76.14) v1(88.89,74.14) v1(88.89,72.14) v1(88.89,68.14) v1(88.9,66.13) v1(88.89,64.14) v1(88.89,62.14) v1(88.89,61.14) v1(88.89,60.14) v1(88.89,59.14) v1(88.89,58.14) v1(88.89,57.14) v1(88.89,56.14) v1(88.89,55.14) v1(88.89,54.14) v1(88.89,53.14) v1(88.89,51.14) v1(88.89,49.14) v1(88.89,47.14) v1(88.89,45.14) v1(88.89,43.14) v1(88.89,41.14) v1(88.89,39.14) v1(88.89,38.14) v1(89.17,11) v1(89.15,5.94) v1(89.15,2.2) v1(89.34,25.74) v1(89.34,24.94) v1(89.34,23.34) v1(89.34,19.34) v1(89.34,16.94) v1(89.54,105.69) v1(89.76,80.64) v1(89.76,79.64) v1(89.76,74.64) v1(89.76,72.64) v1(89.76,66.64) v1(89.76,64.64) v1(89.76,62.64) v1(89.76,61.64) v1(89.76,59.64) v1(89.76,57.64) v1(89.76,55.64) v1(89.76,53.64) v1(89.76,51.64) v1(89.76,49.64) v1(89.76,47.64) v1(89.76,45.64) v1(89.76,43.64) v1(89.76,41.64) v1(89.76,39.64) v1(89.76,38.64) v1(89.76,37.64) v1(90.14,28.94) v1(90.14,28.14) v1(90.14,26.54) v1(90.15,5.94) v1(90.15,2.2) v1(90.34,97.03) v1(90.39,101.73) v1(90.63,80.14) v1(90.63,79.14) v1(90.63,75.14) v1(90.63,74.14) v1(90.63,73.14) v1(90.63,72.14) v1(90.63,71.14) v1(90.63,68.14) v1(90.63,67.14) v1(90.63,66.14) v1(90.63,65.14) v1(90.63,64.14) v1(90.63,63.14) v1(90.63,62.14) v1(90.63,60.14) v1(90.63,58.14) v1(90.63,56.14) v1(90.63,54.14) v1(90.63,53.14) v1(90.63,52.14) v1(90.63,51.14) v1(90.63,50.14) v1(90.63,49.14) v1(90.63,48.14) v1(90.63,47.14) v1(90.63,46.14) v1(90.63,45.14) v1(90.63,44.14) v1(90.63,43.14) v1(90.63,42.14) v1(90.63,41.14) v1(90.63,40.14) v1(90.63,39.14) v1(90.63,38.14) v1(90.94,25.74) v1(91.24,106.26) v1(91.24,99.34) v1(91.15,11) v1(91.15,5.94) v1(91.15,2.2) v1(91.49,80.64) v1(91.49,79.64) v1(91.49,77.64) v1(91.49,73.64) v1(91.49,71.64) v1(91.49,69.64) v1(91.49,67.63) v1(91.49,65.64) v1(91.49,63.64) v1(91.49,62.64) v1(91.49,61.64) v1(91.49,60.64) v1(91.49,59.64) v1(91.49,58.64) v1(91.49,57.64) v1(91.49,56.64) v1(91.49,55.64) v1(91.49,54.64) v1(91.49,53.64) v1(91.49,52.64) v1(91.49,50.64) v1(91.49,48.64) v1(91.49,46.64) v1(91.49,44.64) v1(91.49,42.64) v1(91.49,40.64) v1(91.49,38.64) v1(91.49,37.64) v1(91.65,8.21) v1(92.09,100.96) v1(92.15,5.94) v1(92.15,2.2) v1(92.36,81.14) v1(92.36,80.14) v1(92.36,79.14) v1(92.36,77.14) v1(92.36,75.14) v1(92.36,73.14) v1(92.36,71.14) v1(92.36,69.14) v1(92.36,67.14) v1(92.36,65.14) v1(92.36,63.14) v1(92.36,62.14) v1(92.36,61.14) v1(92.36,60.14) v1(92.36,59.14) v1(92.36,58.14) v1(92.36,57.14) v1(92.36,56.14) v1(92.36,55.14) v1(92.36,54.14) v1(92.36,53.14) v1(92.36,52.14) v1(92.36,50.14) v1(92.36,48.14) v1(92.36,46.14) v1(92.36,44.14) v1(92.36,42.14) v1(92.36,40.14) v1(92.36,38.14) v1(92.65,8.21) v1(92.94,106.2) v1(92.94,99.34) v1(93.23,80.64) v1(93.23,79.64) v1(93.23,77.64) v1(93.23,76.64) v1(93.23,75.64) v1(93.23,74.64) v1(93.23,73.64) v1(93.23,72.64) v1(93.23,71.64) v1(93.23,70.64) v1(93.23,69.64) v1(93.23,68.64) v1(93.23,67.64) v1(93.23,66.64) v1(93.23,65.64) v1(93.23,64.64) v1(93.23,63.64) v1(93.23,61.64) v1(93.23,60.64) v1(93.23,59.64) v1(93.23,58.64) v1(93.23,57.64) v1(93.23,56.64) v1(93.23,55.64) v1(93.23,54.64) v1(93.23,53.64) v1(93.23,52.64) v1(93.23,51.64) v1(93.23,50.64) v1(93.23,49.64) v1(93.23,48.64) v1(93.23,47.64) v1(93.23,46.64) v1(93.23,45.64) v1(93.23,44.64) v1(93.23,43.64) v1(93.23,42.64) v1(93.23,41.64) v1(93.23,40.64) v1(93.23,39.64) v1(93.23,38.64) v1(93.23,37.64) v1(93.17,11) v1(93.15,5.94) v1(93.15,2.2) v1(93.79,101.73) v1(93.77,93.28) v1(94.09,81.14) v1(94.09,80.14) v1(94.09,76.14) v1(94.09,74.14) v1(94.09,70.14) v1(94.09,68.14) v1(94.09,66.14) v1(94.09,64.14) v1(94.09,62.14) v1(94.09,61.14) v1(94.09,60.14) v1(94.09,59.14) v1(94.09,58.14) v1(94.09,57.14) v1(94.09,56.14) v1(94.09,55.14) v1(94.09,54.14) v1(94.09,53.14) v1(94.09,51.14) v1(94.09,49.14) v1(94.09,47.14) v1(94.09,45.14) v1(94.09,43.14) v1(94.09,41.14) v1(94.09,39.14) v1(94.14,16.94) v1(94.15,5.94) v1(94.15,2.2) v1(94.64,106.14) v1(94.62,98.7) v1(94.94,28.94) v1(94.94,26.54) v1(94.94,25.74) v1(94.94,24.14) v1(94.96,80.64) v1(94.96,74.64) v1(94.96,72.64) v1(94.96,70.64) v1(94.96,68.64) v1(94.96,66.64) v1(94.96,64.64) v1(94.96,63.64) v1(94.96,62.64) v1(94.96,61.64) v1(94.96,60.64) v1(94.96,59.64) v1(94.96,58.64) v1(94.96,57.64) v1(94.96,56.64) v1(94.96,55.64) v1(94.96,54.64) v1(94.96,53.64) v1(94.96,51.64) v1(94.96,49.64) v1(94.96,47.64) v1(94.96,45.64) v1(94.96,43.64) v1(94.96,41.64) v1(94.96,39.64) v1(94.96,37.64) v1(95.17,95.84) v1(95.15,11) v1(95.15,5.94) v1(95.15,2.2) v1(95.49,101.66) v1(95.49,94.17) v1(95.68,104.48) v1(95.74,27.34) v1(95.74,23.34) v1(95.82,81.14) v1(95.82,80.14) v1(95.82,79.14) v1(95.82,78.14) v1(95.82,77.14) v1(95.82,76.14) v1(95.82,75.14) v1(95.82,74.14) v1(95.82,73.14) v1(95.82,72.14) v1(95.82,71.14) v1(95.82,70.14) v1(95.82,69.14) v1(95.82,68.14) v1(95.82,67.14) v1(95.82,66.14) v1(95.82,65.14) v1(95.82,64.14) v1(95.82,63.14) v1(95.82,62.14) v1(95.82,61.14) v1(95.82,60.14) v1(95.82,59.14) v1(95.82,58.14) v1(95.82,57.14) v1(95.82,56.14) v1(95.82,55.14) v1(95.82,54.14) v1(95.82,53.14) v1(95.82,52.14) v1(95.82,51.14) v1(95.82,50.14) v1(95.82,49.14) v1(95.82,48.14) v1(95.82,47.14) v1(95.82,46.14) v1(95.82,45.14) v1(95.82,44.14) v1(95.82,43.14) v1(95.82,42.14) v1(95.82,41.14) v1(95.82,40.14) v1(95.82,39.14) v1(95.82,38.14) v1(96.15,5.94) v1(96.15,2.2) v1(96.34,106.2) v1(96.56,104.46) v1(96.69,79.64) v1(96.69,75.64) v1(96.69,73.64) v1(96.69,71.64) v1(96.69,69.64) v1(96.69,65.64) v1(96.69,64.64) v1(96.69,63.64) v1(96.69,62.64) v1(96.69,61.64) v1(96.69,59.64) v1(96.69,58.64) v1(96.69,57.64) v1(96.69,54.64) v1(96.69,52.64) v1(96.69,50.64) v1(96.69,48.64) v1(96.69,46.64) v1(96.69,44.64) v1(96.69,42.64) v1(96.69,40.64) v1(96.69,38.64) v1(96.69,37.64) v1(96.65,10.56) v1(96.65,8.21) v1(97.15,5.94) v1(97.15,2.2) v1(97.56,75.14) v1(97.56,73.14) v1(97.56,71.14) v1(97.56,69.14) v1(97.56,65.14) v1(97.56,64.14) v1(97.56,63.14) v1(97.56,62.14) v1(97.56,58.14) v1(97.56,54.14) v1(97.56,52.14) v1(97.56,50.14) v1(97.56,48.14) v1(97.56,46.14) v1(97.56,44.14) v1(97.56,42.14) v1(97.56,40.14) v1(97.56,38.14) v1(97.65,8.21) v1(98.04,101.73) v1(98.17,11) v1(98.15,5.94) v1(98.15,2.2) v1(98.42,80.64) v1(98.42,79.64) v1(98.42,78.64) v1(98.42,77.64) v1(98.42,76.64) v1(98.42,75.64) v1(98.42,74.64) v1(98.42,73.64) v1(98.42,72.64) v1(98.42,71.64) v1(98.42,70.64) v1(98.42,69.64) v1(98.42,68.64) v1(98.42,67.64) v1(98.42,66.64) v1(98.42,65.64) v1(98.42,64.64) v1(98.42,63.64) v1(98.42,62.64) v1(98.42,59.64) v1(98.42,58.64) v1(98.42,57.64) v1(98.42,55.64) v1(98.42,54.64) v1(98.42,53.64) v1(98.42,52.64) v1(98.42,50.64) v1(98.42,49.64) v1(98.42,48.64) v1(98.42,46.64) v1(98.42,45.64) v1(98.42,44.64) v1(98.42,43.64) v1(98.42,42.64) v1(98.42,41.64) v1(98.42,40.64) v1(98.42,39.64) v1(98.42,38.64) v1(98.42,37.64) v1(98.49,97.33) v1(98.89,106.2) v1(98.89,98.52) v1(99.15,5.94) v1(99.15,2.2) v1(99.29,78.14) v1(99.29,76.14) v1(99.29,42.14) v1(99.29,41.14) v1(99.29,39.14) v1(99.5,25.74) v1(99.5,24.94) v1(99.5,23.34) v1(99.5,19.34) v1(99.5,16.94) v1(99.59,74.11) v1(99.59,73.19) v1(99.59,71.35) v1(99.59,67.67) v1(99.59,63.07) v1(99.59,62.15) v1(99.59,59.39) v1(99.59,58.47) v1(99.59,56.63) v1(99.59,46.51) v1(99.68,100.96) v1(100.15,80.64) v1(100.15,78.64) v1(100.15,77.64) v1(100.15,76.64) v1(100.15,41.64) v1(100.15,39.64) v1(100.15,37.64) v1(100.15,11) v1(100.15,5.94) v1(100.15,2.2) v1(100.3,28.94) v1(100.3,28.14) v1(100.3,26.54) v1(100.39,75.49) v1(100.39,73.65) v1(100.39,72.73) v1(100.39,70.89) v1(100.39,69.97) v1(100.39,64.45) v1(100.39,63.53) v1(100.39,62.61) v1(100.39,61.69) v1(100.39,60.77) v1(100.39,59.85) v1(100.39,58.93) v1(100.39,57.09) v1(100.38,48.81) v1(100.38,44.21) v1(100.59,106.2) v1(100.63,99.35) v1(100.65,8.21) v1(101.02,80.14) v1(101.02,79.14) v1(101.02,78.14) v1(101.02,77.14) v1(101.02,42.14) v1(101.02,41.14) v1(101.02,40.14) v1(101.02,39.14) v1(101.02,38.14) v1(101.1,25.74) v1(101.18,75.95) v1(101.18,73.19) v1(101.18,72.27) v1(101.18,69.51) v1(101.18,68.59) v1(101.18,67.67) v1(101.18,65.83) v1(101.18,60.31) v1(101.18,59.39) v1(101.18,58.47) v1(101.18,57.55) v1(101.18,56.63) v1(101.18,55.71) v1(101.18,54.79) v1(101.18,53.87) v1(101.18,52.95) v1(101.18,52.03) v1(101.18,51.11) v1(101.18,49.27) v1(101.18,46.51) v1(101.15,5.94) v1(101.15,2.2) v1(101.44,100.96) v1(101.44,93.34) v1(101.65,8.21) v1(101.98,80.09) v1(101.98,76.41) v1(101.98,75.49) v1(101.98,71.81) v1(101.98,68.13) v1(101.98,63.53) v1(101.98,60.77) v1(101.98,59.85) v1(101.98,58.93) v1(101.98,58.01) v1(101.98,57.09) v1(101.98,56.17) v1(101.98,48.81) v1(101.98,44.21) v1(101.98,42.37) v1(101.98,41.45) v1(101.98,40.53) v1(101.98,39.61) v1(101.98,38.69) v1(101.98,37.77) v1(102.17,11) v1(102.15,5.94) v1(102.15,2.2) v1(102.29,106.2) v1(102.29,99.34) v1(102.78,77.79) v1(102.77,73.19) v1(102.77,71.35) v1(102.77,70.43) v1(102.78,64.91) v1(102.78,63.07) v1(102.78,61.23) v1(102.78,60.31) v1(102.78,59.39) v1(102.78,58.47) v1(102.78,57.55) v1(102.78,56.63) v1(102.77,52.03) v1(102.77,49.27) v1(102.77,46.51) v1(102.77,42.83) v1(102.77,40.99) v1(103.14,101.73) v1(103.15,5.94) v1(103.15,2.2) v1(103.3,95.94) v1(103.58,80.09) v1(103.57,75.49) v1(103.57,71.81) v1(103.57,68.13) v1(103.57,65.37) v1(103.57,62.61) v1(103.57,59.85) v1(103.57,58.93) v1(103.57,58.01) v1(103.57,57.09) v1(103.57,55.25) v1(103.57,52.49) v1(103.57,48.81) v1(103.57,44.21) v1(103.57,42.37) v1(103.57,38.69) v1(103.99,106.14) v1(103.99,97.97) v1(104.15,11) v1(104.15,5.94) v1(104.15,2.2) v1(104.3,16.94) v1(104.37,77.79) v1(104.37,73.19) v1(104.37,70.43) v1(104.37,66.75) v1(104.37,64.91) v1(104.37,63.07) v1(104.37,61.23) v1(104.37,60.31) v1(104.37,59.39) v1(104.37,58.47) v1(104.37,57.55) v1(104.37,54.79) v1(104.37,53.87) v1(104.37,51.11) v1(104.37,50.19) v1(104.37,49.27) v1(104.37,45.59) v1(104.37,40.99) v1(104.65,8.21) v1(105.1,28.94) v1(105.1,26.54) v1(105.1,25.74) v1(105.1,24.14) v1(105.17,75.49) v1(105.17,71.81) v1(105.17,69.05) v1(105.17,64.45) v1(105.17,63.53) v1(105.17,62.61) v1(105.17,61.69) v1(105.17,60.77) v1(105.17,59.85) v1(105.17,58.93) v1(105.17,58.01) v1(105.17,57.09) v1(105.17,52.49) v1(105.17,49.73) v1(105.17,47.89) v1(105.17,43.29) v1(105.16,38.69) v1(105.15,5.94) v1(105.15,2.2) v1(105.67,106.2) v1(105.69,98.52) v1(105.65,8.21) v1(105.9,27.34) v1(105.9,23.34) v1(105.96,77.79) v1(105.96,73.19) v1(105.96,70.43) v1(105.96,68.59) v1(105.96,65.83) v1(105.96,61.23) v1(105.96,60.31) v1(105.96,58.47) v1(105.96,56.63) v1(105.96,52.95) v1(105.96,50.19) v1(105.96,49.27) v1(105.96,45.59) v1(105.96,40.99) v1(106.17,11) v1(106.15,5.94) v1(106.15,2.2) v1(106.76,80.09) v1(106.76,75.49) v1(106.76,71.81) v1(106.76,67.21) v1(106.76,60.77) v1(106.76,57.09) v1(106.76,56.17) v1(106.76,55.25) v1(106.76,52.49) v1(106.76,50.65) v1(106.76,47.89) v1(106.76,43.29) v1(106.76,38.69) v1(106.76,36.67) v1(106.98,96.98) v1(106.98,96.4) v1(106.95,95.86) v1(107.07,91.9) v1(107.15,5.94) v1(107.15,2.2) v1(107.39,101.73) v1(107.39,94.04) v1(107.56,77.79) v1(107.56,73.19) v1(107.56,71.35) v1(107.56,70.43) v1(107.56,68.59) v1(107.56,67.67) v1(107.56,63.07) v1(107.56,58.47) v1(107.56,56.63) v1(107.56,54.79) v1(107.56,52.95) v1(107.56,51.11) v1(107.56,50.19) v1(107.56,45.59) v1(107.56,40.99) v1(108.24,98.52) v1(108.15,11) v1(108.15,5.94) v1(108.15,2.2) v1(108.29,106.2) v1(108.36,80.09) v1(108.35,75.49) v1(108.35,71.81) v1(108.35,66.29) v1(108.35,62.61) v1(108.35,60.77) v1(108.35,57.09) v1(108.35,54.33) v1(108.35,51.57) v1(108.35,47.89) v1(108.35,43.29) v1(108.35,38.69) v1(108.35,36.67) v1(108.65,8.21) v1(109.09,101.73) v1(109.09,93.34) v1(109.15,73.19) v1(109.15,71.35) v1(109.15,70.43) v1(109.15,68.59) v1(109.15,53.87) v1(109.15,51.11) v1(109.15,48.35) v1(109.15,47.43) v1(109.15,45.59) v1(109.15,40.99) v1(109.15,77.79) v1(109.15,64.91) v1(109.15,62.15) v1(109.15,59.39) v1(109.15,56.63) v1(109.15,5.94) v1(109.15,2.2) v1(109.66,24.94) v1(109.66,23.34) v1(109.66,19.34) v1(109.66,16.94) v1(109.65,8.21) v1(109.94,98.52) v1(109.95,80.09) v1(109.95,75.49) v1(109.95,71.81) v1(109.95,67.21) v1(109.95,64.45) v1(109.95,61.69) v1(109.95,58.93) v1(109.94,56.18) v1(109.95,53.41) v1(109.95,46.97) v1(109.95,43.29) v1(109.95,38.69) v1(110.04,106.96) v1(110.17,11) v1(110.15,5.94) v1(110.15,2.2) v1(110.46,28.94) v1(110.46,28.14) v1(110.46,26.54) v1(110.74,77.79) v1(110.74,73.19) v1(110.74,70.43) v1(110.74,69.51) v1(110.74,66.75) v1(110.74,63.99) v1(110.74,61.23) v1(110.74,58.47) v1(110.74,52.95) v1(110.74,50.19) v1(110.74,48.35) v1(110.74,45.59) v1(110.74,40.99) v1(110.78,101.02) v1(110.79,94.17) v1(110.76,55.69) v1(111.15,5.94) v1(111.15,2.2) v1(111.26,25.74) v1(111.54,80.09) v1(111.54,75.49) v1(111.54,71.81) v1(111.54,66.29) v1(111.54,52.49) v1(111.54,46.97) v1(111.54,43.29) v1(111.54,38.69) v1(111.64,99.34) v1(111.63,92.55) v1(112.15,11) v1(112.15,5.94) v1(112.15,2.2) v1(112.34,77.79) v1(112.34,73.19) v1(112.34,70.43) v1(112.34,68.59) v1(112.34,65.83) v1(112.34,52.03) v1(112.34,51.11) v1(112.34,50.19) v1(112.34,49.27) v1(112.34,48.35) v1(112.34,45.59) v1(112.34,40.99) v1(112.65,8.21) v1(113.06,86.08) v1(113.14,80.09) v1(113.13,75.49) v1(113.13,71.81) v1(113.13,65.37) v1(113.13,51.57) v1(113.13,46.97) v1(113.13,43.29) v1(113.13,38.69) v1(113.15,5.94) v1(113.15,2.2) v1(113.34,97.24) v1(113.32,95.59) v1(113.39,104.84) v1(113.65,8.21) v1(113.93,77.79) v1(113.93,73.19) v1(113.93,70.43) v1(113.91,69.5) v1(113.93,68.59) v1(113.93,64.91) v1(113.93,63.99) v1(113.93,63.07) v1(113.93,62.15) v1(113.93,61.23) v1(113.93,60.31) v1(113.93,59.39) v1(113.93,58.47) v1(113.93,57.55) v1(113.93,56.63) v1(113.93,55.71) v1(113.93,54.79) v1(113.93,50.19) v1(113.93,49.27) v1(113.93,48.35) v1(113.93,45.59) v1(113.93,40.99) v1(114.23,104.82) v1(114.21,100.04) v1(114.19,92.55) v1(114.17,11) v1(114.15,5.94) v1(114.15,2.2) v1(114.46,16.94) v1(114.73,75.49) v1(114.73,71.81) v1(114.73,67.21) v1(114.73,53.41) v1(114.73,46.97) v1(114.73,43.29) v1(114.73,38.69) v1(115.05,103.36) v1(115.07,95.88) v1(115.15,5.94) v1(115.15,2.2) v1(115.26,28.94) v1(115.26,25.74) v1(115.26,24.14) v1(115.53,77.79) v1(115.52,73.19) v1(115.52,68.59) v1(115.52,52.95) v1(115.52,50.19) v1(115.52,49.27) v1(115.52,48.35) v1(115.52,45.59) v1(115.52,40.99) v1(115.95,95.88) v1(116.06,23.34) v1(116.06,21.74) v1(116.15,11) v1(116.15,5.94) v1(116.15,2.2) v1(116.32,80.09) v1(116.32,75.49) v1(116.32,71.81) v1(116.32,66.29) v1(116.32,63.07) v1(116.32,55.71) v1(116.32,52.49) v1(116.32,46.97) v1(116.32,43.29) v1(116.32,38.69) v1(116.75,104.82) v1(116.65,8.21) v1(117.12,77.79) v1(117.12,73.19) v1(117.12,70.43) v1(117.1,69.55) v1(117.12,68.59) v1(117.12,65.83) v1(117.12,62.61) v1(117.12,56.17) v1(117.12,52.03) v1(117.12,50.19) v1(117.12,49.27) v1(117.12,48.35) v1(117.12,45.59) v1(117.12,40.99) v1(117.15,5.92) v1(117.15,2.2) v1(117.56,95.34) v1(117.65,8.21) v1(117.92,80.09) v1(117.92,75.49) v1(117.92,63.07) v1(117.92,55.71) v1(117.91,51.57) v1(117.91,46.97) v1(117.91,43.29) v1(117.91,38.69) v1(118.04,104.82) v1(118.17,11) v1(118.15,5.94) v1(118.15,2.2) v1(118.45,103.37) v1(118.65,68.54) v1(118.71,77.79) v1(118.71,73.19) v1(118.72,69.58) v1(118.71,64.91) v1(118.71,53.87) v1(118.71,50.19) v1(118.71,49.27) v1(118.71,48.35) v1(118.71,45.59) v1(118.71,40.99) v1(119.15,5.94) v1(119.15,2.2) v1(119.26,95.34) v1(119.51,80.09) v1(119.51,75.49) v1(119.51,71.81) v1(119.51,67.21) v1(119.51,63.53) v1(119.51,62.61) v1(119.51,61.69) v1(119.51,60.77) v1(119.51,59.85) v1(119.51,58.93) v1(119.51,58.01) v1(119.51,57.09) v1(119.51,56.17) v1(119.51,55.25) v1(119.51,53.41) v1(119.51,46.97) v1(119.51,43.29) v1(119.51,38.69) v1(120.15,11) v1(120.15,5.94) v1(120.15,2.2) v1(120.31,77.79) v1(120.31,73.19) v1(120.31,69.51) v1(120.3,68.59) v1(120.31,52.95) v1(120.31,50.19) v1(120.31,49.27) v1(120.31,48.35) v1(120.31,45.59) v1(120.3,40.99) v1(120.65,8.21) v1(121.1,80.09) v1(121.1,75.49) v1(121.1,71.81) v1(121.1,66.29) v1(121.1,52.49) v1(121.1,46.97) v1(121.1,43.29) v1(121.1,38.69) v1(121.15,5.94) v1(121.15,2.2) v1(121.65,8.21) v1(121.9,77.79) v1(121.9,73.19) v1(121.93,68.59) v1(121.9,65.83) v1(121.9,52.03) v1(121.9,50.19) v1(121.9,49.27) v1(121.9,48.35) v1(121.9,45.59) v1(121.9,40.99) v1(122.02,27.24) v1(122.02,23.97) v1(122.02,22.46) v1(122.17,11) v1(122.15,5.94) v1(122.15,2.2) v1(122.41,97.09) v1(122.71,103.37) v1(122.7,80.09) v1(122.7,75.49) v1(122.7,71.81) v1(122.7,65.37) v1(122.7,62.61) v1(122.7,57.09) v1(122.7,54.33) v1(122.7,46.97) v1(122.7,43.29) v1(122.7,38.69) v1(122.8,95.34) v1(122.87,25.66) v1(122.87,24.86) v1(122.87,23.26) v1(122.87,21.66) v1(122.87,19.26) v1(123.15,5.94) v1(123.15,2.2) v1(123.49,77.79) v1(123.49,73.19) v1(123.49,71.35) v1(123.49,68.59) v1(123.49,67.67) v1(123.49,64.91) v1(123.49,59.39) v1(123.49,56.63) v1(123.49,53.87) v1(123.49,51.11) v1(123.49,49.27) v1(123.49,45.59) v1(123.49,40.99) v1(123.67,28.86) v1(123.67,28.06) v1(123.67,26.46) v1(124.15,11) v1(124.15,5.94) v1(124.15,2.2) v1(124.29,83.11) v1(124.29,80.09) v1(124.29,75.49) v1(124.29,70.89) v1(124.29,69.05) v1(124.29,67.21) v1(124.29,64.45) v1(124.29,61.69) v1(124.29,58.93) v1(124.29,56.17) v1(124.29,53.41) v1(124.29,52.49) v1(124.29,47.89) v1(124.29,46.97) v1(124.29,43.29) v1(124.29,38.69) v1(124.47,25.66) v1(124.58,12.29) v1(124.65,8.21) v1(125.09,77.79) v1(125.09,73.19) v1(125.09,69.51) v1(125.09,68.59) v1(125.09,64.91) v1(125.09,63.07) v1(125.09,61.23) v1(125.09,59.39) v1(125.09,57.55) v1(125.09,55.71) v1(125.09,53.87) v1(125.09,50.19) v1(125.09,49.27) v1(125.09,47.43) v1(125.09,45.59) v1(125.09,40.99) v1(125.15,5.94) v1(125.15,2.2) v1(125.41,36.21) v1(125.48,28.07) v1(125.65,8.21) v1(125.88,80.09) v1(125.88,75.49) v1(125.88,70.89) v1(125.88,66.29) v1(125.88,65.37) v1(125.88,64.45) v1(125.88,62.61) v1(125.88,61.69) v1(125.88,60.77) v1(125.88,59.85) v1(125.88,58.93) v1(125.88,57.09) v1(125.88,53.41) v1(125.88,47.89) v1(125.88,46.97) v1(125.88,43.29) v1(125.88,38.69) v1(126,34.8) v1(126.11,27.18) v1(126.11,26.67) v1(126.17,11) v1(126.15,5.94) v1(126.15,2.2) v1(126.68,77.79) v1(126.68,73.19) v1(126.68,66.75) v1(126.68,65.83) v1(126.68,64.91) v1(126.68,63.99) v1(126.68,63.07) v1(126.68,62.15) v1(126.68,61.23) v1(126.68,60.31) v1(126.68,59.39) v1(126.68,56.63) v1(126.68,52.95) v1(126.68,50.19) v1(126.68,45.59) v1(126.68,40.99) v1(127.15,5.94) v1(127.15,2.2) v1(127.48,80.09) v1(127.48,75.49) v1(127.48,70.89) v1(127.48,67.21) v1(127.48,66.29) v1(127.48,65.37) v1(127.48,64.45) v1(127.48,63.53) v1(127.48,62.61) v1(127.48,61.69) v1(127.48,60.77) v1(127.48,59.85) v1(127.48,57.09) v1(127.48,52.49) v1(127.48,47.89) v1(127.48,43.29) v1(127.48,38.69) v1(127.67,16.86) v1(128.14,2.2) v1(128.15,11) v1(128.2,5.94) v1(128.27,77.79) v1(128.27,73.19) v1(128.27,66.75) v1(128.27,65.83) v1(128.27,64.91) v1(128.27,63.99) v1(128.27,63.07) v1(128.27,62.15) v1(128.27,61.23) v1(128.27,60.31) v1(128.27,59.39) v1(128.27,58.47) v1(128.27,55.71) v1(128.27,50.19) v1(128.27,45.59) v1(128.27,40.99) v1(128.47,28.86) v1(128.47,26.46) v1(128.47,25.66) v1(128.47,24.06) v1(129.04,103.96) v1(129.07,75.49) v1(129.07,70.89) v1(129.07,67.21) v1(129.07,66.29) v1(129.07,65.37) v1(129.07,64.45) v1(129.07,63.53) v1(129.07,62.61) v1(129.07,61.69) v1(129.07,60.77) v1(129.07,58.93) v1(129.07,57.09) v1(129.07,54.33) v1(129.07,47.89) v1(129.07,43.29) v1(129.07,38.69) v1(129.27,27.26) v1(129.87,77.79) v1(129.87,73.19) v1(129.87,68.59) v1(129.87,67.67) v1(129.87,66.75) v1(129.87,65.83) v1(129.87,64.91) v1(129.87,63.99) v1(129.87,63.07) v1(129.87,62.15) v1(129.87,61.23) v1(129.87,60.31) v1(129.87,57.55) v1(129.87,50.19) v1(129.87,45.59) v1(129.87,40.99) v1(130.16,28.07) v1(130.16,22.56) v1(130.16,17.76) v1(130.16,16.86) v1(130.3,106.89) v1(130.3,105.62) v1(130.29,102.31) v1(130.3,101.04) v1(130.3,99.22) v1(130.35,98.2) v1(130.67,83.12) v1(130.7,80.09) v1(130.66,75.49) v1(130.66,70.91) v1(130.66,68.13) v1(130.66,67.21) v1(130.66,66.29) v1(130.66,65.37) v1(130.66,64.45) v1(130.66,63.53) v1(130.66,62.61) v1(130.66,61.69) v1(130.66,60.77) v1(130.66,53.41) v1(130.66,51.57) v1(130.66,47.89) v1(130.66,43.29) v1(130.66,38.69) v1(130.76,24.77) v1(130.76,23.87) v1(131.46,77.79) v1(131.46,73.19) v1(131.46,67.67) v1(131.46,65.83) v1(131.46,64.91) v1(131.46,63.99) v1(131.46,63.07) v1(131.46,62.15) v1(131.46,60.31) v1(131.46,59.39) v1(131.46,58.47) v1(131.46,57.55) v1(131.46,56.63) v1(131.46,55.71) v1(131.46,54.79) v1(131.46,53.87) v1(131.46,51.11) v1(131.46,50.19) v1(131.46,45.59) v1(131.46,40.99) v1(132.04,97.22) v1(132.18,27.24) v1(132.18,23.97) v1(132.18,22.46) v1(132.26,80.09) v1(132.26,75.49) v1(132.26,70.89) v1(132.26,47.89) v1(132.26,43.29) v1(132.26,38.69) v1(133.03,25.66) v1(133.03,24.86) v1(133.03,19.26) v1(133.03,16.86) v1(133.05,77.79) v1(133.05,73.19) v1(133.05,67.67) v1(133.05,50.19) v1(133.05,45.59) v1(133.05,43.75) v1(133.05,40.99) v1(133.83,28.86) v1(133.83,28.06) v1(133.83,26.46) v1(133.85,80.09) v1(133.85,38.69) v1(134,75.1) v1(134,74.1) v1(134,73.1) v1(134,72.1) v1(134,71.1) v1(134,68.1) v1(134,66.1) v1(134,65.1) v1(134,64.1) v1(134,63.1) v1(134,62.1) v1(134,59.1) v1(134,58.1) v1(134,57.1) v1(134,56.1) v1(134,55.1) v1(134,54.1) v1(134,53.1) v1(134,52.1) v1(134,51.1) v1(134,50.1) v1(134,49.1) v1(134,48.1) v1(134,47.1) v1(134,46.1) v1(134,45.1) v1(134,44.1) v1(134,43.1) v1(134.58,104.9) v1(134.56,102.93) v1(134.58,95.34) v1(134.65,77.79) v1(134.65,40.99) v1(134.63,25.66) v1(134.87,74.6) v1(134.87,72.6) v1(134.87,70.6) v1(134.87,68.6) v1(134.87,66.6) v1(134.87,64.6) v1(134.87,62.6) v1(134.87,60.6) v1(134.87,58.6) v1(134.87,56.6) v1(134.87,54.6) v1(134.87,52.6) v1(134.87,50.6) v1(134.87,48.6) v1(134.87,46.6) v1(134.87,44.6) v1(134.87,42.6) v1(135.45,80.09) v1(135.44,38.69) v1(135.64,28.07) v1(135.73,75.1) v1(135.73,73.1) v1(135.73,71.1) v1(135.73,69.1) v1(135.73,67.1) v1(135.73,65.1) v1(135.73,63.1) v1(135.73,61.1) v1(135.73,59.1) v1(135.73,57.1) v1(135.73,55.1) v1(135.73,53.1) v1(135.73,51.1) v1(135.73,49.1) v1(135.73,47.1) v1(135.73,45.1) v1(135.73,43.1) v1(136.24,40.99) v1(136.24,27.18) v1(136.24,26.67) v1(136.3,102.96) v1(136.28,95.34) v1(136.6,75.6) v1(136.6,74.6) v1(136.6,73.6) v1(136.6,72.6) v1(136.6,71.6) v1(136.6,70.6) v1(136.6,69.6) v1(136.6,68.6) v1(136.6,67.6) v1(136.6,66.6) v1(136.6,65.6) v1(136.6,64.6) v1(136.6,63.6) v1(136.6,62.6) v1(136.6,61.6) v1(136.6,60.6) v1(136.6,59.6) v1(136.6,58.6) v1(136.6,57.6) v1(136.6,56.6) v1(136.6,55.6) v1(136.6,54.6) v1(136.6,53.6) v1(136.6,52.6) v1(136.6,51.6) v1(136.6,50.6) v1(136.6,49.6) v1(136.6,48.6) v1(136.6,47.6) v1(136.6,46.6) v1(136.6,45.6) v1(136.62,44.61) v1(136.6,43.6) v1(137.04,80.09) v1(137.04,38.69) v1(137.47,76.02) v1(137.47,74.1) v1(137.47,72.1) v1(137.47,70.1) v1(137.47,68.1) v1(137.47,66.1) v1(137.47,64.1) v1(137.47,62.1) v1(137.47,60.1) v1(137.47,58.1) v1(137.47,56.1) v1(137.47,54.1) v1(137.47,52.1) v1(137.47,50.1) v1(137.47,48.1) v1(137.47,46.1) v1(137.47,44.1) v1(137.84,40.99) v1(137.83,16.86) v1(138.33,75.6) v1(138.33,73.6) v1(138.33,71.6) v1(138.33,69.6) v1(138.33,67.6) v1(138.33,65.6) v1(138.33,63.6) v1(138.33,61.6) v1(138.33,59.6) v1(138.33,57.6) v1(138.33,53.6) v1(138.33,51.6) v1(138.33,49.6) v1(138.33,47.6) v1(138.33,45.6) v1(138.33,43.6) v1(138.49,97.37) v1(138.63,38.69) v1(138.63,28.86) v1(138.63,26.46) v1(138.63,25.66) v1(138.63,24.06) v1(138.82,95.32) v1(139.2,75.1) v1(139.2,74.1) v1(139.2,73.1) v1(139.2,72.1) v1(139.2,71.1) v1(139.2,70.1) v1(139.2,69.1) v1(139.2,68.1) v1(139.2,67.1) v1(139.2,66.1) v1(139.2,65.1) v1(139.2,64.1) v1(139.2,63.1) v1(139.2,62.1) v1(139.2,61.1) v1(139.2,60.1) v1(139.2,59.1) v1(139.2,58.1) v1(139.2,57.1) v1(139.2,56.1) v1(139.2,55.1) v1(139.2,54.1) v1(139.2,53.1) v1(139.2,52.1) v1(139.2,51.1) v1(139.2,50.1) v1(139.2,49.1) v1(139.2,48.1) v1(139.2,47.1) v1(139.2,46.1) v1(139.2,45.1) v1(139.2,44.1) v1(139.2,43.1) v1(139.43,77.79) v1(139.43,40.99) v1(139.43,27.26) v1(139.43,23.26) v1(140.06,74.6) v1(140.06,72.6) v1(140.06,70.6) v1(140.06,68.6) v1(140.06,66.6) v1(140.06,64.6) v1(140.06,62.6) v1(140.06,60.6) v1(140.06,58.6) v1(140.06,56.6) v1(140.06,54.6) v1(140.06,52.6) v1(140.06,50.6) v1(140.06,48.6) v1(140.06,46.6) v1(140.06,44.6) v1(140.06,42.6) v1(140.23,81.01) v1(140.23,80.09) v1(140.23,38.69) v1(140.23,37.77) v1(140.32,28.07) v1(140.32,22.56) v1(140.32,17.76) v1(140.32,16.86) v1(140.93,75.1) v1(140.93,73.1) v1(140.93,71.1) v1(140.93,69.1) v1(140.93,67.1) v1(140.93,65.1) v1(140.93,63.1) v1(140.93,61.1) v1(140.93,59.1) v1(140.93,57.1) v1(140.93,55.1) v1(140.93,53.1) v1(140.93,51.1) v1(140.93,49.1) v1(140.93,47.1) v1(140.93,45.1) v1(140.93,43.1) v1(140.92,24.77) v1(140.92,23.87) v1(141.02,77.79) v1(141.02,40.99) v1(141.38,103.01) v1(141.82,81.01) v1(141.8,75.6) v1(141.8,74.6) v1(141.8,73.6) v1(141.8,72.6) v1(141.8,71.6) v1(141.8,70.6) v1(141.8,69.6) v1(141.8,68.6) v1(141.8,67.6) v1(141.8,66.6) v1(141.8,65.6) v1(141.8,64.6) v1(141.8,63.6) v1(141.8,62.6) v1(141.8,61.6) v1(141.8,60.6) v1(141.8,59.6) v1(141.8,58.6) v1(141.8,57.6) v1(141.8,56.6) v1(141.8,55.6) v1(141.8,54.6) v1(141.8,53.6) v1(141.8,52.6) v1(141.8,51.6) v1(141.8,50.6) v1(141.8,49.6) v1(141.8,48.6) v1(141.8,47.6) v1(141.8,46.6) v1(141.8,45.6) v1(141.8,44.6) v1(141.8,43.6) v1(141.85,38.66) v1(141.82,37.77) v1(142.25,104.99) v1(142.34,27.24) v1(142.34,23.97) v1(142.34,22.46) v1(142.62,80.55) v1(142.62,79.63) v1(142.62,40.99) v1(142.62,39.15) v1(142.62,38.23) v1(142.66,76.02) v1(142.66,74.1) v1(142.66,72.1) v1(142.66,70.1) v1(142.66,68.1) v1(142.66,66.1) v1(142.66,64.1) v1(142.66,62.1) v1(142.66,60.1) v1(142.66,58.1) v1(142.66,56.1) v1(142.66,54.1) v1(142.66,52.1) v1(142.66,50.1) v1(142.66,48.1) v1(142.66,46.1) v1(142.66,44.1) v1(143.19,25.66) v1(143.19,24.86) v1(143.19,23.26) v1(143.19,19.26) v1(143.19,16.86) v1(143.41,79.17) v1(143.41,39.61) v1(143.41,38.69) v1(143.53,75.6) v1(143.53,73.6) v1(143.53,71.6) v1(143.53,69.6) v1(143.53,67.6) v1(143.53,65.6) v1(143.53,63.6) v1(143.53,61.6) v1(143.53,59.6) v1(143.53,57.6) v1(143.53,55.6) v1(143.53,53.6) v1(143.53,51.6) v1(143.53,49.6) v1(143.53,47.6) v1(143.53,45.6) v1(143.53,43.6) v1(143.57,97.37) v1(143.92,103.01) v1(143.93,95.32) v1(143.99,28.86) v1(143.99,28.06) v1(143.99,26.46) v1(144.4,59.1) v1(144.4,58.1) v1(144.4,57.1) v1(144.4,56.1) v1(144.4,55.1) v1(144.4,54.1) v1(144.84,97.34) v1(144.79,25.66) v1(145.65,100.27) v1(145.8,28.07) v1(146.4,27.18) v1(146.4,26.67) v1(146.49,104.82) v1(147.34,100.96) v1(147.34,100.27) v1(147.37,93.35) v1(147.99,16.86) v1(148.19,106.96) v1(148.19,99.34) v1(148.51,67.6) v1(148.79,28.86) v1(148.79,26.46) v1(148.79,25.66) v1(148.79,24.06) v1(149.04,101.6) v1(149.04,93.34) v1(149.49,69.17) v1(149.59,27.26) v1(149.59,23.26) v1(149.89,105.57) v1(149.89,98.64) v1(150.25,69.17) v1(150.19,44.71) v1(150.29,63.67) v1(150.34,59.09) v1(150.34,57.38) v1(150.48,28.07) v1(150.48,22.56) v1(150.48,17.76) v1(150.48,16.86) v1(150.74,101.65) v1(151.03,104.97) v1(151.08,24.77) v1(151.08,23.87) v1(151.23,91.39) v1(151.5,55.58) v1(151.59,105.57) v1(151.63,53.1) v1(151.66,104.97) v1(152.26,55.58) v1(152.27,53.1) v1(152.5,27.24) v1(152.5,23.97) v1(152.5,22.46) v1(153.19,101.65) v1(153.22,94.76) v1(153.35,25.7) v1(153.35,24.9) v1(153.35,23.3) v1(153.35,19.3) v1(153.35,16.86) v1(154.13,105.57) v1(154.14,97.95) v1(154.15,28.9) v1(154.15,28.1) v1(154.15,26.5) v1(154.95,25.7) v1(155.07,100.96) v1(155.84,106.94) v1(155.84,97.95) v1(155.96,28.11) v1(156.61,93.36) v1(156.56,27.21) v1(156.56,26.71) v1(156.56,21.71) v1(156.56,21.2) v1(157.53,99.34) v1(157.59,106.96) v1(158.15,16.9) v1(158.31,93.37) v1(158.48,101.32) v1(158.95,28.9) v1(158.95,26.5) v1(158.95,25.7) v1(158.95,24.1) v1(159.24,105.57) v1(159.24,98.7) v1(159.75,27.3) v1(159.75,23.3) v1(160.09,102.36) v1(160.09,100.96) v1(160.64,28.07) v1(160.64,17.76) v1(160.64,16.86) v1(160.78,24.85) v1(160.78,23.95) v1(160.87,98.66) v1(161.02,105.57) v1(161.56,23.26) v1(161.86,27.26) v1(162.59,102.36) v1(163.49,105.57) v1(163.49,97.95) v1(163.51,25.66) v1(163.51,23.26) v1(163.51,19.26) v1(164.34,102.36) v1(164.34,100.96) v1(164.34,93.34) v1(164.31,28.86) v1(164.31,28.06) v1(164.31,26.46) v1(165.11,25.66) v1(165.19,106.96) v1(165.19,97.95) v1(165.95,27.26) v1(166.04,93.34) v1(166.09,101.3) v1(166.89,106.45) v1(166.89,98.77) v1(166.89,28.86) v1(166.89,27.26) v1(166.89,26.46) v1(167.74,101.6) v1(167.74,94.04) v1(168.59,106.26) v1(168.59,99.34) v1(169.11,28.86) v1(169.11,26.46) v1(169.11,25.66) v1(169.11,24.06) v1(169.44,101.52) v1(169.44,94.04) v1(169.96,92.41) v1(170.21,99.34) v1(170.29,105.62) v1(170.46,92.14) v1(170.75,17.46) v1(170.85,24.86) v1(170.95,92.41) v1(171.99,101.52) v1(171.99,94.73) v1(172.84,106.33) v1(172.84,98.77) v1(172.87,20.06) v1(173.58,74.53) v1(173.69,100.96) v1(174.54,105.57) v1(174.53,97.97) v1(174.48,88.56) v1(174.51,65.8) v1(174.51,53.23) v1(174.51,37.1) v1(175.39,100.96) v1(175.39,93.34) v1(176.03,44.74) v1(176.05,24.27) v1(176.05,21.52) v1(176.05,16.38) v1(176.05,90.29) v1(176.24,105.57) v1(176.24,99.34) v1(176.18,59.85) v1(176.97,90.29) v1(177.11,101.86) v1(177.09,93.34) v1(177.11,40.46) v1(177.94,105.57) v1(177.94,98.64) v1(178.29,90.36) v1(178.8,100.99) v1(178.79,94.04) v1(179.41,54.57) v1(179.53,62.21) v1(179.53,61.19) v1(179.53,60.18) v1(179.53,59.16) v1(179.53,58.14) v1(179.64,105.57) v1(179.64,98.64) v1(179.55,29) v1(179.65,90.36) v1(179.86,27.79) v1(180.32,15.06) v1(180.55,54.57) v1(180.55,63.22) v1(180.55,62.21) v1(180.55,61.19) v1(180.55,60.18) v1(180.55,59.16) v1(180.55,58.14) v1(180.88,27.79) v1(181.13,22.56) v1(181.33,101.73) v1(181.34,94.36) v1(181.57,63.22) v1(181.57,62.21) v1(181.57,61.19) v1(181.57,60.18) v1(181.57,59.16) v1(181.57,58.14) v1(181.64,54.57) v1(181.87,29) v1(181.9,27.79) v1(182.19,105.57) v1(182.19,98.64) v1(182.4,18.75) v1(182.4,17.48) v1(182.47,54.57) v1(182.58,63.22) v1(182.58,62.21) v1(182.58,61.19) v1(182.58,60.18) v1(182.58,59.16) v1(182.7,66.02) v1(183.04,100.96) v1(183.04,93.34) v1(183.14,15.92) v1(183.14,15.01) v1(183.3,54.57) v1(183.47,92.55) v1(183.67,22.56) v1(183.89,105.57) v1(183.89,99.34) v1(183.85,42.29) v1(183.85,41.02) v1(184.38,82.64) v1(184.38,81.37) v1(184.38,80.1) v1(184.38,78.83) v1(184.64,63.2) v1(184.74,100.96) v1(184.74,93.34) v1(184.94,22.56) v1(184.94,20.02) v1(185.12,42.29) v1(185.12,41.02) v1(185.12,39.75) v1(185.53,99.35) v1(185.59,106.96) v1(185.65,87.72) v1(185.65,86.45) v1(185.65,85.18) v1(185.65,83.91) v1(185.65,77.56) v1(185.65,76.29) v1(185.65,75.02) v1(185.65,73.75) v1(185.78,70.13) v1(185.8,69.29) v1(185.91,63.2) v1(186.21,18.75) v1(186.21,17.48) v1(186.44,101.66) v1(186.39,47.37) v1(186.39,46.1) v1(186.39,44.83) v1(186.39,43.56) v1(186.39,41.02) v1(186.37,39.78) v1(186.39,37.21) v1(186.39,35.94) v1(186.39,34.67) v1(186.39,33.4) v1(186.47,94.83) v1(186.7,91.8) v1(186.92,87.72) v1(186.92,86.45) v1(186.92,75.02) v1(186.92,73.75) v1(186.87,63.13) v1(187.15,69.89) v1(187.29,105.57) v1(187.25,99.4) v1(187.53,80.71) v1(187.48,22.56) v1(187.66,47.37) v1(187.66,46.1) v1(187.66,44.83) v1(187.66,43.56) v1(187.66,37.21) v1(187.66,34.67) v1(187.66,33.4) v1(187.79,92.79) v1(187.79,92.03) v1(187.79,91.26) v1(188.14,94.04) v1(188.14,63.13) v1(188.19,87.72) v1(188.19,86.45) v1(188.19,85.18) v1(188.19,75.02) v1(188.19,73.75) v1(188.75,22.56) v1(188.75,21.29) v1(188.75,20.02) v1(188.9,90.55) v1(188.93,47.37) v1(188.93,46.1) v1(188.93,44.83) v1(188.93,43.56) v1(188.93,37.21) v1(188.93,34.67) v1(188.93,33.4) v1(188.99,98.64) v1(189.07,105.57) v1(189.46,87.72) v1(189.46,86.45) v1(189.46,85.18) v1(189.54,83.95) v1(189.46,76.29) v1(189.46,75.02) v1(189.46,73.75) v1(189.75,68.84) v1(189.75,68.07) v1(189.75,67.31) v1(189.77,64.21) v1(189.8,63.58) v1(189.77,60.02) v1(189.8,59.44) v1(190.02,18.75) v1(190.02,17.48) v1(190.1,80.44) v1(190.2,47.37) v1(190.2,44.83) v1(190.2,43.56) v1(190.2,37.21) v1(190.2,34.67) v1(190.2,33.4) v1(190.53,90.27) v1(190.51,68.84) v1(190.51,68.07) v1(190.51,67.31) v1(190.73,87.72) v1(190.73,86.45) v1(190.73,85.18) v1(190.73,76.29) v1(190.73,75.02) v1(190.73,73.75) v1(190.84,60.78) v1(191.27,68.84) v1(191.27,68.07) v1(191.27,67.31) v1(191.29,22.56) v1(191.42,90.27) v1(191.37,55.25) v1(191.54,105.57) v1(191.55,98.18) v1(191.47,44.83) v1(191.47,43.56) v1(191.47,37.21) v1(191.59,61.51) v1(192,87.72) v1(192,86.45) v1(192,85.18) v1(192,76.29) v1(192,75.02) v1(192,73.75) v1(192.4,100.98) v1(192.74,34.67) v1(193.01,26.69) v1(193.17,98.88) v1(193.21,90.55) v1(193.27,87.72) v1(193.27,85.18) v1(193.27,81.37) v1(193.27,80.1) v1(193.27,78.83) v1(193.27,76.29) v1(193.27,73.75) v1(193.83,18.75) v1(193.83,17.48) v1(193.89,70.37) v1(194.04,94.24) v1(194.04,93.41) v1(194.16,16.08) v1(194.54,82.64) v1(194.54,80.1) v1(194.54,78.83) v1(194.64,90.55) v1(194.93,106.94) v1(194.93,99.39) v1(195.18,61.6) v1(195.34,15.31) v1(195.33,14.15) v1(196.08,90.55) v1(196.48,68.81) v1(196.48,68.05) v1(196.48,67.29) v1(196.45,61.6) v1(196.78,84.88) v1(197.05,20.31) v1(197.05,18.54) v1(197.24,68.81) v1(197.24,68.05) v1(197.24,67.29) v1(197.51,90.55) v1(197.72,65.06) v1(197.94,19.42) v1(198,68.81) v1(198,68.05) v1(198.25,86.82) v1(198.43,54.04) v1(198.61,85.42) v1(198.84,69.85) v1(198.83,20.31) v1(198.83,18.54) v1(199.45,69.85) v1(199.4,22.21) v1(200.29,66.28) v1(200.26,62.87) v1(200.59,55.02) v1(200.59,51.82) v1(201.07,20.92) v1(201.39,55.82) v1(201.39,55.02) v1(201.39,54.22) v1(201.39,53.42) v1(201.39,52.62) v1(201.44,18.38) v1(201.4,17.49) v1(201.79,67.92) v1(201.78,65.7) v1(201.79,64.46) v1(201.79,62.37) v1(202.19,55.82) v1(202.19,55.02) v1(202.19,54.22) v1(202.99,55.82) v1(202.99,55.02) v1(202.99,54.22) v1(203.3,47.44) v1(203.3,46.64) v1(203.3,45.04) v1(203.3,44.24) v1(203.79,55.82) v1(203.79,55.02) v1(203.79,54.22) v1(204.05,58.68) v1(204.1,47.44) v1(204.1,46.64) v1(204.1,45.84) v1(204.41,64.77) v1(204.63,97.11) v1(204.63,96.6) v1(204.59,55.82) v1(204.82,22.94) v1(204.9,47.44) v1(204.9,46.64) v1(204.9,45.84) v1(205.26,97.11) v1(205.26,96.6) v1(205.7,47.44) v1(205.7,46.64) v1(205.7,45.84) v1(205.9,97.11) v1(205.86,96.6) v1(205.98,19.48) v1(206.26,30.62) v1(206.51,100.57) v1(206.51,99.3) v1(206.5,47.44) v1(206.5,46.64) v1(207.02,55.38) v1(207.25,20.75) v1(207.25,19.48) v1(207.41,90.24) v1(207.4,89.63) v1(207.78,104.38) v1(207.78,103.11) v1(207.92,90.25) v1(208.26,45.91) v1(208.42,95.73) v1(208.41,89.63) v1(208.45,90.24) v1(208.73,46.81) v1(209.05,99.3) v1(209.82,67.62) v1(209.93,38.94) v1(210.32,101.84) v1(210.48,59.39) v1(210.61,65.18) v1(210.61,63.2) v1(210.65,54.37) v1(210.61,52.4) v1(210.61,47.18) v1(210.61,45.2) v1(210.61,36.47) v1(210.61,34.49) v1(210.61,29.27) v1(210.61,27.29) v1(211.48,25.71) v1(211.48,23.73) v1(211.59,104.38) v1(211.59,103.11) v1(211.64,18.46) v1(211.62,16.41) v1(212.35,78.63) v1(212.48,83.9) v1(212.48,83.01) v1(212.59,67.03) v1(212.59,65) v1(212.59,56.18) v1(212.59,54.2) v1(212.59,48.98) v1(212.59,47) v1(212.59,38.27) v1(212.59,36.29) v1(212.59,31.07) v1(212.59,29.09) v1(212.59,27.47) v1(212.59,25.49) v1(212.59,20.27) v1(212.59,18.29) v1(212.86,99.3) v1(213.09,59.66) v1(213.1,57.89) v1(214.13,101.84) v1(214.13,100.57) v1(214.89,86.25) v1(215.1,63.61) v1(215.4,104.38) v1(215.4,103.11) v1(216.67,99.3) v1(217.94,101.84) v1(217.94,100.57) v1(219.21,104.38) v1(219.21,103.11) v1(220.04,97.11) v1(220.04,96.6) v1(220.67,97.11) v1(220.67,96.6) v1(221.31,97.11) v1(221.31,96.6) v1(224.54,91.14) v1(225.15,105.53) v1(225.56,91.65) v1(225.56,91.14) v1(228.2,106.42) v1(230.84,40.97) v1(230.84,40.29) v1(232.01,93.26) v1(232.52,66.37) v1(232.77,44.58) v1(232.77,43.77) v1(232.77,42.73) v1(232.77,41.91) v1(233.15,62.59) v1(234.12,44.58) v1(234.12,43.77) v1(234.12,41.91) v1(234.42,62.59) v1(237.09,38.17) v1(239.35,37.61) v1(239.38,36.94) v1(239.35,36.16) v1(239.38,35.42) v1(239.66,80.03) v1(240.11,37.61) v1(240.11,36.94) v1(240.11,36.16) v1(240.11,35.42) v1(240.42,76.02) v1(240.93,37.61) v1(240.93,36.16) v1(240.95,36.94) v1(240.95,35.42) v1(241.31,76.02) v1(241.69,37.61) v1(241.69,36.94) v1(241.69,36.16) v1(241.69,35.42) v1(242.2,76.02) v1(242.53,37.61) v1(242.53,36.94) v1(242.53,36.16) v1(242.53,35.42) v1(243.66,54.43) v1(243.66,53.42) v1(243.66,52.4) v1(246.9,56.97) v1(247.02,65.1) v1(250.96,50.5) v1(251.85,50.5) v1(251.85,49.61) v2(36.49,22.9) v2(39.3,15.46) v2(40.39,15.88) v2(41.9,17.36) v2(44.95,16) v2(47.9,11.06) v2(48.35,19.77) v2(48.67,18.13) v2(72.08,35.46) v2(72.08,34.66) v2(205.96,66.57) v2(206.1,68.79) v2(210.61,57.98) v2(210.61,56) v3(14.44,86.46) v3(14.44,85.46) v3(15.87,104.22) v3(16.19,108.72) v3(17.24,101.99) v3(17.45,106.75) v3(17.64,79.01) v3(18.23,88.22) v3(18.64,79.01) v3(20.61,28.93) v3(20.97,24.56) v3(21.37,28.93) v3(21.58,24.56) v3(22.11,79.01) v3(23.12,79.01) v3(24.29,35.26) v3(24.29,34.62) v3(24.79,88.9) v3(25.71,88.9) v3(29.13,106.46) v3(29.13,105.4) v3(30.02,108.88) v3(30.12,105.4) v3(30.2,84.48) v3(30.2,83.44) v3(33.54,63.13) v3(34.17,81.49) v3(34.39,103.53) v3(36.08,61.61) v3(37.79,50.88) v3(43.66,102.64) v3(44.08,79.81) v3(44.08,55.01) v3(44.33,56.34) v3(46.11,57.84) v3(46.11,56.31) v3(75.09,94.69) v3(82.74,93.34) v3(84.44,93.34) v3(90.39,94.11) v3(92.09,93.34) v3(95.28,86.42) v3(95.28,85.32) v3(104.61,86.14) v3(104.61,85.14) v3(108.61,86.14) v3(109.95,86.14) v3(111.64,106.95) v3(111.64,98.26) v3(112.34,32.53) v3(114.23,32.53) v3(114.72,86.14) v3(116.32,33.74) v3(116.32,32.56) v3(117.91,86.14) v3(117.9,83.51) v3(119.51,32.53) v3(121.1,86.14) v3(124.05,33.64) v3(124.05,32.43) v3(125.87,85.14) v3(129.12,88.9) v3(129.12,88.22) v3(129.52,93.83) v3(150.08,60.72) v3(188.14,101.73) v3(208.67,65.23) v3(208.67,63.71) v3(208.67,62.69) v3(209.81,65.23) v3(209.81,63.71) v3(209.81,62.69) v3(209.81,61.55) v3(211.08,62.56) v3(211.08,61.55) v3(211.72,65.23) v3(212.35,63.58) v3(212.35,62.56) v3(212.35,61.55) v3(241.31,80.6) v3(244.55,48.34) v3(245.73,92.15) v3(245.73,91.14) v3(245.73,90.12) v3(246.9,63.13) v3(247.47,47.2) v4(19.31,69.29) v4(19.31,68.28) v4(20.2,69.29) v4(20.2,68.28) v4(21.03,69.29) v4(21.03,68.28) v4(32.67,99.09) v4(32.67,96.55) v4(32.67,95.33) v4(33.05,69.65) v4(33.05,68.63) v4(33.94,99.09) v4(33.94,96.55) v4(33.94,95.33) v4(33.94,69.65) v4(33.94,68.63) v4(34.77,69.65) v4(34.77,68.63) v4(35.21,95.33) v4(36.08,76.66) v4(37.22,76.66) v4(38.36,76.66) v4(39.76,77.29) v4(39.76,76.02) v4(40.77,76.66) v4(41.79,77.29) v4(41.79,76.02) v4(42.83,99.09) v4(42.83,96.55) v4(42.83,95.3) v4(44.1,99.09) v4(44.1,96.55) v4(45.37,99.09) v4(46.24,99.14) v4(46.24,96.6) v4(46.24,95.38) v4(47.51,99.14) v4(47.51,96.6) v4(47.51,95.38) v4(56.4,99.14) v4(56.4,96.6) v4(57.67,99.14) v4(57.67,96.6) v4(58.94,99.14) v4(68.87,43.05) v4(70.54,43.51) v4(134.98,88.64) v4(137.78,88.04) v4(138.8,88.04) v4(139.94,88.04) v4(164.29,88.72) v4(164.85,88.72) v4(165.08,48.13) v4(165.41,88.72) v4(165.48,76.79) v4(165.52,33.28) v4(165.63,63.17) v4(165.64,48.13) v4(166,88.72) v4(165.97,77.29) v4(166.08,33.28) v4(166.19,63.17) v4(166.2,48.13) v4(166.53,77.29) v4(166.64,33.28) v4(166.75,63.17) v4(166.79,48.13) v4(167.12,77.3) v4(167.23,33.28) v4(167.34,63.17) v4(169.03,84.49) v4(169.03,83.93) v4(169,41.65) v4(169,41.09) v4(169.15,70.45) v4(169.15,69.89) v4(169.07,56.46) v4(169.07,55.9) v4(169.59,84.49) v4(169.59,83.93) v4(169.63,56.46) v4(169.63,55.9) v4(169.55,41.65) v4(169.55,41.09) v4(169.71,70.45) v4(169.71,69.89) v4(170.12,85.36) v4(170.11,83.03) v4(170.11,82.47) v4(170.15,55) v4(170.15,54.44) v4(170.08,43.08) v4(170.09,42.51) v4(170.11,41.65) v4(170.11,41.09) v4(170.07,40.19) v4(170.07,39.63) v4(170.15,84.49) v4(170.15,83.93) v4(170.23,71.88) v4(170.24,71.32) v4(170.23,68.99) v4(170.23,68.43) v4(170.15,57.88) v4(170.16,57.32) v4(170.19,56.46) v4(170.19,55.9) v4(170.27,70.45) v4(170.27,69.89) v4(170.65,43.08) v4(170.69,85.92) v4(170.69,85.36) v4(170.74,84.5) v4(170.74,83.94) v4(170.7,83.04) v4(170.7,82.48) v4(170.73,57.89) v4(170.73,57.33) v4(170.74,55) v4(170.74,54.44) v4(170.66,42.52) v4(170.71,41.65) v4(170.71,41.09) v4(170.66,40.19) v4(170.66,39.63) v4(170.8,71.88) v4(170.81,71.32) v4(170.82,68.99) v4(170.82,68.44) v4(170.78,56.46) v4(170.78,55.9) v4(170.86,70.45) v4(170.86,69.9) v4(179.84,53.42) v4(182.25,53.42) v4(184.54,53.42) v4(186.21,51.37) v4(186.19,50.73) v4(186.24,49.35) v4(186.27,49.99) v4(186.85,51.39) v4(186.85,50.73) v4(186.9,50.02) v4(186.9,49.35) v4(187.46,51.39) v4(187.46,50.73) v4(187.51,50.02) v4(187.51,49.35) v4(188.12,51.37) v4(188.09,50.73) v4(188.14,49.35) v4(188.17,49.99) v4(188.78,49.99) v4(188.75,49.35) v4(189.34,49.38) v4(189.44,51.41) v4(189.44,50.78) v4(189.41,50.02) v4(189.95,49.38) v4(190.05,51.41) v4(190.02,50.02) v4(190.05,50.78) v4(192.03,56.72) v4(192.67,48.24) v4(193.05,56.72) v4(193.87,47.56) v4(194.44,56.72) v4(195.71,56.72) v4(197.03,47.96) v4(198.05,47.96) v4(199.6,31.75) v4(199.6,30.84) v4(199.83,39.68) v4(199.83,38.61) v4(200.21,39.14) v4(200.21,38.13) v4(200.21,32.21) v4(200.21,31.3) v4(200.21,30.38) v4(201.12,32.59) v4(201.12,31.75) v4(201.12,30.91) v4(201.12,30.08) v4(202.27,32.59) v4(202.34,30.15) v4(202.36,29.45) v4(202.7,31.34) v4(203.93,35.93) v4(203.93,34.58) v4(205.79,35.93) v4(205.79,34.58) v4(210.04,40.59) v4(217.33,34.88) v4(217.33,33.1) v4(218.32,34.88) v4(218.32,33.1) v4(218.47,48.85) v4(218.47,47.07) v4(222.12,94.03) v4(222.12,92.76) v4(222.12,91.49) v4(223.01,94.03) v4(223.01,92.76) v4(223.53,79.96) v4(223.53,78.44) v4(223.53,76.91) v4(223.53,75.39) v4(223.53,73.87) v4(224.72,55.83) v4(224.72,54.94) v4(224.72,54.05) v4(224.95,50.27) v4(224.95,49.38) v4(224.95,48.49) v4(225.05,79.96) v4(225.05,78.44) v4(225.05,76.91) v4(225.05,75.39) v4(225.05,73.87) v4(225.05,71.96) v4(225.05,70.44) v4(225.05,68.91) v4(225.64,55.83) v4(225.64,54.94) v4(225.64,54.05) v4(225.86,50.27) v4(225.86,49.38) v4(225.86,48.49) v4(226.58,81.49) v4(226.58,79.96) v4(226.58,78.44) v4(226.58,76.91) v4(226.58,75.39) v4(226.58,73.87) v4(226.58,71.96) v4(226.58,70.44) v4(226.58,68.91) v4(227.01,51.89) v4(227.01,51.01) v4(227.64,45.49) v4(227.64,44.8) v4(227.69,51.89) v4(227.69,51.01) v4(227.73,49.61) v4(228.1,81.49) v4(228.1,79.96) v4(228.1,78.44) v4(228.1,76.91) v4(228.1,75.39) v4(228.1,73.87) v4(228.1,71.96) v4(228.1,70.44) v4(228.1,68.91) v4(228.53,45.49) v4(228.53,44.8) v4(229.62,81.49) v4(229.62,79.96) v4(229.62,78.44) v4(229.62,76.91) v4(229.62,75.39) v4(229.62,73.87) v4(229.62,72.34) v4(229.88,44.94) v4(237.04,45.16) v4(237.12,63.2) v4(237.12,62.05) v4(237.62,73.61) v4(238.26,62.69) v4(238.26,61.42) v4(238.39,45.89) v4(238.39,45.2) v4(238.92,49.76) v4(239.03,51.07) v4(239.28,45.89) v4(239.28,45.2) v4(239.53,62.69) v4(239.53,61.42) v4(240.72,46.89) v4(240.72,45.88) v4(240.8,70.31) v4(240.8,68.79) v4(240.8,62.69) v4(240.8,61.42) v4(240.95,50.27) v4(240.95,49.38) v4(240.95,48.49) v4(241.1,56.29) v4(241.1,55.4) v4(241.1,54.51) v4(241.63,103.73) v4(241.74,46.89) v4(241.74,45.88) v4(241.87,50.27) v4(241.87,49.38) v4(241.87,48.49) v4(242.02,56.29) v4(242.02,55.4) v4(242.02,54.51) v4(242.07,62.69) v4(242.07,61.42) v4(242.32,70.31) v4(242.32,68.79) v4(251.47,58.5) v4(251.77,66.25) v4(251.77,62.18) v7(175.75,83.82) v7(175.75,82.86) v7(175.78,81.89) v7(176.71,83.82) v7(176.71,82.86) v7(176.74,81.89) v7(176.66,73.74) v7(177.68,83.82) v7(177.68,82.86) v7(177.68,81.89) v7(177.65,73.74) v7(178.62,73.74) v7(178.7,83.72) v7(179.66,83.72) v7(179.66,73.76) v7(180.73,73.79) v7(180.86,83.77) v7(181.69,73.79) v7(181.82,83.77) v7(196.25,80.75) v7(198.43,74.58) v7(198.43,73.61) v7(198.41,72.65) v7(198.41,71.68) v7(199.4,74.58) v7(199.4,73.61) v7(199.37,72.65) v7(199.37,71.68) v7(200.34,76.51) v7(200.34,75.54) v7(200.34,74.58) v7(200.34,73.61) v7(200.34,72.65) v7(200.34,71.68) v7(201.4,83.37) v7(201.4,82.4) v7(201.43,81.44) v7(201.43,80.47) v7(201.4,79.5) v7(201.4,78.54) v7(201.38,77.5) v7(201.38,76.53) v7(201.4,75.57) v7(201.4,74.6) v7(201.38,73.64) v7(201.38,72.67) v7(201.38,71.71) v7(202.34,77.5) v7(202.34,76.53) v7(202.34,73.64) v7(202.34,72.67) v7(202.34,71.71) v7(202.37,83.37) v7(202.37,82.4) v7(202.39,81.44) v7(202.39,80.47) v7(202.37,79.5) v7(202.37,78.54) v7(202.37,75.57) v7(202.37,74.6) v7(203.33,83.37) v7(203.33,82.4) v7(203.33,81.44) v7(203.33,80.47) v7(203.33,79.5) v7(203.33,78.54) v7(203.31,77.5) v7(203.31,76.53) v7(203.31,75.57) v7(203.31,74.6) v7(203.31,73.64) v7(203.31,72.67) v7(203.31,71.71) v9(6.5,27.16) v9(6.5,26.14) v9(8.83,22.5) v9(32.5,17.9) v9(35.5,18.9) v9(37.52,43.03) v9(37.46,41.37) v9(37.5,20.9) v9(37.9,42.22) v9(38.47,43.08) v9(38.5,32.9) v9(38.5,23.9) v9(38.5,17.9) v9(40.75,27.24) v9(40.78,26.44) v9(43.26,30.38) v9(43.82,29.8) v9(44.54,24.51) v9(45.61,29.34) v9(46.36,33.42) v9(46.36,32.43) v9(46.45,24.94) v9(47.2,21.22) v9(47.78,63.25) v9(47.9,88.04) v9(47.9,85.64) v9(47.9,83.24) v9(47.9,78.44) v9(47.9,60.85) v9(47.9,58.45) v9(47.9,53.65) v9(47.9,22.84) v9(49.41,33.42) v9(50.71,63.25) v9(50.71,53.65) v9(50.83,88.04) v9(50.83,78.44) v9(51.44,33.42) v9(53.73,63.65) v9(53.76,58.85) v9(53.76,54.05) v9(54.18,13.81) v9(56.57,58.85) v9(57.41,44.47) v9(57.92,32.53) v9(58.71,14.44) v9(59.32,16.65) v9(60.75,45.36) v9(61.73,32.53) v9(61.67,19.64) v9(62.36,43.52) v9(62.48,45.26) v9(62.47,44.46) v9(79.18,21.74) v9(81.95,53.14) v9(84.84,52.14) v9(85.58,21.74) v9(88.89,70.14) v9(89.34,21.74) v9(89.54,98.64) v9(89.76,78.64) v9(89.76,76.64) v9(89.76,70.64) v9(89.76,68.64) v9(90.63,78.14) v9(90.63,77.14) v9(90.63,76.14) v9(90.63,70.14) v9(90.63,69.14) v9(91.49,75.64) v9(93.23,78.64) v9(94.09,78.14) v9(94.09,72.14) v9(94.96,78.64) v9(94.96,76.64) v9(95.74,21.74) v9(96.34,98.64) v9(96.69,77.64) v9(97.56,79.14) v9(97.56,77.14) v9(98.04,94.04) v9(99.29,80.14) v9(99.5,21.74) v9(99.74,94.04) v9(100.39,58.01) v9(101.18,50.19) v9(103.14,94.04) v9(104.84,94.04) v9(105.17,80.09) v9(105.9,21.74) v9(106.76,64.45) v9(108.19,33.66) v9(108.35,64.45) v9(108.6,33.19) v9(108.94,33.63) v9(109.66,25.74) v9(109.66,21.74) v9(110.75,68.59) v9(110.74,49.27) v9(112.34,69.51) v9(114.73,80.09) v9(115.26,26.54) v9(115.52,70.43) v9(115.52,69.51) v9(116.06,27.34) v9(117.92,71.81) v9(118.71,70.43) v9(120.31,70.43) v9(121.9,70.43) v9(121.88,69.52) v9(122.87,16.86) v9(123.49,70.43) v9(123.49,69.51) v9(125.88,67.21) v9(126.68,69.51) v9(128.27,69.51) v9(129.07,80.09) v9(129.27,23.26) v9(129.27,21.66) v9(129.87,69.51) v9(130.15,35.94) v9(131.46,69.51) v9(131.46,66.75) v9(131.46,61.23) v9(133,29.84) v9(133.03,23.26) v9(133.03,21.66) v9(134,70.1) v9(134,69.1) v9(134,67.1) v9(134,61.1) v9(134,60.1) v9(134.68,29.81) v9(136.24,77.79) v9(137.84,77.79) v9(138.33,55.6) v9(138.63,80.09) v9(139.43,21.66) v9(143.19,21.66) v9(149.59,21.66) v9(150.74,94.04) v9(151.59,98.64) v9(153.35,21.7) v9(153.57,91.33) v9(154.99,94.04) v9(159.75,21.7) v9(160.09,94.04) v9(173.69,94.04) v9(175.32,59.82) v9(175.81,60.62) v9(200.5,92.34) v9(205.61,70.17) v10(5.35,23.53) v10(7.4,23.13) v10(25.55,25.9) v10(25.55,24.9) v10(26.09,32.39) v10(26.47,27.98) v10(26.7,32.39) v10(26.68,21.08) v10(26.84,34.17) v10(27.5,30.85) v10(27.6,25.83) v10(27.91,20.36) v10(28.12,23.53) v10(28.46,27.04) v10(30.46,35.07) v10(31.5,28.05) v10(32.49,29.05) v10(32.5,19.9) v10(33.5,19.9) v10(34.55,24.9) v10(34.94,30.46) v10(35.17,22.61) v10(39.05,24.34) v10(39.07,23.02) v10(39.2,44.63) v10(39.31,30.03) v10(39.65,28.25) v10(40.89,15.12) v10(46.62,11.45) v10(47.89,11.57) v10(49.24,19.76) v10(53.66,13.79) v10(54.01,14.67) v10(55.57,13.16) v10(58.62,17.92) v10(60.53,27.87) v10(63.85,21.52) v10(63.85,20.72) v10(63.85,19.92) v10(63.85,19.12) v10(63.85,17.17) v10(63.85,16.37) v10(63.85,15.57) v10(63.85,14.77) v10(65.73,49.35) v10(65.92,10.56) v10(66.46,23.43) v10(67.05,20.13) v10(67.05,17.66) v10(67.34,31.46) v10(67.25,27.38) v10(67.57,24.98) v10(67.93,24.56) v10(68.02,36.25) v10(68.07,29) v10(68.48,12.41) v10(69.28,12.41) v10(70.08,12.41) v10(70.88,12.41) v10(71.12,68.72) v10(71.44,27.33) v10(71.51,29.12) v10(72.02,25.03) v10(72.35,28.98) v10(72.35,27.33) v10(72.35,26.51) v10(73.03,25.34) v10(73.98,48.85) v10(73.98,47.58) v10(76.33,29.02) v10(76.34,28.17) v10(76.33,24.93) v10(77.43,20.17) v10(78.34,27.24) v10(78.34,24) v10(78.34,22.59) v10(79.2,21.78) v10(81.75,28.1) v10(82.06,21.7) v10(82.17,27.2) v10(82.46,21.3) v10(82.56,26.79) v10(83.03,24.2) v10(86.42,28.1) v10(86.42,22.59) v10(86.42,20.86) v10(86.42,17.8) v10(86.42,16.9) v10(86.6,25.87) v10(87.02,23.91) v10(88.44,22.53) v10(88.44,20.93) v10(88.5,27.3) v10(88.5,24) v10(91.91,28.11) v10(92.34,26.92) v10(92.34,21.63) v10(92.71,27.26) v10(92.71,21.3) v10(93.19,24.2) v10(96.64,28.1) v10(96.64,22.53) v10(96.58,20.86) v10(96.58,17.8) v10(96.58,16.9) v10(97.18,24.85) v10(97.18,23.96) v10(102.07,28.1) v10(102.62,26.91) v10(102.58,21.51) v10(102.86,83.08) v10(102.93,21.17) v10(102.99,27.25) v10(103.35,24.2) v10(106.74,64.46) v10(106.74,28.1) v10(106.74,17.67) v10(106.74,16.77) v10(106.78,21.01) v10(106.85,22.61) v10(107.34,25.01) v10(107.34,24.11) v10(108.24,33.63) v10(108.24,33.12) v10(108.24,32.62) v10(108.38,64.67) v10(108.71,22.53) v10(108.82,27.29) v10(108.78,24.06) v10(108.82,21.02) v10(110.72,68.37) v10(110.77,49.25) v10(111.65,103.03) v10(112.23,28.12) v10(112.36,69.52) v10(112.76,21.33) v10(113,26.75) v10(113.1,21.77) v10(113.47,27.25) v10(113.51,24.22) v10(115.21,26.64) v10(115.5,69.49) v10(115.55,70.44) v10(116.88,28.14) v10(116.9,22.61) v10(116.9,20.88) v10(116.9,17.81) v10(116.9,16.92) v10(117.5,24.82) v10(117.5,23.92) v10(117.72,71.7) v10(118.71,70.45) v10(120.31,70.43) v10(121.8,70.44) v10(121.9,69.51) v10(122.02,20.97) v10(122.31,104.82) v10(122.91,16.82) v10(123.48,69.72) v10(123.59,70.53) v10(125.81,21.72) v10(126.25,21.23) v10(126.77,24.17) v10(130.16,20.83) v10(132.08,94.67) v10(132.08,93.35) v10(132.18,20.97) v10(134.09,70.26) v10(135.96,21.68) v10(136.41,21.18) v10(136.93,24.17) v10(140.32,20.83) v10(142.02,31.94) v10(142.34,20.97) v10(145.57,107.81) v10(146.16,21.67) v10(146.6,21.31) v10(147.09,24.17) v10(147.35,107.81) v10(148.39,66.04) v10(148.72,45.23) v10(149.87,45.29) v10(150.48,20.83) v10(151.52,51.11) v10(151.52,46.94) v10(152.02,50.88) v10(152.5,20.97) v10(153.23,48.29) v10(155.7,30.03) v10(156.14,29.66) v10(157.25,24.17) v10(158.08,22.46) v10(159.82,21.71) v10(161.56,20.06) v10(162.04,24.34) v10(162.41,24.73) v10(162.58,28.93) v10(164.14,85.78) v10(164.22,86.43) v10(166.06,28.1) v10(166.53,24.96) v10(167.38,24.06) v10(169.96,21.83) v10(170.86,28.93) v10(170.86,28.1) v10(175.52,15.63) v10(175.52,15.04) v10(175.53,14.42) v10(176.65,63.27) v10(181.08,57.5) v10(184.15,29) v10(184.67,29.03) v10(186.44,29) v10(186.98,29.02) v10(204.41,62.18) v10(206.36,27.46) v10(206.99,27.58) v10(208.41,48.34) v10(208.89,48.62) v10(208.88,27.5) v10(209.33,27.45) v10(211.61,15.06) v10(211.74,17.06) v10(212.02,14.9) v10(212.15,16.9) v10(214,86.25) v10(232.54,63.13) v10(232.54,62.21)
