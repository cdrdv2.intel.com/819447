# Allegro board FM85_AGILEX_PCIE_DK_CMC_ADI_REVC.brd (continued)
## Nets (continued)
CXL_SMB_ALERT_N: J6.B9 U107.14
CXL_TX_C_N0: C355.2 J6.B3
CXL_TX_C_N1: C357.2 J6.B6
CXL_TX_C_N2: C359.2 J6.B15
CXL_TX_C_N3: C361.2 J6.B18
CXL_TX_C_N4: C363.2 J6.B21
CXL_TX_C_N5: C365.2 J6.B24
CXL_TX_C_N6: C367.2 J6.B33
CXL_TX_C_N7: C369.2 J6.B36
CXL_TX_C_N8: C374.2 J7.B3
CXL_TX_C_N9: C376.2 J7.B6
CXL_TX_C_N10: C378.2 J7.B15
CXL_TX_C_N11: C380.2 J7.B18
CXL_TX_C_N12: C382.2 J7.B21
CXL_TX_C_N13: C384.2 J7.B24
CXL_TX_C_N14: C386.2 J7.B33
CXL_TX_C_N15: C388.2 J7.B36
CXL_TX_C_P0: C354.2 J6.B2
CXL_TX_C_P1: C356.2 J6.B5
CXL_TX_C_P2: C358.2 J6.B14
CXL_TX_C_P3: C360.2 J6.B17
CXL_TX_C_P4: C362.2 J6.B20
CXL_TX_C_P5: C364.2 J6.B23
CXL_TX_C_P6: C366.2 J6.B32
CXL_TX_C_P7: C368.2 J6.B35(TX1_3P)
CXL_TX_C_P8: C373.2 J7.B2
CXL_TX_C_P9: C375.2 J7.B5
CXL_TX_C_P10: C377.2 J7.B14
CXL_TX_C_P11: C379.2 J7.B17
CXL_TX_C_P12: C381.2 J7.B20
CXL_TX_C_P13: C383.2 J7.B23
CXL_TX_C_P14: C385.2 J7.B32
CXL_TX_C_P15: C387.2 J7.B35(TX1_3P)
CXL_TX_N0: C355.1 U6.AH22
CXL_TX_N1: C357.1 U6.AU16
CXL_TX_N2: C359.1 U6.BA22
CXL_TX_N3: C361.1 U6.BK16
CXL_TX_N4: C363.1 U6.BN22
CXL_TX_N5: C365.1 U6.CB16
CXL_TX_N6: C367.1 U6.CE22
CXL_TX_N7: C369.1 U6.CP16
CXL_TX_N8: C374.1 U6.CV22
CXL_TX_N9: C376.1 U6.DG16
CXL_TX_N10: C378.1 U6.DK22
CXL_TX_N11: C380.1 U6.DW16
CXL_TX_N12: C382.1 U6.EB22
CXL_TX_N13: C384.1 U6.EM16
CXL_TX_N14: C386.1 U6.ER22
CXL_TX_N15: C388.1 U6.FD16
CXL_TX_P0: C354.1 U6.AL20
CXL_TX_P1: C356.1 U6.AP14
CXL_TX_P2: C358.1 U6.BD20
CXL_TX_P3: C360.1 U6.BG14
CXL_TX_P4: C362.1 U6.BT20
CXL_TX_P5: C364.1 U6.BW14
CXL_TX_P6: C366.1 U6.CH20
CXL_TX_P7: C368.1 U6.CL14
CXL_TX_P8: C373.1 U6.DA20
CXL_TX_P9: C375.1 U6.DD14
CXL_TX_P10: C377.1 U6.DN20
CXL_TX_P11: C379.1 U6.DT14
CXL_TX_P12: C381.1 U6.EE20
CXL_TX_P13: C383.1 U6.EH14
CXL_TX_P14: C385.1 U6.EV20
CXL_TX_P15: C387.1 U6.FA14
DAOUT0: C7678.2 R5875.1 R6291.2 U119.11
DDR4_COMP_CH0_A0: R868.2 U1.P3 U2.P3 U3.P3 U4.P3 U5.P3 U6.N59
DDR4_COMP_CH0_A1: R869.2 U1.P7 U2.P7 U3.P7 U4.P7 U5.P7 U6.L60
DDR4_COMP_CH0_A2: R870.2 U1.R3 U2.R3 U3.R3 U4.R3 U5.R3 U6.U59
DDR4_COMP_CH0_A3: R871.2 U1.N7 U2.N7 U3.N7 U4.N7 U5.N7 U6.W60
DDR4_COMP_CH0_A4: R872.2 U1.N3 U2.N3 U3.N3 U4.N3 U5.N3 U6.N61
DDR4_COMP_CH0_A5: R873.2 U1.P8 U2.P8 U3.P8 U4.P8 U5.P8 U6.L62
DDR4_COMP_CH0_A6: R874.2 U1.P2 U2.P2 U3.P2 U4.P2 U5.P2 U6.U61
DDR4_COMP_CH0_A7: R875.2 U1.R8 U2.R8 U3.R8 U4.R8 U5.R8 U6.W62
DDR4_COMP_CH0_A8: R876.2 U1.R2 U2.R2 U3.R2 U4.R2 U5.R2 U6.N63
DDR4_COMP_CH0_A9: R877.2 U1.R7 U2.R7 U3.R7 U4.R7 U5.R7 U6.L64
DDR4_COMP_CH0_A10: R878.2 U1.M3 U2.M3 U3.M3 U4.M3 U5.M3 U6.U63
DDR4_COMP_CH0_A11: R879.2 U1.T2 U2.T2 U3.T2 U4.T2 U5.T2 U6.W64
DDR4_COMP_CH0_A12: R880.2 U1.M7 U2.M7 U3.M7 U4.M7 U5.M7 U6.AT64
DDR4_COMP_CH0_A13: R881.2 U1.T8 U2.T8 U3.T8 U4.T8 U5.T8 U6.AG65
DDR4_COMP_CH0_A14: R882.2 U1.L2 U2.L2 U3.L2 U4.L2 U5.L2 U6.AK66
DDR4_COMP_CH0_A15: R883.2 U1.M8 U2.M8 U3.M8 U4.M8 U5.M8 U6.AV65
DDR4_COMP_CH0_A16: R884.2 U1.L8 U2.L8 U3.L8 U4.L8 U5.L8 U6.AT66
DDR4_COMP_CH0_ACT_N: R891.2 U1.L3 U2.L3 U3.L3 U4.L3 U5.L3 U6.H60
DDR4_COMP_CH0_ALERT_N: R28.2 U1.P9 U2.P9 U3.P9 U4.P9 U5.P9 U6.AG68
DDR4_COMP_CH0_BA0: R887.2 U1.N2 U2.N2 U3.N2 U4.N2 U5.N2 U6.AK70
DDR4_COMP_CH0_BA1: R888.2 U1.N8 U2.N8 U3.N8 U4.N8 U5.N8 U6.AV68
DDR4_COMP_CH0_BG0: R885.2 U1.M2 U2.M2 U3.M2 U4.M2 U5.M2 U6.AT70
DDR4_COMP_CH0_BG1: R886.2 U1.M9 U2.M9 U3.M9 U4.M9 U5.M9 U6.B59
DDR4_COMP_CH0_CKE: R32.2 R34.1 U1.K2 U2.K2 U3.K2 U4.K2 U5.K2 U6.J61
DDR4_COMP_CH0_CLK_N: R36.2 U1.K8 U2.K8 U3.K8 U4.K8 U5.K8 U6.D64
DDR4_COMP_CH0_CLK_P: R35.2 U1.K7 U2.K7 U3.K7 U4.K7 U5.K7 U6.B63
DDR4_COMP_CH0_CS_N: R889.2 U1.L7 U2.L7 U3.L7 U4.L7 U5.L7 U6.J59
DDR4_COMP_CH0_DBI_N0: U1.E7 U6.U55
DDR4_COMP_CH0_DBI_N1: U1.E2 U6.AN59
DDR4_COMP_CH0_DBI_N2: U2.E7 U6.BC47
DDR4_COMP_CH0_DBI_N3: U2.E2 U6.BC53
DDR4_COMP_CH0_DBI_N4: U3.E7 U6.CA59
DDR4_COMP_CH0_DBI_N5: U3.E2 U6.BJ65
DDR4_COMP_CH0_DBI_N6: U4.E7 U6.AN53
DDR4_COMP_CH0_DBI_N7: U4.E2 U6.AN47
DDR4_COMP_CH0_DBI_N8: U5.E7 U6.BC59
DDR4_COMP_CH0_DQ0: U1.G2 U6.N57
DDR4_COMP_CH0_DQ1: U1.F7 U6.L54
DDR4_COMP_CH0_DQ2: U1.H3 U6.W54
DDR4_COMP_CH0_DQ3: U1.H7 U6.N53
DDR4_COMP_CH0_DQ4: U1.H2 U6.L58
DDR4_COMP_CH0_DQ5: U1.H8 U6.U53
DDR4_COMP_CH0_DQ6: U1.J3 U6.W58
DDR4_COMP_CH0_DQ7: U1.J7 U6.U57
DDR4_COMP_CH0_DQ8: U1.A3 U6.AN61
DDR4_COMP_CH0_DQ9: U1.B8 U6.AN57
DDR4_COMP_CH0_DQ10: U1.C3 U6.AD62
DDR4_COMP_CH0_DQ11: U1.C7 U6.AD58
DDR4_COMP_CH0_DQ12: U1.C2 U6.AK62
DDR4_COMP_CH0_DQ13: U1.C8 U6.AA57
DDR4_COMP_CH0_DQ14: U1.D3 U6.AK58
DDR4_COMP_CH0_DQ15: U1.D7 U6.AA61
DDR4_COMP_CH0_DQ16: U2.G2 U6.AV49
DDR4_COMP_CH0_DQ17: U2.F7 U6.AT46
DDR4_COMP_CH0_DQ18: U2.H3 U6.AT50
DDR4_COMP_CH0_DQ19: U2.H7 U6.BF46
DDR4_COMP_CH0_DQ20: U2.H2 U6.BC49
DDR4_COMP_CH0_DQ21: U2.H8 U6.AV45
DDR4_COMP_CH0_DQ22: U2.J3 U6.BF50
DDR4_COMP_CH0_DQ23: U2.J7 U6.BC45
DDR4_COMP_CH0_DQ24: U2.A3 U6.AV55
DDR4_COMP_CH0_DQ25: U2.B8 U6.AT56
DDR4_COMP_CH0_DQ26: U2.C3 U6.BF52
DDR4_COMP_CH0_DQ27: U2.C7 U6.AT52
DDR4_COMP_CH0_DQ28: U2.C2 U6.BC55
DDR4_COMP_CH0_DQ29: U2.C8 U6.AV51
DDR4_COMP_CH0_DQ30: U2.D3 U6.BF56
DDR4_COMP_CH0_DQ31: U2.D7 U6.BC51
DDR4_COMP_CH0_DQ32: U3.G2 U6.BJ57
DDR4_COMP_CH0_DQ33: U3.F7 U6.BM62
DDR4_COMP_CH0_DQ34: U3.H3 U6.BV58
DDR4_COMP_CH0_DQ35: U3.H7 U6.BJ61
DDR4_COMP_CH0_DQ36: U3.H2 U6.CA57
DDR4_COMP_CH0_DQ37: U3.H8 U6.BV62
DDR4_COMP_CH0_DQ38: U3.J3 U6.CA61
DDR4_COMP_CH0_DQ39: U3.J7 U6.BM58
DDR4_COMP_CH0_DQ40: U3.A3 U6.BJ68
DDR4_COMP_CH0_DQ41: U3.B8 U6.BC68
DDR4_COMP_CH0_DQ42: U3.C3 U6.BM70
DDR4_COMP_CH0_DQ43: U3.C7 U6.AY70
DDR4_COMP_CH0_DQ44: U3.C2 U6.BJ63
DDR4_COMP_CH0_DQ45: U3.C8 U6.AY64
DDR4_COMP_CH0_DQ46: U3.D3 U6.BM64
DDR4_COMP_CH0_DQ47: U3.D7 U6.BC63
DDR4_COMP_CH0_DQ48: U4.G2 U6.AD56
DDR4_COMP_CH0_DQ49: U4.F7 U6.AN51
DDR4_COMP_CH0_DQ50: U4.H3 U6.AK56
DDR4_COMP_CH0_DQ51: U4.H7 U6.AN55
DDR4_COMP_CH0_DQ52: U4.H2 U6.AA55
DDR4_COMP_CH0_DQ53: U4.H8 U6.AK52
DDR4_COMP_CH0_DQ54: U4.J3 U6.AD52
DDR4_COMP_CH0_DQ55: U4.J7 U6.AA51
DDR4_COMP_CH0_DQ56: U4.A3 U6.AK50
DDR4_COMP_CH0_DQ57: U4.B8 U6.AD46
DDR4_COMP_CH0_DQ58: U4.C3 U6.AD50
DDR4_COMP_CH0_DQ59: U4.C7 U6.AK46
DDR4_COMP_CH0_DQ60: U4.C2 U6.AN49
DDR4_COMP_CH0_DQ61: U4.C8 U6.AA45
DDR4_COMP_CH0_DQ62: U4.D3 U6.AA49
DDR4_COMP_CH0_DQ63: U4.D7 U6.AN45
DDR4_COMP_CH0_DQ64: U5.G2 U6.BC61
DDR4_COMP_CH0_DQ65: U5.F7 U6.AT62
DDR4_COMP_CH0_DQ66: U5.H3 U6.AV61
DDR4_COMP_CH0_DQ67: U5.H7 U6.BC57
DDR4_COMP_CH0_DQ68: U5.H2 U6.BF62
DDR4_COMP_CH0_DQ69: U5.H8 U6.AT58
DDR4_COMP_CH0_DQ70: U5.J3 U6.BF58
DDR4_COMP_CH0_DQ71: U5.J7 U6.AV57
DDR4_COMP_CH0_DQS_N0: U1.F3 U6.L56
DDR4_COMP_CH0_DQS_N1: U1.A7 U6.AD60
DDR4_COMP_CH0_DQS_N2: U2.F3 U6.AT48
DDR4_COMP_CH0_DQS_N3: U2.A7 U6.AT54
DDR4_COMP_CH0_DQS_N4: U3.F3 U6.BM60
DDR4_COMP_CH0_DQS_N5: U3.A7 U6.AY66
DDR4_COMP_CH0_DQS_N6: U4.F3 U6.AD54
DDR4_COMP_CH0_DQS_N7: U4.A7 U6.AD48
DDR4_COMP_CH0_DQS_N8: U5.F3 U6.AT60
DDR4_COMP_CH0_DQS_P0: U1.G3 U6.N55
DDR4_COMP_CH0_DQS_P1: U1.B7 U6.AA59
DDR4_COMP_CH0_DQS_P2: U2.G3 U6.AV47
DDR4_COMP_CH0_DQS_P3: U2.B7 U6.AV53
DDR4_COMP_CH0_DQS_P4: U3.G3 U6.BJ59
DDR4_COMP_CH0_DQS_P5: U3.B7 U6.BC65
DDR4_COMP_CH0_DQS_P6: U4.G3 U6.AA53
DDR4_COMP_CH0_DQS_P7: U4.B7 U6.AA47
DDR4_COMP_CH0_DQS_P8: U5.G3 U6.AV59
DDR4_COMP_CH0_ODT: R890.2 U1.K3 U2.K3 U3.K3 U4.K3 U5.K3 U6.B61
DDR4_COMP_CH0_PAR: R27.2 U1.T3 U2.T3 U3.T3 U4.T3 U5.T3 U6.H64
DDR4_COMP_CH0_RESET_N: R29.2 R30.2 U1.P1 U2.P1 U3.P1 U4.P1 U5.P1 U6.D60
DDR4_COMP_CH0_RZQ: R1034.2 U6.AV63
DDR4_COMP_CH0_TEN: R31.2 R33.1 U1.N9 U2.N9 U3.N9 U4.N9 U5.N9
DDR4_COMP_CH1_A0: R892.2 U6.N33 U7.P3 U8.P3 U9.P3 U10.P3 U11.P3
DDR4_COMP_CH1_A1: R893.2 U6.L34 U7.P7 U8.P7 U9.P7 U10.P7 U11.P7
DDR4_COMP_CH1_A2: R894.2 U6.U33 U7.R3 U8.R3 U9.R3 U10.R3 U11.R3
DDR4_COMP_CH1_A3: R895.2 U6.W34 U7.N7 U8.N7 U9.N7 U10.N7 U11.N7
DDR4_COMP_CH1_A4: R896.2 U6.N31 U7.N3 U8.N3 U9.N3 U10.N3 U11.N3
DDR4_COMP_CH1_A5: R897.2 U6.L32 U7.P8 U8.P8 U9.P8 U10.P8 U11.P8
DDR4_COMP_CH1_A6: R898.2 U6.U31 U7.P2 U8.P2 U9.P2 U10.P2 U11.P2
DDR4_COMP_CH1_A7: R899.2 U6.W32 U7.R8 U8.R8 U9.R8 U10.R8 U11.R8
DDR4_COMP_CH1_A8: R900.2 U6.N29 U7.R2 U8.R2 U9.R2 U10.R2 U11.R2
DDR4_COMP_CH1_A9: R901.2 U6.L30 U7.R7 U8.R7 U9.R7 U10.R7 U11.R7
DDR4_COMP_CH1_A10: R902.2 U6.U29 U7.M3 U8.M3 U9.M3 U10.M3 U11.M3
DDR4_COMP_CH1_A11: R903.2 U6.W30 U7.T2 U8.T2 U9.T2 U10.T2 U11.T2
DDR4_COMP_CH1_A12: R904.2 U6.AK32 U7.M7 U8.M7 U9.M7 U10.M7 U11.M7
DDR4_COMP_CH1_A13: R905.2 U6.AA29 U7.T8 U8.T8 U9.T8 U10.T8 U11.T8
DDR4_COMP_CH1_A14: R906.2 U6.AD30 U7.L2 U8.L2 U9.L2 U10.L2 U11.L2
DDR4_COMP_CH1_A15: R907.2 U6.AN29 U7.M8 U8.M8 U9.M8 U10.M8 U11.M8
DDR4_COMP_CH1_A16: R908.2 U6.AK30 U7.L8 U8.L8 U9.L8 U10.L8 U11.L8
DDR4_COMP_CH1_ACT_N: R915.2 U6.BF38 U7.L3 U8.L3 U9.L3 U10.L3 U11.L3
DDR4_COMP_CH1_ALERT_N: R66.2 U6.AA27 U7.P9 U8.P9 U9.P9 U10.P9 U11.P9
DDR4_COMP_CH1_BA0: R911.2 U6.AD28 U7.N2 U8.N2 U9.N2 U10.N2 U11.N2
DDR4_COMP_CH1_BA1: R912.2 U6.AN27 U7.N8 U8.N8 U9.N8 U10.N8 U11.N8
DDR4_COMP_CH1_BG0: R909.2 U6.AK28 U7.M2 U8.M2 U9.M2 U10.M2 U11.M2
DDR4_COMP_CH1_BG1: R910.2 U6.AV37 U7.M9 U8.M9 U9.M9 U10.M9 U11.M9
DDR4_COMP_CH1_CKE: R70.2 R72.1 U6.BC35 U7.K2 U8.K2 U9.K2 U10.K2 U11.K2
DDR4_COMP_CH1_CLK_N: R74.2 U6.AT34 U7.K8 U8.K8 U9.K8 U10.K8 U11.K8
DDR4_COMP_CH1_CLK_P: R73.2 U6.AV33 U7.K7 U8.K7 U9.K7 U10.K7 U11.K7
DDR4_COMP_CH1_CS_N: R913.2 U6.BC37 U7.L7 U8.L7 U9.L7 U10.L7 U11.L7
DDR4_COMP_CH1_DBI_N0: U6.J13 U11.E7
DDR4_COMP_CH1_DBI_N1: U6.J31 U8.E7
DDR4_COMP_CH1_DBI_N2: U6.U37 U7.E7
DDR4_COMP_CH1_DBI_N3: U6.AN41 U8.E2
DDR4_COMP_CH1_DBI_N4: U6.AN35 U9.E2
DDR4_COMP_CH1_DBI_N5: U6.U5 U10.E7
DDR4_COMP_CH1_DBI_N6: U6.J25 U9.E7
DDR4_COMP_CH1_DBI_N7: U6.BC41 U7.E2
DDR4_COMP_CH1_DBI_N8: U6.BC29 U10.E2
DDR4_COMP_CH1_DQ0: U6.H11 U11.H2
DDR4_COMP_CH1_DQ1: U6.B17 U11.F7
DDR4_COMP_CH1_DQ2: U6.D11 U11.J3
DDR4_COMP_CH1_DQ3: U6.H19 U11.J7
DDR4_COMP_CH1_DQ4: U6.J9 U11.H3
DDR4_COMP_CH1_DQ5: U6.D19 U11.H8
DDR4_COMP_CH1_DQ6: U6.H7 U11.G2
DDR4_COMP_CH1_DQ7: U6.J17 U11.H7
DDR4_COMP_CH1_DQ8: U6.J29 U8.J7
DDR4_COMP_CH1_DQ9: U6.B33 U8.H3
DDR4_COMP_CH1_DQ10: U6.B29 U8.H8
DDR4_COMP_CH1_DQ11: U6.D30 U8.F7
DDR4_COMP_CH1_DQ12: U6.J33 U8.G2
DDR4_COMP_CH1_DQ13: U6.D34 U8.J3
DDR4_COMP_CH1_DQ14: U6.H30 U8.H7
DDR4_COMP_CH1_DQ15: U6.H34 U8.H2
DDR4_COMP_CH1_DQ16: U6.L36 U7.F7
DDR4_COMP_CH1_DQ17: U6.W40 U7.J7
DDR4_COMP_CH1_DQ18: U6.U35 U7.H3
DDR4_COMP_CH1_DQ19: U6.U39 U7.H7
DDR4_COMP_CH1_DQ20: U6.N35 U7.H8
DDR4_COMP_CH1_DQ21: U6.W36 U7.J3
DDR4_COMP_CH1_DQ22: U6.N39 U7.G2
DDR4_COMP_CH1_DQ23: U6.L40 U7.H2
DDR4_COMP_CH1_DQ24: U6.AK40 U8.B8
DDR4_COMP_CH1_DQ25: U6.AD44 U8.C3
DDR4_COMP_CH1_DQ26: U6.AA39 U8.C7
DDR4_COMP_CH1_DQ27: U6.AA43 U8.A3
DDR4_COMP_CH1_DQ28: U6.AN39 U8.D7
DDR4_COMP_CH1_DQ29: U6.AK44 U8.C2
DDR4_COMP_CH1_DQ30: U6.AD40 U8.C8
DDR4_COMP_CH1_DQ31: U6.AN43 U8.D3
DDR4_COMP_CH1_DQ32: U6.AD34 U9.C8
DDR4_COMP_CH1_DQ33: U6.AD38 U9.C2
DDR4_COMP_CH1_DQ34: U6.AA33 U9.C7
DDR4_COMP_CH1_DQ35: U6.AA37 U9.A3
DDR4_COMP_CH1_DQ36: U6.AN33 U9.D3
DDR4_COMP_CH1_DQ37: U6.AK38 U9.B8
DDR4_COMP_CH1_DQ38: U6.AN37 U9.C3
DDR4_COMP_CH1_DQ39: U6.AK34 U9.D7
DDR4_COMP_CH1_DQ40: U6.N2 U10.H8
DDR4_COMP_CH1_DQ41: U6.N9 U10.H3
DDR4_COMP_CH1_DQ42: U6.L4 U10.J7
DDR4_COMP_CH1_DQ43: U6.L11 U10.H2
DDR4_COMP_CH1_DQ44: U6.U2 U10.H7
DDR4_COMP_CH1_DQ45: U6.U9 U10.G2
DDR4_COMP_CH1_DQ46: U6.W4 U10.F7
DDR4_COMP_CH1_DQ47: U6.W11 U10.J3
DDR4_COMP_CH1_DQ48: U6.J21 U9.J7
DDR4_COMP_CH1_DQ49: U6.J27 U9.G2
DDR4_COMP_CH1_DQ50: U6.B27 U9.H3
DDR4_COMP_CH1_DQ51: U6.B21 U9.H8
DDR4_COMP_CH1_DQ52: U6.D28 U9.J3
DDR4_COMP_CH1_DQ53: U6.D23 U9.F7
DDR4_COMP_CH1_DQ54: U6.H28 U9.H2
DDR4_COMP_CH1_DQ55: U6.H23 U9.H7
DDR4_COMP_CH1_DQ56: U6.BF44 U7.D3
DDR4_COMP_CH1_DQ57: U6.AV43 U7.C3
DDR4_COMP_CH1_DQ58: U6.BC39 U7.B8
DDR4_COMP_CH1_DQ59: U6.AT40 U7.C8
DDR4_COMP_CH1_DQ60: U6.BF40 U7.C7
DDR4_COMP_CH1_DQ61: U6.BC43 U7.C2
DDR4_COMP_CH1_DQ62: U6.AV39 U7.D7
DDR4_COMP_CH1_DQ63: U6.AT44 U7.A3
DDR4_COMP_CH1_DQ64: U6.AT28 U10.B8
DDR4_COMP_CH1_DQ65: U6.AT32 U10.A3
DDR4_COMP_CH1_DQ66: U6.AV27 U10.C7
DDR4_COMP_CH1_DQ67: U6.BC31 U10.C3
DDR4_COMP_CH1_DQ68: U6.BF32 U10.D7
DDR4_COMP_CH1_DQ69: U6.AV31 U10.D3
DDR4_COMP_CH1_DQ70: U6.BC27 U10.C8
DDR4_COMP_CH1_DQ71: U6.BF28 U10.C2
DDR4_COMP_CH1_DQS_N0: U6.D15 U11.F3
DDR4_COMP_CH1_DQS_N1: U6.D32 U8.F3
DDR4_COMP_CH1_DQS_N2: U6.L38 U7.F3
DDR4_COMP_CH1_DQS_N3: U6.AD42 U8.A7
DDR4_COMP_CH1_DQS_N4: U6.AD36 U9.A7
DDR4_COMP_CH1_DQS_N5: U6.L7 U10.F3
DDR4_COMP_CH1_DQS_N6: U6.D26 U9.F3
DDR4_COMP_CH1_DQS_N7: U6.AT42 U7.A7
DDR4_COMP_CH1_DQS_N8: U6.AT30 U10.A7
DDR4_COMP_CH1_DQS_P0: U6.B13 U11.G3
DDR4_COMP_CH1_DQS_P1: U6.B31 U8.G3
DDR4_COMP_CH1_DQS_P2: U6.N37 U7.G3
DDR4_COMP_CH1_DQS_P3: U6.AA41 U8.B7
DDR4_COMP_CH1_DQS_P4: U6.AA35 U9.B7
DDR4_COMP_CH1_DQS_P5: U6.N5 U10.G3
DDR4_COMP_CH1_DQS_P6: U6.B25 U9.G3
DDR4_COMP_CH1_DQS_P7: U6.AV41 U7.B7
DDR4_COMP_CH1_DQS_P8: U6.AV29 U10.B7
DDR4_COMP_CH1_ODT: R914.2 U6.AV35 U7.K3 U8.K3 U9.K3 U10.K3 U11.K3
DDR4_COMP_CH1_PAR: R65.2 U6.BF34 U7.T3 U8.T3 U9.T3 U10.T3 U11.T3
DDR4_COMP_CH1_RESET_N: R67.2 R68.2 U6.AT38 U7.P1 U8.P1 U9.P1 U10.P1 U11.P1
DDR4_COMP_CH1_RZQ: R108.1 U6.AN31
DDR4_COMP_CH1_TEN: R69.2 R71.1 U7.N9 U8.N9 U9.N9 U10.N9 U11.N9
DDR4_DDIMM2_A0: J1.79 U6.KR45
DDR4_DDIMM2_A1: J1.72 U6.KU44
DDR4_DDIMM2_A2: J1.216 U6.KJ45
DDR4_DDIMM2_A3: J1.71 U6.KF44
DDR4_DDIMM2_A4: J1.214 U6.KU46
DDR4_DDIMM2_A5: J1.213 U6.KR47
DDR4_DDIMM2_A6: J1.69 U6.KF46
DDR4_DDIMM2_A7: J1.211 U6.KJ47
DDR4_DDIMM2_A8: J1.68 U6.KR49
DDR4_DDIMM2_A9: J1.66 U6.KU48
DDR4_DDIMM2_A10: J1.225 U6.KF48
DDR4_DDIMM2_A11: J1.210 U6.KJ49
DDR4_DDIMM2_A12: J1.65 U6.LR43
DDR4_DDIMM2_A13: J1.232 U6.LW45
DDR4_DDIMM2_A14: J1.228(WE_N/A14) U6.MA46
DDR4_DDIMM2_A15: J1.86 U6.LR45
DDR4_DDIMM2_A16: J1.82 U6.LN46
DDR4_DDIMM2_A17: J1.234 U6.MA48
DDR4_DDIMM2_ACT_N: J1.62 U6.KW45
DDR4_DDIMM2_ALERT_N: J1.208 R91.1 U6.MA54
DDR4_DDIMM2_BA0: J1.81 U6.LW47
DDR4_DDIMM2_BA1: J1.224 U6.LN48
DDR4_DDIMM2_BG0: J1.63 U6.LR47
DDR4_DDIMM2_BG1: J1.207 U6.LH44
DDR4_DDIMM2_C0: R1074.1 U6.MA50
DDR4_DDIMM2_C0_CS_N2: J1.93 R1074.2 R1075.2
DDR4_DDIMM2_C1: R1076.1 U6.LW49
DDR4_DDIMM2_C1_CS_N3: J1.237 R1076.2 R1077.2
DDR4_DDIMM2_CS_N2: R1075.1 U6.LR51
DDR4_DDIMM2_CS_N3: R1077.1 U6.LN52
DDR4_DDIMM2_DBI_N0: J1.7 U6.LR57
DDR4_DDIMM2_DBI_N1: J1.18 U6.LR39
DDR4_DDIMM2_DBI_N2: J1.29 U6.KF52
DDR4_DDIMM2_DBI_N3: J1.40 U6.MD36
DDR4_DDIMM2_DBI_N4: J1.99 U6.MD48
DDR4_DDIMM2_DBI_N5: J1.110 U6.MD60
DDR4_DDIMM2_DBI_N6: J1.121 U6.MD54
DDR4_DDIMM2_DBI_N7: J1.132 U6.LB52
DDR4_DDIMM2_DBI_N8: J1.51 U6.MD42
DDR4_DDIMM2_DQ0: J1.5 U6.LN56
DDR4_DDIMM2_DQ1: J1.150 U6.MA56
DDR4_DDIMM2_DQ2: J1.12 U6.LW55
DDR4_DDIMM2_DQ3: J1.157 U6.LR55
DDR4_DDIMM2_DQ4: J1.3 U6.LN60
DDR4_DDIMM2_DQ5: J1.148 U6.MA60
DDR4_DDIMM2_DQ6: J1.10 U6.LW59
DDR4_DDIMM2_DQ7: J1.155 U6.LR59
DDR4_DDIMM2_DQ8: J1.16 U6.LW37
DDR4_DDIMM2_DQ9: J1.161 U6.LR37
DDR4_DDIMM2_DQ10: J1.23 U6.MA38
DDR4_DDIMM2_DQ11: J1.168 U6.LN38
DDR4_DDIMM2_DQ12: J1.14 U6.MA42
DDR4_DDIMM2_DQ13: J1.159 U6.LW41
DDR4_DDIMM2_DQ14: J1.21 U6.LN42
DDR4_DDIMM2_DQ15: J1.166 U6.LR41
DDR4_DDIMM2_DQ16: J1.27 U6.KF50
DDR4_DDIMM2_DQ17: J1.172 U6.KJ51
DDR4_DDIMM2_DQ18: J1.34 U6.KU50
DDR4_DDIMM2_DQ19: J1.179 U6.KR51
DDR4_DDIMM2_DQ20: J1.25 U6.KJ55
DDR4_DDIMM2_DQ21: J1.170 U6.KR55
DDR4_DDIMM2_DQ22: J1.32 U6.KU54
DDR4_DDIMM2_DQ23: J1.177 U6.KF54
DDR4_DDIMM2_DQ24: J1.38 U6.MK35
DDR4_DDIMM2_DQ25: J1.183 U6.MC35
DDR4_DDIMM2_DQ26: J1.45 U6.MD34
DDR4_DDIMM2_DQ27: J1.190 U6.MH34
DDR4_DDIMM2_DQ28: J1.36 U6.MK39
DDR4_DDIMM2_DQ29: J1.181 U6.MC39
DDR4_DDIMM2_DQ30: J1.43 U6.MD38
DDR4_DDIMM2_DQ31: J1.188 U6.MH38
DDR4_DDIMM2_DQ32: J1.97 U6.MC47
DDR4_DDIMM2_DQ33: J1.242 U6.MK47
DDR4_DDIMM2_DQ34: J1.104 U6.MH46
DDR4_DDIMM2_DQ35: J1.249 U6.MD46
DDR4_DDIMM2_DQ36: J1.95 U6.MC51
DDR4_DDIMM2_DQ37: J1.240 U6.MK51
DDR4_DDIMM2_DQ38: J1.102 U6.MD50
DDR4_DDIMM2_DQ39: J1.247 U6.MH50
DDR4_DDIMM2_DQ40: J1.108 U6.MK59
DDR4_DDIMM2_DQ41: J1.253 U6.MH58
DDR4_DDIMM2_DQ42: J1.115 U6.MC59
DDR4_DDIMM2_DQ43: J1.260 U6.MD58
DDR4_DDIMM2_DQ44: J1.106 U6.MK63
DDR4_DDIMM2_DQ45: J1.251 U6.MC63
DDR4_DDIMM2_DQ46: J1.113 U6.MH62
DDR4_DDIMM2_DQ47: J1.258 U6.MD62
DDR4_DDIMM2_DQ48: J1.119 U6.MC53
DDR4_DDIMM2_DQ49: J1.264 U6.MK53
DDR4_DDIMM2_DQ50: J1.126 U6.MH52
DDR4_DDIMM2_DQ51: J1.271 U6.MD52
DDR4_DDIMM2_DQ52: J1.117 U6.MH56
DDR4_DDIMM2_DQ53: J1.262 U6.MC57
DDR4_DDIMM2_DQ54: J1.124 U6.MK57
DDR4_DDIMM2_DQ55: J1.269 U6.MD56
DDR4_DDIMM2_DQ56: J1.130 U6.LL51
DDR4_DDIMM2_DQ57: J1.275 U6.KW51
DDR4_DDIMM2_DQ58: J1.137 U6.LB50
DDR4_DDIMM2_DQ59: J1.282 U6.LH50
DDR4_DDIMM2_DQ60: J1.128 U6.LL55
DDR4_DDIMM2_DQ61: J1.273 U6.KW55
DDR4_DDIMM2_DQ62: J1.135 U6.LH54
DDR4_DDIMM2_DQ63: J1.280 U6.LB54
DDR4_DDIMM2_DQ64: J1.49 U6.MH40
DDR4_DDIMM2_DQ65: J1.194 U6.MD40
DDR4_DDIMM2_DQ66: J1.56 U6.MC41
DDR4_DDIMM2_DQ67: J1.201 U6.MK41
DDR4_DDIMM2_DQ68: J1.47 U6.MH44
DDR4_DDIMM2_DQ69: J1.192 U6.MK45
DDR4_DDIMM2_DQ70: J1.54 U6.MD44
DDR4_DDIMM2_DQ71: J1.199 U6.MC45
DDR4_DDIMM2_DQS_N0: J1.152 U6.MA58
DDR4_DDIMM2_DQS_N1: J1.163 U6.MA40
DDR4_DDIMM2_DQS_N2: J1.174 U6.KR53
DDR4_DDIMM2_DQS_N3: J1.185 U6.MK37
DDR4_DDIMM2_DQS_N4: J1.244 U6.MK49
DDR4_DDIMM2_DQS_N5: J1.255 U6.MK61
DDR4_DDIMM2_DQS_N6: J1.266 U6.MK55
DDR4_DDIMM2_DQS_N7: J1.277 U6.LL53
DDR4_DDIMM2_DQS_N8: J1.196 U6.MK43
DDR4_DDIMM2_DQS_P0: J1.153 U6.LW57
DDR4_DDIMM2_DQS_P1: J1.164 U6.LW39
DDR4_DDIMM2_DQS_P2: J1.175 U6.KU52
DDR4_DDIMM2_DQS_P3: J1.186 U6.MH36
DDR4_DDIMM2_DQS_P4: J1.245 U6.MH48
DDR4_DDIMM2_DQS_P5: J1.256 U6.MH60
DDR4_DDIMM2_DQS_P6: J1.267 U6.MH54
DDR4_DDIMM2_DQS_P7: J1.278 U6.LH52
DDR4_DDIMM2_DQS_P8: J1.197 U6.MH42
DDR4_DDIMM2_PAR: J1.222 U6.LB48
DDR4_DDIMM2_RESET_N: J1.58 R87.1 R88.2 U6.LL45
DDR4_DDIMM2_RZQ: R37.1 U6.LN44
DDR4_DDIMM2_TDQS_N9: J1.8 U6.LN58
DDR4_DDIMM2_TDQS_N10: J1.19 U6.LN40
DDR4_DDIMM2_TDQS_N11: J1.30 U6.KJ53
DDR4_DDIMM2_TDQS_N12: J1.41 U6.MC37
DDR4_DDIMM2_TDQS_N13: J1.100 U6.MC49
DDR4_DDIMM2_TDQS_N14: J1.111 U6.MC61
DDR4_DDIMM2_TDQS_N15: J1.122 U6.MC55
DDR4_DDIMM2_TDQS_N16: J1.133 U6.KW53
DDR4_DDIMM2_TDQS_N17: J1.52 U6.MC43
DDR4_DDIMM_A0: J2.79 U6.LH42
DDR4_DDIMM_A1: J2.72 U6.LL43
DDR4_DDIMM_A2: J2.216 U6.KW43
DDR4_DDIMM_A3: J2.71 U6.LB42
DDR4_DDIMM_A4: J2.214 U6.LH40
DDR4_DDIMM_A5: J2.213 U6.LL41
DDR4_DDIMM_A6: J2.69 U6.LB40
DDR4_DDIMM_A7: J2.211 U6.KW41
DDR4_DDIMM_A8: J2.68 U6.LH38
DDR4_DDIMM_A9: J2.66 U6.LL39
DDR4_DDIMM_A10: J2.225 U6.KW39
DDR4_DDIMM_A11: J2.210 U6.LB38
DDR4_DDIMM_A12: J2.65 U6.KF36
DDR4_DDIMM_A13: J2.232 U6.KU34
DDR4_DDIMM_A14: J2.228(WE_N/A14) U6.KR35
DDR4_DDIMM_A15: J2.86 U6.KF34
DDR4_DDIMM_A16: J2.82 U6.KJ35
DDR4_DDIMM_A17: J2.234 U6.KU32
DDR4_DDIMM_ACT_N: J2.62 U6.KJ43
DDR4_DDIMM_ALERT_N: J2.208 R1049.1 U6.KC33
DDR4_DDIMM_BA0: J2.81 U6.KR33
DDR4_DDIMM_BA1: J2.224 U6.KJ33
DDR4_DDIMM_BG0: J2.63 U6.KF32
DDR4_DDIMM_BG1: J2.207 U6.KR43
DDR4_DDIMM_C0: R1070.1 U6.KC37
DDR4_DDIMM_C0_CS_N2: J2.93 R1070.2 R1072.2
DDR4_DDIMM_C1: R1071.1 U6.JY36
DDR4_DDIMM_C1_CS_N3: J2.237 R1071.2 R1073.2
DDR4_DDIMM_CK_N0: J2.75 U6.KU38
DDR4_DDIMM_CK_N1: J2.219 U6.JL33
DDR4_DDIMM_CK_P0: J2.74 U6.KR39
DDR4_DDIMM_CK_P1: J2.218 U6.JP32
DDR4_DDIMM_CKE0: J2.60 R103.2 U6.KF40
DDR4_DDIMM_CKE1: J2.203 R104.2 U6.KJ41
DDR4_DDIMM_CS_N0: J2.84 U6.KF42
DDR4_DDIMM_CS_N1: J2.89 U6.KF38
DDR4_DDIMM_CS_N2: R1072.1 U6.JP34
DDR4_DDIMM_CS_N3: R1073.1 U6.JL35
DDR4_DDIMM_DBI_N0: J2.7 U6.LR17
DDR4_DDIMM_DBI_N1: J2.18 U6.MD23
DDR4_DDIMM_DBI_N2: J2.29 U6.LR5
DDR4_DDIMM_DBI_N3: J2.40 U6.MD11
DDR4_DDIMM_DBI_N4: J2.99 U6.LR27
DDR4_DDIMM_DBI_N5: J2.110 U6.LR33
DDR4_DDIMM_DBI_N6: J2.121 U6.LB28
DDR4_DDIMM_DBI_N7: J2.132 U6.LB34
DDR4_DDIMM_DBI_N8: J2.51 U6.MD30
DDR4_DDIMM_DQ0: J2.5 U6.LR21
DDR4_DDIMM_DQ1: J2.150 U6.LN23
DDR4_DDIMM_DQ2: J2.12 U6.LW21
DDR4_DDIMM_DQ3: J2.157 U6.MA23
DDR4_DDIMM_DQ4: J2.3 U6.LW13
DDR4_DDIMM_DQ5: J2.148 U6.MA15
DDR4_DDIMM_DQ6: J2.10 U6.LR13
DDR4_DDIMM_DQ7: J2.155 U6.LN15
DDR4_DDIMM_DQ8: J2.16 U6.MH26
DDR4_DDIMM_DQ9: J2.161 U6.MK27
DDR4_DDIMM_DQ10: J2.23 U6.MD26
DDR4_DDIMM_DQ11: J2.168 U6.MC27
DDR4_DDIMM_DQ12: J2.14 U6.MH19
DDR4_DDIMM_DQ13: J2.159 U6.MD19
DDR4_DDIMM_DQ14: J2.21 U6.MK21
DDR4_DDIMM_DQ15: J2.166 U6.MC21
DDR4_DDIMM_DQ16: J2.27 U6.LR9
DDR4_DDIMM_DQ17: J2.172 U6.LW9
DDR4_DDIMM_DQ18: J2.34 U6.LN11
DDR4_DDIMM_DQ19: J2.179 U6.MA11
DDR4_DDIMM_DQ20: J2.25 U6.LU4
DDR4_DDIMM_DQ21: J2.170 U6.LW2
DDR4_DDIMM_DQ22: J2.32 U6.MA4
DDR4_DDIMM_DQ23: J2.177 U6.MC5
DDR4_DDIMM_DQ24: J2.38 U6.MH15
DDR4_DDIMM_DQ25: J2.183 U6.MD15
DDR4_DDIMM_DQ26: J2.45 U6.MC17
DDR4_DDIMM_DQ27: J2.190 U6.MK17
DDR4_DDIMM_DQ28: J2.36 U6.MF5
DDR4_DDIMM_DQ29: J2.181 U6.MD7
DDR4_DDIMM_DQ30: J2.43 U6.MC9
DDR4_DDIMM_DQ31: J2.188 U6.MH7
DDR4_DDIMM_DQ32: J2.97 U6.LW29
DDR4_DDIMM_DQ33: J2.242 U6.LR29
DDR4_DDIMM_DQ34: J2.104 U6.LN30
DDR4_DDIMM_DQ35: J2.249 U6.MA30
DDR4_DDIMM_DQ36: J2.95 U6.LN26
DDR4_DDIMM_DQ37: J2.240 U6.MA26
DDR4_DDIMM_DQ38: J2.102 U6.LW25
DDR4_DDIMM_DQ39: J2.247 U6.LR25
DDR4_DDIMM_DQ40: J2.108 U6.LW35
DDR4_DDIMM_DQ41: J2.253 U6.LR35
DDR4_DDIMM_DQ42: J2.115 U6.MA36
DDR4_DDIMM_DQ43: J2.260 U6.LN36
DDR4_DDIMM_DQ44: J2.106 U6.LR31
DDR4_DDIMM_DQ45: J2.251 U6.LW31
DDR4_DDIMM_DQ46: J2.113 U6.LN32
DDR4_DDIMM_DQ47: J2.258 U6.MA32
DDR4_DDIMM_DQ48: J2.119 U6.LH30
DDR4_DDIMM_DQ49: J2.264 U6.KW31
DDR4_DDIMM_DQ50: J2.126 U6.LB30
DDR4_DDIMM_DQ51: J2.271 U6.LL31
DDR4_DDIMM_DQ52: J2.117 U6.KW27
DDR4_DDIMM_DQ53: J2.262 U6.LH26
DDR4_DDIMM_DQ54: J2.124 U6.LB26
DDR4_DDIMM_DQ55: J2.269 U6.LL27
DDR4_DDIMM_DQ56: J2.130 U6.LH36
DDR4_DDIMM_DQ57: J2.275 U6.LB36
DDR4_DDIMM_DQ58: J2.137 U6.LL37
DDR4_DDIMM_DQ59: J2.282 U6.KW37
DDR4_DDIMM_DQ60: J2.128 U6.LB32
DDR4_DDIMM_DQ61: J2.273 U6.LL33
DDR4_DDIMM_DQ62: J2.135 U6.LH32
DDR4_DDIMM_DQ63: J2.280 U6.KW33
DDR4_DDIMM_DQ64: J2.49 U6.MD32
DDR4_DDIMM_DQ65: J2.194 U6.MH32
DDR4_DDIMM_DQ66: J2.56 U6.MK33
DDR4_DDIMM_DQ67: J2.201 U6.MC33
DDR4_DDIMM_DQ68: J2.47 U6.MD28
DDR4_DDIMM_DQ69: J2.192 U6.MH28
DDR4_DDIMM_DQ70: J2.54 U6.MK29
DDR4_DDIMM_DQ71: J2.199 U6.MC29
DDR4_DDIMM_DQS_N0: J2.152 U6.MA19
DDR4_DDIMM_DQS_N1: J2.163 U6.MK25
DDR4_DDIMM_DQS_N2: J2.174 U6.MA7
DDR4_DDIMM_DQS_N3: J2.185 U6.MK13
DDR4_DDIMM_DQS_N4: J2.244 U6.MA28
DDR4_DDIMM_DQS_N5: J2.255 U6.MA34
DDR4_DDIMM_DQS_N6: J2.266 U6.LL29
DDR4_DDIMM_DQS_N7: J2.277 U6.LL35
DDR4_DDIMM_DQS_N8: J2.196 U6.MK31
DDR4_DDIMM_DQS_P0: J2.153 U6.LW17
DDR4_DDIMM_DQS_P1: J2.164 U6.MH23
DDR4_DDIMM_DQS_P2: J2.175 U6.LW5
DDR4_DDIMM_DQS_P3: J2.186 U6.MH11
DDR4_DDIMM_DQS_P4: J2.245 U6.LW27
DDR4_DDIMM_DQS_P5: J2.256 U6.LW33
DDR4_DDIMM_DQS_P6: J2.267 U6.LH28
DDR4_DDIMM_DQS_P7: J2.278 U6.LH34
DDR4_DDIMM_DQS_P8: J2.197 U6.MH30
DDR4_DDIMM_EVENT_N: J2.78 R99.1 U13.13
DDR4_DDIMM_ODT0: J2.87 U6.KU40
DDR4_DDIMM_ODT1: J2.91 U6.KR41
DDR4_DDIMM_PAR: J2.222 U6.KJ39
DDR4_DDIMM_RESET_N: J2.58 R1047.1 R1048.2 U6.KU42
DDR4_DDIMM_RZQ: R75.1 U6.KJ37
DDR4_DDIMM_SA0: J2.139 R100.1
DDR4_DDIMM_SA1: J2.140 R101.2
DDR4_DDIMM_SA2: J2.238 R102.2
DDR4_DDIMM_SAVE_N: J2.230 R98.1 U13.12
DDR4_DDIMM_TDQS_N9: J2.8 U6.LN19
DDR4_DDIMM_TDQS_N10: J2.19 U6.MC25
DDR4_DDIMM_TDQS_N11: J2.30 U6.LN7
DDR4_DDIMM_TDQS_N12: J2.41 U6.MC13
DDR4_DDIMM_TDQS_N13: J2.100 U6.LN28
DDR4_DDIMM_TDQS_N14: J2.111 U6.LN34
DDR4_DDIMM_TDQS_N15: J2.122 U6.KW29
DDR4_DDIMM_TDQS_N16: J2.133 U6.KW35
DDR4_DDIMM_TDQS_N17: J2.52 U6.MC31
DDR4_DIMM2_CK_N0: J1.75 U6.LL49
DDR4_DIMM2_CK_N1: J1.219 U6.LN54
DDR4_DIMM2_CK_P0: J1.74 U6.LH48
DDR4_DIMM2_CK_P1: J1.218 U6.LR53
DDR4_DIMM2_CKE0: J1.60 R89.2 U6.LB46
DDR4_DIMM2_CKE1: J1.203 R90.2 U6.KW47
DDR4_DIMM2_CS_N0: J1.84 U6.LB44
DDR4_DIMM2_CS_N1: J1.89 U6.KW49
DDR4_DIMM2_EVENT_N: J1.78 R83.1 U12.13
DDR4_DIMM2_ODT0: J1.87 U6.LH46
DDR4_DIMM2_ODT1: J1.91 U6.LL47
DDR4_DIMM2_SA0: J1.139 R84.2 R1068.1
DDR4_DIMM2_SA1: J1.140 R85.2 R1069.1
DDR4_DIMM2_SA2: J1.238 R86.2
DDR4_DIMM2_SAVE_N: J1.230 R82.1 U12.12
DDR4_DIMM_SCL: J1.141 J2.141 R330.1 U12.11 U29.2
DDR4_DIMM_SDA: J1.285 J2.285 R329.1 U12.10 U29.3
DFX_1_TOG: R865.2 U34.G14
ED_PMBUS_ALERTN: R926.1 U107.15
EXT_JTAG_TCK: R434.1 R2736.2 U34.R5 U38.1
EXT_JTAG_TDI: J10.9 R431.2 U34.T4 U38.8
EXT_JTAG_TDO: J10.3 R430.2 U34.M7 U38.11
EXT_JTAG_TMS: J10.5 R429.2 U34.T5 U38.4
FAN_CTRL: J9.4 R415.1 U107.2
FAN_TACH: R414.2 R416.1 U107.3
FAULT: R6024.1 R6025.1 R6065.1 R6255.1 R6256.1 R6257.1 R6258.1 U119.18
FGT_AGND: C804.2 C805.1 C806.2 R658.2 ST9.2
FM41_14C_PCIE_PERSTN: R6297.1 R6298.2 R6324.2 U6.EP70
FM41_15C_CXL_PERSTN: R6299.1 R6325.1 U6.HV34
FPGA_3V3_LED0: Q7.1 U42.20
FPGA_3V3_LED1: Q9.1 U42.18
FPGA_3V3_LED2: Q10.1 U42.17
FPGA_3V3_LED3: Q11.1 U42.16
FPGA_BYPASSN: R409.1 SW8.2 U34.C12
FPGA_CONF_DONE: Q12.1 R219.2 U6.LW61 U34.H12
FPGA_CXL_PERSTN: R195.1 R196.2 U6.CY30
FPGA_CXL_PRSNTX1_N: R6302.2 U18.2
FPGA_CXL_PRSNTX4_N: R6305.2 U18.3
FPGA_CXL_PRSNTX8_N: U6.JY26 U18.4
FPGA_CXL_PRSNTX16_N: U6.KC27 U18.5
FPGA_CXL_RSTN: U6.W46 U42.7
FPGA_DDIMM_EVENT_N: U6.KR29 U13.2
FPGA_DDIMM_SAVE_N: U6.KF30 U13.3
FPGA_DIMM2_EVENT_N: U6.KJ59 U12.2
FPGA_DIMM2_SAVE_N: U6.KR59 U12.3
FPGA_DIMM_SCL: R80.1 U6.KC29 U12.4
FPGA_DIMM_SDA: R81.1 U6.KJ27 U12.5
FPGA_FABRIC_RESET_N: R6218.1 U42.12 U107.5
FPGA_I2C1_SCL: R323.1 U6.KJ61 U28.2
FPGA_I2C1_SDA: R322.1 U6.KF60 U28.3
FPGA_I2C2_EN: R857.1 U6.D38
FPGA_I2C2_EN_R: R337.2 R857.2 SW4.2 U30.8
FPGA_I2C2_SCL: R336.1 U6.H36 U30.2
FPGA_I2C2_SDA: R335.1 U6.H40 U30.3
FPGA_I2C_EN: R326.1 U6.H42
FPGA_I2C_EN_R: R321.2 R326.2 SW4.1 U28.8
FPGA_JTAG_TCK: R216.2 U6.LB64 U34.N14
FPGA_JTAG_TDI: R215.2 U6.LN64 U34.K11
FPGA_JTAG_TDO: U6.LB66 U34.M14
FPGA_JTAG_TMS: R214.2 U6.LR65 U34.K12
FPGA_LED0: R452.2 U6.H46 U42.1
FPGA_LED1: R450.2 U6.J45 U42.3
FPGA_LED2: R449.2 U6.D46 U42.4
FPGA_LED3: R448.2 U6.B45 U42.5
FPGA_M10_FABRIC_RESET_N: U6.D36 U42.9
FPGA_M10_HB: R2738.1 TP950.1 U34.L11
FPGA_M10_IBUS_CLK0: U34.N3 U106.15
FPGA_M10_IBUS_CLK1: U34.L3 U105.20
FPGA_M10_IBUS_CS0_N: R6215.2 U34.J6 U106.12
FPGA_M10_IBUS_CS1_N: R6209.1 U34.K5 U105.16
FPGA_M10_MISO_0: U34.M1 U106.13
FPGA_M10_MISO_1: U34.K2 U105.17
FPGA_M10_MOSI_0: U34.M2 U106.14
FPGA_M10_MOSI_1: U34.L1 U105.18
FPGA_M10_VID_ALERTN: R6217.2 U6.B39 U106.4
FPGA_MSEL0: R203.1 U34.G16
FPGA_MSEL1: R205.1 U34.G15
FPGA_NCONFIG: R218.2 U6.LR61 U34.J11
FPGA_NSTATUS: R217.2 U6.LH62 U34.L16
FPGA_OSC_CLK_1: R239.1 U6.KU64
FPGA_PCIE_PERSTN: R183.1 R184.2 U6.CD58
FPGA_PMBUS_EN: R316.2 SW4.4 U26.5 U34.A5
FPGA_QSPI_CLK: U34.N1 U40.18
FPGA_QSPI_CS_N: R6107.1 U34.K6 U40.20
FPGA_QSPI_DATA0: U34.P1 U40.17
FPGA_QSPI_DATA1: U34.L2 U40.16
FPGA_QSPI_DATA2: U34.N2 U40.15
FPGA_QSPI_DATA3: U34.M3 U40.14
FPGA_SDM_SCL: R307.1 U6.ML71 U26.7
FPGA_SDM_SDA: R305.1 U6.ML67 U26.6
FPGA_SEU_ERROR: U105.14 U107.4
FPGA_SEU_ERROR_B: R6216.1 U6.B37 U105.7
FPGA_TEMP0AN: R455.2 U6.LH64
FPGA_TEMP0AP: R454.2 U6.LL63
FPGA_TEMP0CN: R458.2 U6.CG55
FPGA_TEMP0CP: R456.2 U6.CN55
FPGA_TEMP1N: R461.2 U6.HM60
FPGA_TEMP1P: R459.2 U6.HJ59
FPGA_TEMP3N: R471.2 U6.BV66
FPGA_TEMP3P: R470.2 U6.BR68
FPGA_TEMP4N: R475.2 U6.JE27
FPGA_TEMP4P: R474.2 U6.HY27
FPGA_TEMP6N: R473.2 U6.FJ27
FPGA_TEMP6P: R472.2 U6.FF26
FPGA_VCC: C1019.1 C1020.1 C1021.1 C1022.1 C1023.1 C1024.1 C1025.1 C1026.1 C1027.1 C1028.1 C1029.1 C1030.1 C1031.1 C1032.1 C1033.1 C1037.1 C1038.1 C1039.1 C1040.1 C1044.1 C1048.1 C1049.1 C1050.1 C1051.1 C1052.1 C1053.1 C1054.1 C1055.1 C1056.1 C1057.1 C1063.1 C1064.1 C1065.1 C1066.1 C1067.1 C1068.1 C1069.1 C1070.1 C1090.1 C1091.1 C1092.1 C1093.1 C1105.1 C1106.1 C1107.1 C1108.1 C1109.1 C1110.1 C1117.1 C1118.1 C1119.1 C1120.1 C1401.1 C1402.1 C1403.1 C1404.1 C1405.1 C1406.1 C1407.1 C1408.1 C1409.1 C1410.1 C1411.1 C1412.1 C1413.1 C1414.1 C1415.1 C1416.1 C1417.1 C1418.1 C1419.1 C1420.1 C1421.1 C1422.1 C1423.1 C1424.1 C1425.1 C1426.1 C1427.1 C1428.1 C1429.1 C1430.1 C1431.1 C1432.1 C1433.1 C1435.1 C1436.1 C1437.1 C1438.1 C1439.1 C1440.1 C1441.1 C1442.1 C1443.1 C1444.1 C1445.1 C1446.1 C1450.2 C1557.1(P) C1558.2 C1559.2 C1575.1(P) C1576.2 C1577.2 C1622.1(P) C1623.1(P) C1624.1(P) C1738.1(P) C1739.2 C1740.2 C1749.1(P) C1750.2 C1751.2 C7557.1(P) C7679.2 C7680.2 C7687.2 C7688.2 C7693.2 C7694.2 C7695.2 C7696.2 L23.2 L27.2 L28.2 L29.2 R5887.2 R6041.2 TP966.1 TP967.1 U6.CG43 U6.CG45 U6.CG47 U6.CG49 U6.CG51 U6.CN43 U6.CN45 U6.CN47 U6.CN49 U6.CN51 U6.CR40 U6.CR42 U6.CU41 U6.CU43 U6.CU47 U6.CU49 U6.CU53 U6.CU55 U6.CY38 U6.CY42 U6.CY44 U6.CY48 U6.CY50 U6.CY54 U6.CY56 U6.DC39 U6.DC43 U6.DC45 U6.DC49 U6.DC51 U6.DC55 U6.DC57 U6.DF38 U6.DF40 U6.DF44 U6.DF46 U6.DF50 U6.DF52 U6.DF56 U6.DJ39 U6.DJ41 U6.DJ45 U6.DJ47 U6.DJ51 U6.DJ53 U6.DJ57 U6.DM40 U6.DM42 U6.DM46 U6.DM48 U6.DM52 U6.DM54 U6.DR37 U6.DR53 U6.DR55 U6.DV38 U6.DV40 U6.DV54 U6.DV56 U6.EA37 U6.EA39 U6.EA53 U6.EA55 U6.EA57 U6.ED38 U6.ED40 U6.ED56 U6.EG39 U6.EG53 U6.EG57 U6.EJ40 U6.EJ54 U6.EL37 U6.EL53 U6.EL55 U6.EP38 U6.EP40 U6.EP54 U6.EP56 U6.EU37 U6.EU39 U6.EU53 U6.EU55 U6.EU57 U6.EY38 U6.EY40 U6.EY56 U6.FC53 U6.FC57 U6.FF40 U6.FF54 U6.FJ37 U6.FJ53 U6.FJ55 U6.FM38 U6.FM40 U6.FM54 U6.FM56 U6.FR37 U6.FR39 U6.FR53 U6.FR55 U6.FV38 U6.FV40 U6.FV56 U6.GA39 U6.GA53 U6.GD40 U6.GD54 U6.GF37 U6.GF53 U6.GF55 U6.GH38 U6.GH40 U6.GH54 U6.GH56 U6.GL37 U6.GL39 U6.GL53 U6.GL55 U6.GP38 U6.GP40 U6.GP56 U6.GU39 U6.GU53 U6.GY40 U6.GY42 U6.GY46 U6.GY48 U6.GY52 U6.GY54 U6.HC37 U6.HC41 U6.HC43 U6.HC47 U6.HC49 U6.HC53 U6.HC55 U6.HF38 U6.HF42 U6.HF44 U6.HF48 U6.HF50 U6.HF54 U6.HJ37 U6.HJ39 U6.HJ43 U6.HJ45 U6.HJ49 U6.HJ51 U6.HJ55 U6.HM38 U6.HM40 U6.HM44 U6.HM46 U6.HM50 U6.HM52 U6.HR39 U6.HR41 U6.HR45 U6.HR47 U6.HR51 U6.HR53 U6.HV40 U6.HV42 U6.HV52 U6.HY41 U6.HY43 U6.HY45 U6.HY47 U6.HY49 U6.JE41 U6.JE43 U6.JE45 U6.JE47 U6.JE49
FPGA_VCC_EN: R853.2 R6037.1 R6229.2 U119.20
FPGA_VCC_PG: C7664.2 R6036.1 R6279.1 R6291.1 U34.R4
FPGA_VID_ALERTN: U34.N4 U106.17
FX2_D_N: J8.2 U35.2 U143.9
FX2_D_P: J8.3 U35.1 U143.8
FX2_FLAGA: U34.J5 U143.29
FX2_FLAGB: U34.H6 U143.30
FX2_FLAGC: U34.J3 U143.31
FX2_PA0: U34.F5 U143.33
FX2_PA1: U34.C4 U143.34
FX2_PA2: U34.F4 U143.35
FX2_PA3: U34.C3 U143.36
FX2_PA4: U34.H5 U143.37
FX2_PA5: U34.E3 U143.38
FX2_PA6: U34.G5 U143.39
FX2_PA7: U34.F2 U143.40
FX2_PB0: U34.G2 U143.18
FX2_PB1: U34.C2 U143.19
FX2_PB2: U34.F1 U143.20
FX2_PB3: U34.B2 U143.21
FX2_PB4: U34.E1 U143.22
FX2_PB5: U34.B1 U143.23
FX2_PB6: U34.D1 U143.24
FX2_PB7: U34.C1 U143.25
FX2_PD0: U38.16 U143.45
FX2_PD1: U38.3 U143.46
FX2_PD2: U38.9 U143.47
FX2_PD3: U38.12 U143.48
FX2_PD4: U34.T8 U143.49
FX2_PD5: U34.P6 U143.50
FX2_PD6: U34.T6 U143.51
FX2_PD7: U34.R7 U143.52
FX2_RESETN: R374.1 U33.2 U34.J2 U143.42
FX2_SCL: R376.1 U34.R8 U143.15
FX2_SDA: R372.1 R377.1 U143.16
FX2_SLRDN: U34.R9 U143.1
FX2_SLWRN: U34.T11 U143.2
FX2_WAKEUP: C499.1 R381.2 R382.2 R383.2 U143.44
G0_EN: R6228.1 U34.E9
G1_EN: R6229.1 U34.B3
G2_EN: R6231.2 R6232.2 R6233.2 R6234.2 R6235.2 R6236.2 R6237.2 U34.F10
G3_EN: R6238.2 R6239.2 R6240.2 R6249.2 R6253.1 R6254.1 U34.B13
G4_EN: R6241.2 R6242.2 R6243.2 R6244.2 R6245.2 R6246.2 R6247.2 R6248.2 U34.B8
G5_EN: R6230.1 U34.L7
GXF_PERSTN: R854.1 R856.2 S5.2 U6.JL61
GXR_AGND: C821.2 C822.1 C823.2 R670.2 ST10.2
HPS_JTAG_TCK: U6.BM30 U34.J15
HPS_JTAG_TDI: U6.U21 U34.H11
HPS_JTAG_TDO: U6.BJ29 U34.H16
HPS_JTAG_TMS: U6.L19 U34.G11
HPS_OSC_CLK: R237.1 U6.U25
HPS_UART_RX: J15.2 R6286.1 U6.L15
HPS_UART_TX: J15.1 R6285.1 U6.BF26
HRAM_CK: R6224.2 U103.B2
HRAM_CK_N: R6225.2 U103.B1
HRAM_CK_N_R: R6225.1 U34.L15
HRAM_CK_R: R6224.1 U34.K14
HRAM_CS: R2653.2 R6213.2 U103.A3
HRAM_CS_R: R6213.1 U34.T15
HRAM_D0: R2692.2 U34.P15
HRAM_D1: R2691.2 U34.N16
HRAM_D2: R2693.2 U34.R15
HRAM_D3: R2694.2 U34.P14
HRAM_D4: R2695.2 U34.R14
HRAM_D5: R2696.2 U34.P16
HRAM_D6: R2697.2 U34.M15
HRAM_D7: R2698.2 U34.M16
HRAM_RST_N: R2654.2 U34.T14 U103.A4
HRAM_RWDS: R6214.2 U103.C3
HRAM_RWDS_R: R6214.1 U34.R16
HSSI_GXF_AGND: C7661.1 R5938.1 R5944.1 R5945.2 R5946.1 R5947.1 R6154.1 ST17.1 U136.F5 U136.F6 U136.G5 U136.G6
I2C2_SCL: EU1.12 EU2.12 J6.A8 R333.2 R859.2 U14.23 U34.A11 U43.6 U107.19
I2C2_SDA: EU1.11 EU2.11 J6.A9 R331.2 R858.2 U14.24 U34.B12 U43.5 U107.20
I2C3_SCL: R328.1 U29.13 U34.A12
I2C3_SDA: R327.1 U29.12 U34.B11
IIN-_0: C618.2 C7466.2 C7467.2 C7468.2 C7469.2 C7470.2 C7471.2 R5952.2 R5954.2 U135.E1 U135.E2 U135.E3 U135.E4 U135.F1 U135.F2 U135.F3 U135.F4 U135.G1 U135.G2 U135.G3 U135.G4 U135.H1 U135.H2 U135.H3 U135.H4
INTVCC4: C809.1 R656.2 R660.2 R664.2 U68.20
INTVCC5: C826.1 R668.2 R671.2 R676.2 U69.20
INTVCC6: C1332.1 R942.2 R946.2 R950.2 U71.20
INTVCC_PVCC: R6076.2 U116.C3
IO_1P8V: C477.2 C498.1 C1159.2 C1160.2 C1161.1 C1162.2 C1163.2 C1164.1 C1283.2 C7442.2 C7571.2 C7723.2 FB5.1 FB8.2 FB9.2 FB10.2 R198.2 R199.2 R200.2 R201.2 R209.1 R214.1 R215.1 R217.1 R218.1 R219.1 R241.2 R243.2 R245.2 R247.2 R251.2 R257.2 R263.2 R268.2 R269.2 R271.2 R282.1 R283.1 R305.2 R307.2 R983.2 R984.2 R2740.2 R6057.2 R6058.2 R6285.2 R6286.2 TP982.1 U6.BV36 U6.CA37 U6.CG37 U6.JL55 U6.JL57 U6.JU55 U6.JU57 U26.8(VCCB) U117.A1 U117.A7 U117.B1 U117.B7 U117.F1 U117.F7 U117.G1(VOUT4_2) U117.G7 U141.1
IO_1P8V_AGND: R6287.1 ST20.1
IO_1P8V_EN: R6167.1 R6242.1
IO_1P8V_PG: R6145.1 U34.T3 U117.D2
IO_1P8V_SI53254_1: C1293.1 C1294.1 C1389.1 C1390.1 C1391.1 C1392.1 FB10.1 U24.1(VDD_DIG) U24.4 U24.9 U24.15 U24.18 U24.25
IO_3P3V: C265.1 C266.2 C280.1 C281.2 C295.2 C296.2 C297.2 C298.2 C299.2 C300.2 C301.2 C302.2 C303.2 C304.2 C308.1 C310.1 C370.1 C371.1 C434.1 C478.2 C479.2 C480.2 C482.2 C484.1 C486.2 C488.2 C490.2 C561.1 C567.1 C1004.1 C1005.1 FB7.1 L1.1 L2.1 L3.1 L4.1 L5.1 L6.1 R121.2 R123.1 R124.1 R126.2 R128.1 R129.1 R131.2 R132.2 R133.2 R134.2 R135.2 R136.1 R149.2 R150.1 R153.2 R154.2 R156.1 R224.2 R226.2 R227.2 R228.2 R281.1 R306.2 R308.2 R311.2 R312.2 R315.1 R316.1 R327.2 R328.2 R331.1 R333.1 R338.2 R339.1 R340.1 R341.1 R342.2 R343.2 R347.1 R348.1 R349.1 R350.2 R354.2 R355.2 R356.2 R359.2 R361.2 R363.2 R364.2 R462.2 R463.2 R464.2 R835.2 R1001.2 TP994.1 U14.9 U14.20 U14.26(VDD2_2) U14.43 U14.54 U15.14 U18.14 U26.1 U27.1 U27.8(VCCB) U28.14 U29.14 U30.14 U31.14 U32.14 U42.19 U43.8 U87.1 U87.2 U87.3(S3) U88.6(VOUT)
IO_3P3V_EN: R839.2 R6243.1
IO_EXPNDR1_INT_N: R2742.1 U34.B7 U107.22
IO_EXPNDR1_RST_N: R2743.1 U34.A6 U107.24
IREF: C1718.2 R6194.2 U119.33 U119.43 U119.44 U119.47 U119.48
ISENSE0: R5883.2 U119.4 U120.33
ISENSE2: R5881.2 U119.3 U125.33
ISENSE3: R6035.2 U119.52 U126.33
ISENSE4: R5882.2 U119.51 U121.33
ITH0: C1720.1 U119.9
ITHR0: C1721.1 U119.10
JTAG_INPUT_SOURCE: R408.1 SW8.1 U34.B4
JTAGEN: R6189.1 R6190.2 U34.G6
LT4625_INTVCC: C715.2 R578.2 R581.2 R582.2 R583.2 U122.E4
LTM3888_ALERTN: R926.2 U119.17
LTM3888_SCL: J12.1 R546.2 U119.15
LTM3888_SDA: J12.2 R547.2 U119.16
LTM4623_INTVCC: C7650.1 R2788.2 R6141.2 U134.E4
LTM4623_INTVCC1: C7697.2 R6111.2 R6219.1 U123.E4
LTM4623_INTVCC2: C7700.2 R6115.2 R6220.1 U124.E4
LTM4623_INTVCC3: C7703.2 R6128.1 R6221.1 U142.E4
LTM4623_INTVCC4: C7704.2 R6122.2 R6222.1 U128.E4
LTM4623_INTVCC5: C7714.2 R6136.2 R6223.1 U133.E4
LTM_INTVCC1: C7760.2 R6077.1 U117.C4 U117.C7 U117.E1 U117.E7
LTM_PMBUS_ALERTN: R5847.2 R5937.2 R6163.2 U135.H11
LTM_SCL: J13.1 R621.2 R6289.2 U118.E4 U135.J12 U136.E4
LTM_SDA: J13.2 R622.2 R6290.2 U118.D4 U135.H10 U136.D4
M10_1V2_CLK: R441.2 U6.LB60 U40.3
M10_1V2_DATA0: R439.2 U6.LH60 U40.4
M10_1V2_DATA1: R438.2 U6.LL61 U40.5
M10_1V2_DATA2: R437.2 U6.KW59 U40.6
M10_1V2_DATA3: R436.2 U6.LB58 U40.7
M10_1V2_GPIO0: U6.LL59 U40.8
M10_1V2_GPIO1: U6.LH58 U40.9
M10_1V2_SSN: R442.2 U6.KW61 U40.1
M10_1V2_VCCDPLL: C541.1 C542.1 C543.1 C544.1 C545.1 L13.2 U34.D4 U34.D13 U34.M5 U34.N13
M10_CONF_DONE: Q15.1 R423.1 U34.E7
M10_CRC_ERROR: R6191.1 U34.C5 U105.13
M10_GPIO0: U40.13 U107.12
M10_GPIO1: U40.12 U107.13
M10_IBUS_CLK0: U6.W44 U106.6
M10_IBUS_CLK1: U6.W42 U105.1
M10_IBUS_CS0_N: U6.N43 U106.9
M10_IBUS_CS1_N: U6.N41 U105.5
M10_MISO_0: U6.L44 U106.8
M10_MISO_1: U6.L42 U105.4
M10_MOSI_0: U6.U43 U106.7
M10_MOSI_1: U6.U41 U105.3
M10_VCCINT: C546.1 L14.2 U34.F6
MAIN_I2C_SCL: R258.1 R309.1 R312.1 R324.2 R621.1 R6060.1 U22.16 U27.7 U141.7
MAIN_I2C_SDA: R261.1 R310.1 R311.1 R325.2 R622.1 R6059.1 U22.18 U27.6 U141.6
MAIN_PMBUS_EN: R315.2 SW4.3 U27.5 U34.A15
MAX10_VCCA_2.5V: C523.1 C524.1 C525.1 C526.1 C527.1 L11.2 U34.D5 U34.E12 U34.L5 U34.M12
MAX10_VCCA_ADC_2.5V: C528.1 L12.2 U34.E5
MAX_SDA: R372.2 U34.T9
MSEL0: R199.1 R203.2 SW2.1 U6.LB62
MSEL1: R200.1 R205.2 SW2.2 U6.MH64
MSEL2: R201.1 R202.2 SW2.3
MSEL2_FPGA_NCATTRIP: R202.1 U6.LW65 U34.J16
NIOS_UART_RX: J14.2 R6211.2 U34.F12
NIOS_UART_TX: J14.1 R6210.2 U34.A14
OVERTEMPN: D9.C(CATHODE) U107.10
PCIE_1V2_CLKREQN: R157.2 U6.J49 U15.5
PCIE_CLK_LOS: R2740.1 U24.10 U34.M9
PCIE_CLKREQN: C319.1 J5.B12 R156.2 U15.10
PCIE_EP_3P3V: J5.A9 J5.A10 J5.B8
PCIE_EP_3V3_WAKEN: R152.2 R155.2 U15.11
PCIE_EP_12V: C588.1 D13.1(C) J5.A2 J5.A3 J5.B1 J5.B2 J5.B3 R487.1 R503.2 TP960.1 TP961.1 U49.1 U49.2 U49.3(S3) U51.2
PCIE_EP_JTAG_TCK: J5.A5 R451.1 U41.1
PCIE_EP_JTAG_TDI: J5.A6 R149.1 R445.2 U41.3
PCIE_EP_JTAG_TDO: J5.A7 R443.1
PCIE_EP_JTAG_TMS: J5.A8 R153.1 R435.2 U39.1
PCIE_EP_PERSTN: J5.A11 R154.1 R1000.1 U107.11
PCIE_EP_PRSNT_N: J5.A1 SW1.1 SW1.2 SW1.3 SW1.4
PCIE_EP_PRSNT_NX1: C330.1 J5.B17 SW1.5(B4)
PCIE_EP_PRSNT_NX4: C331.1 J5.B31 SW1.6
PCIE_EP_PRSNT_NX8: C333.1 J5.B48 SW1.7
PCIE_EP_PRSNT_NX16: C335.1 J5.B81 SW1.8
PCIE_EP_RX_CN0: C307.2 J5.A17
PCIE_EP_RX_CN1: C312.2 J5.A22
PCIE_EP_RX_CN2: C314.2 J5.A26
PCIE_EP_RX_CN3: C316.2 J5.A30
PCIE_EP_RX_CN4: C318.2 J5.A36
PCIE_EP_RX_CN5: C322.2 J5.A40
PCIE_EP_RX_CN6: C328.2 J5.A44
PCIE_EP_RX_CN7: C334.2 J5.A48
PCIE_EP_RX_CN8: C337.2 J5.A53
PCIE_EP_RX_CN9: C339.2 J5.A57
PCIE_EP_RX_CN10: C342.2 J5.A61
PCIE_EP_RX_CN11: C344.2 J5.A65
PCIE_EP_RX_CN12: C346.2 J5.A69
PCIE_EP_RX_CN13: C348.2 J5.A73
PCIE_EP_RX_CN14: C350.2 J5.A77
PCIE_EP_RX_CN15: C352.2 J5.A81
PCIE_EP_RX_CP0: C306.2 J5.A16
PCIE_EP_RX_CP1: C311.2 J5.A21
PCIE_EP_RX_CP2: C313.2 J5.A25
PCIE_EP_RX_CP3: C315.2 J5.A29
PCIE_EP_RX_CP4: C317.2 J5.A35
PCIE_EP_RX_CP5: C320.2 J5.A39
PCIE_EP_RX_CP6: C326.2 J5.A43
PCIE_EP_RX_CP7: C332.2 J5.A47
PCIE_EP_RX_CP8: C336.2 J5.A52
PCIE_EP_RX_CP9: C338.2 J5.A56
PCIE_EP_RX_CP10: C341.2 J5.A60
PCIE_EP_RX_CP11: C343.2 J5.A64
PCIE_EP_RX_CP12: C345.2 J5.A68
PCIE_EP_RX_CP13: C347.2 J5.A72
PCIE_EP_RX_CP14: C349.2 J5.A76
PCIE_EP_RX_CP15: C351.2 J5.A80
PCIE_EP_RX_N0: C307.1 U6.DH73
PCIE_EP_RX_N1: C312.1 U6.DE76
PCIE_EP_RX_N2: C314.1 U6.CT73
PCIE_EP_RX_N3: C316.1 U6.CM76
PCIE_EP_RX_N4: C318.1 U6.CC73
PCIE_EP_RX_N5: C322.1 U6.BY76
PCIE_EP_RX_N6: C328.1 U6.BL73
PCIE_EP_RX_N7: C334.1 U6.BH76
PCIE_EP_RX_N8: C337.1 U6.AW73
PCIE_EP_RX_N9: C339.1 U6.AR76
PCIE_EP_RX_N10: C342.1 U6.AF73
PCIE_EP_RX_N11: C344.1 U6.AC76
PCIE_EP_RX_N12: C346.1 U6.T73
PCIE_EP_RX_N13: C348.1 U6.G73
PCIE_EP_RX_N14: C350.1 U6.E69
PCIE_EP_RX_N15: C352.1 U6.P69
PCIE_EP_RX_P0: C306.1 U6.DL74
PCIE_EP_RX_P1: C311.1 U6.DB77
PCIE_EP_RX_P2: C313.1 U6.CW74
PCIE_EP_RX_P3: C315.1 U6.CJ77
PCIE_EP_RX_P4: C317.1 U6.CF74
PCIE_EP_RX_P5: C320.1 U6.BU77
PCIE_EP_RX_P6: C326.1 U6.BP74
PCIE_EP_RX_P7: C332.1 U6.BE77
PCIE_EP_RX_P8: C336.1 U6.BB74
PCIE_EP_RX_P9: C338.1 U6.AM77
PCIE_EP_RX_P10: C341.1 U6.AJ74
PCIE_EP_RX_P11: C343.1 U6.Y77
PCIE_EP_RX_P12: C345.1 U6.V74
PCIE_EP_RX_P13: C347.1 U6.K74
PCIE_EP_RX_P14: C349.1 U6.C71
PCIE_EP_RX_P15: C351.1 U6.M71
PCIE_EP_SMBCLK: J5.B5 R147.1 U16.6 U34.B9
PCIE_EP_SMBDAT: J5.B6 R148.1 U16.5 U34.B5
PCIE_EP_TX_N0: J5.B15 U6.DB83
PCIE_EP_TX_N1: J5.B20 U6.CT79
PCIE_EP_TX_N2: J5.B24 U6.CJ83
PCIE_EP_TX_N3: J5.B28 U6.CC79
PCIE_EP_TX_N4: J5.B34 U6.BU83
PCIE_EP_TX_N5: J5.B38 U6.BL79
PCIE_EP_TX_N6: J5.B42 U6.BE83
PCIE_EP_TX_N7: J5.B46 U6.AW79
PCIE_EP_TX_N8: J5.B51 U6.AM83
PCIE_EP_TX_N9: J5.B55 U6.AF79
PCIE_EP_TX_N10: J5.B59 U6.Y83
PCIE_EP_TX_N11: J5.B63 U6.T79
PCIE_EP_TX_N12: J5.B67 U6.M83
PCIE_EP_TX_N13: J5.B71 U6.G79
PCIE_EP_TX_N14: J5.B75 U6.P76
PCIE_EP_TX_N15: J5.B79 U6.E76
PCIE_EP_TX_P0: J5.B14 U6.DE82
PCIE_EP_TX_P1: J5.B19 U6.CW80
PCIE_EP_TX_P2: J5.B23 U6.CM82
PCIE_EP_TX_P3: J5.B27 U6.CF80
PCIE_EP_TX_P4: J5.B33 U6.BY82
PCIE_EP_TX_P5: J5.B37 U6.BP80
PCIE_EP_TX_P6: J5.B41 U6.BH82
PCIE_EP_TX_P7: J5.B45 U6.BB80
PCIE_EP_TX_P8: J5.B50 U6.AR82
PCIE_EP_TX_P9: J5.B54 U6.AJ80
PCIE_EP_TX_P10: J5.B58 U6.AC82
PCIE_EP_TX_P11: J5.B62 U6.V80
PCIE_EP_TX_P12: J5.B66 U6.P82
PCIE_EP_TX_P13: J5.B70 U6.K80
PCIE_EP_TX_P14: J5.B74 U6.M77
PCIE_EP_TX_P15: J5.B78 U6.C77
PCIE_EP_WAKEN: R999.2 U6.H48 U15.4
PCIE_PERSTN: R367.1 R369.1 S2.2 U17.2
PCIE_PWRBRKN: C323.1 J5.B30 R158.2 U107.17
PCIE_RSV2: C321.1 J5.A19
PCIE_RSV4: C324.1 J5.A32
PCIE_RSV5: C325.1 J5.A33
PCIE_RSV6: C327.1 J5.B82
PCIE_RSV7: C329.1 J5.A50
PHMD4: R664.1 R667.2 U68.28
PHMD5: R676.1 R679.2 U69.28
PHMD6: R950.1 R953.2 U71.28
PHMD137: R6269.1 R6272.2 U137.28
POWER_ON: R401.1 R482.2 R495.2 R504.2 SW6.5
POWER_ON_R: R401.2 U34.A2
PWM0: R6040.1 U119.5
PWM2: R5891.1 U119.2
PWM3: R5894.1 U119.1
PWM4: R5886.1 U119.50
PWR_LED_DR: Q8.1 R360.1 U107.16
QSFPDD0_3V3_INT_L: J3.28 R123.2 U14.41
QSFPDD0_3V3_LPMODE: J3.31 U14.38
QSFPDD0_3V3_MODPRS_L: J3.27 R124.2 U14.39
QSFPDD0_3V3_RESET_L: J3.9 U14.40
QSFPDD0_FPGA_LED0: R346.1 U6.D44 U31.2
QSFPDD0_FPGA_LED1: R345.1 U6.J43 U31.3
QSFPDD0_FPGA_LED2: R344.1 U6.H44 U31.4
QSFPDD0_I2C_SCL: J3.11 R133.1 U14.36
QSFPDD0_I2C_SDA: J3.12 R132.1 U14.35
QSFPDD0_LED0: Q1.1 R341.2 U31.13
QSFPDD0_LED1: Q3.1 R340.2 U31.12
QSFPDD0_LED2: Q2.1 R339.2 U31.11
QSFPDD0_RX0_N: J3.18 U6.ME76
QSFPDD0_RX0_P: J3.17 U6.MB77
QSFPDD0_RX1_N: J3.21 U6.LT76
QSFPDD0_RX1_P: J3.22 U6.LP77
QSFPDD0_RX2_N: J3.15 U6.LV79
QSFPDD0_RX2_P: J3.14 U6.LY80
QSFPDD0_RX3_N: J3.24 U6.LT82
QSFPDD0_RX3_P: J3.25 U6.LP83
QSFPDD0_RX4_N: J3.56 U6.LK79
QSFPDD0_RX4_P: J3.55 U6.LM80
QSFPDD0_RX5_N: J3.59 U6.LG82
QSFPDD0_RX5_P: J3.60 U6.LD83
QSFPDD0_RX6_N: J3.53 U6.KV79
QSFPDD0_RX6_P: J3.52 U6.LA80
QSFPDD0_RX7_N: J3.62 U6.KP82
QSFPDD0_RX7_P: J3.63 U6.KL83
QSFPDD0_TX0_N: J3.37 U6.ME69
QSFPDD0_TX0_P: J3.36 U6.MB71
QSFPDD0_TX1_N: J3.2 U6.MG73
QSFPDD0_TX1_P: J3.3 U6.MJ74
QSFPDD0_TX2_N: J3.34 U6.LV73
QSFPDD0_TX2_P: J3.33 U6.LY74
QSFPDD0_TX3_N: J3.5 U6.LK73
QSFPDD0_TX3_P: J3.6 U6.LM74
QSFPDD0_TX4_N: J3.75 U6.LG76
QSFPDD0_TX4_P: J3.74 U6.LD77
QSFPDD0_TX5_N: J3.40 U6.KV73
QSFPDD0_TX5_P: J3.41 U6.LA74
QSFPDD0_TX6_N: J3.72 U6.KP76
QSFPDD0_TX6_P: J3.71 U6.KL77
QSFPDD0_TX7_N: J3.43 U6.KE73
QSFPDD0_TX7_P: J3.44 U6.KH74
QSFPDD0_VCC: C275.1 C276.2 C277.2 C278.2 J3.30 J3.68 L3.2
QSFPDD0_VCCR: C271.1 C272.2 C273.2 C274.2 J3.10 J3.48 L2.2
QSFPDD0_VCCT: C267.1 C268.2 C269.2 C270.2 J3.29 J3.67 L1.2
QSFPDD1_3V3_INT_L: J4.28 R128.2 U14.55
QSFPDD1_3V3_LPMODE: J4.31 U14.2
QSFPDD1_3V3_MODPRS_L: J4.27 R129.2 U14.1
QSFPDD1_3V3_RESET_L: J4.9 U14.56
QSFPDD1_FPGA_LED0: R353.1 U6.B41 U32.2
QSFPDD1_FPGA_LED1: R352.1 U6.D42 U32.3
QSFPDD1_FPGA_LED2: R351.1 U6.J41 U32.4
QSFPDD1_I2C_SCL: J4.11 R135.1 U14.4
QSFPDD1_I2C_SDA: J4.12 R134.1 U14.5
QSFPDD1_LED0: Q4.1 R349.2 U32.13
QSFPDD1_LED1: Q6.1 R348.2 U32.12
QSFPDD1_LED2: Q5.1 R347.2 U32.11
QSFPDD1_RX0_N: J4.18 U6.KE79
QSFPDD1_RX0_P: J4.17 U6.KH80
QSFPDD1_RX1_N: J4.21 U6.KB82
QSFPDD1_RX1_P: J4.22 U6.JW83
QSFPDD1_RX2_N: J4.15 U6.JN79
QSFPDD1_RX2_P: J4.14 U6.JT80
QSFPDD1_RX3_N: J4.24 U6.JK82
QSFPDD1_RX3_P: J4.25 U6.JG83
QSFPDD1_RX4_N: J4.56 U6.JA79
QSFPDD1_RX4_P: J4.55 U6.JD80
QSFPDD1_RX5_N: J4.59 U6.HU82
QSFPDD1_RX5_P: J4.60 U6.HP83
QSFPDD1_RX6_N: J4.53 U6.HE82
QSFPDD1_RX6_P: J4.52 U6.HB83
QSFPDD1_RX7_N: J4.62 U6.GN82
QSFPDD1_RX7_P: J4.63 U6.GK83
QSFPDD1_TX0_N: J4.37 U6.KB76
QSFPDD1_TX0_P: J4.36 U6.JW77
QSFPDD1_TX1_N: J4.2 U6.JN73
QSFPDD1_TX1_P: J4.3 U6.JT74
QSFPDD1_TX2_N: J4.34 U6.JK76
QSFPDD1_TX2_P: J4.33 U6.JG77
QSFPDD1_TX3_N: J4.5 U6.HU76
QSFPDD1_TX3_P: J4.6 U6.HP77
QSFPDD1_TX4_N: J4.75 U6.HH79
QSFPDD1_TX4_P: J4.74 U6.HL80
QSFPDD1_TX5_N: J4.40 U6.HE76
QSFPDD1_TX5_P: J4.41 U6.HB77
QSFPDD1_TX6_N: J4.72 U6.GT79
QSFPDD1_TX6_P: J4.71 U6.GW80
QSFPDD1_TX7_N: J4.43 U6.GK77
QSFPDD1_TX7_P: J4.44 U6.GG78
QSFPDD1_VCC: C290.1 C291.2 C292.2 C293.2 J4.30 J4.68 L6.2
QSFPDD1_VCCR: C286.1 C287.2 C288.2 C289.2 J4.10 J4.48 L5.2
QSFPDD1_VCCT: C282.1 C283.2 C284.2 C285.2 J4.29 J4.67 L4.2
QSFPDD_1V2_PORT_EN: R332.1 U6.B35 U31.5
QSFPDD_1V2_PORT_INT_N: U6.H38 U32.5
QSFPDD_3V3_PORT_EN: R136.2 R137.1 U14.22 U31.10
QSFPDD_3V3_PORT_INT_N: R131.1 U14.25 U32.10
QSPI_1_M10_CLK: U34.M11 U36.B2
QSPI_1_M10_CS_N: R211.1 U34.T13 U36.C2
QSPI_1_M10_DATA0: U34.R12 U36.D3
QSPI_1_M10_DATA1: U34.T12 U36.D2
QSPI_1_M10_DATA2: U34.P13 U36.C4(W#/DQ2)
QSPI_1_M10_DATA3: U34.P12 U36.D4
QSPI_1_M10_RESETN: R212.1 U34.K15 U36.A4
QSPI_2_M10_CLK: U34.L10 U104.B2
QSPI_2_M10_CS_N: R2699.1 U34.P11 U104.C2
QSPI_2_M10_DATA0: U34.R11 U104.D3
QSPI_2_M10_DATA1: U34.P10 U104.D2
QSPI_2_M10_DATA2: U34.M10 U104.C4(W#/DQ2)
QSPI_2_M10_DATA3: U34.L9 U104.D4
QSPI_2_M10_RESETN: R2700.1 U34.L12 U104.A4
QSPI_AVST_SEL: R198.1 SW2.4 U34.H15
RCOMP_FM41_BANK_14C: R6312.2 R6314.1 U6.CK70
RCOMP_FM41_BANK_15A: R6307.2 R6308.1 U6.HR27
RCOMP_FM41_BANK_15C: R6309.2 R6311.1 U6.FR27
REFCLK_CXL_15C_CH0_N: R190.1 R933.1 U6.ED26
REFCLK_CXL_15C_CH0_P: R932.1 R939.1 U6.EG27
REFCLK_CXL_15C_CH1_N: R191.1 R935.1 U6.EY26
REFCLK_CXL_15C_CH1_P: R934.1 R941.1 U6.FC27
REFCLK_CXL_EP_N: C476.1 R254.1
REFCLK_CXL_EP_P: C475.1 R252.1
REFCLK_CXL_RP_N0: J7.B30 R256.1
REFCLK_CXL_RP_N1: J7.B12 R262.1
REFCLK_CXL_RP_P0: J7.B29 R255.1
REFCLK_CXL_RP_P1: J7.B11 R259.1
REFCLK_FGT12ACH0_N: C1452.2 R140.2 U6.JP70
REFCLK_FGT12ACH0_P: C1451.2 R140.1 U6.JH70
REFCLK_FGT12ACH3_N: C454.2 R142.2 U6.HM70
REFCLK_FGT12ACH3_P: C453.2 R142.1 U6.HJ68
REFCLK_FGT12ACH4_N: C446.2 R143.2 U6.JA73
REFCLK_FGT12ACH4_P: C445.2 R143.1 U6.JD74
REFCLK_FGT12ACH5_N: C448.2 R138.2 U6.HH73
REFCLK_FGT12ACH5_P: C447.2 R138.1 U6.HL74
REFCLK_FGT12ACH6_N: C452.2 R144.2 U6.FU73
REFCLK_FGT12ACH6_P: C451.2 R144.1 U6.FP74
REFCLK_FM41_14C_PCIE_N: R6321.2 R6322.1 U6.ED70
REFCLK_FM41_14C_PCIE_P: R6320.2 R6323.1 U6.EG68
REFCLK_FM41_15C_CXL_N: R6318.2 U6.JB26
REFCLK_FM41_15C_CXL_P: R6316.1 R6317.2 U6.JH26
REFCLK_PCIE_14C_CH0_N: R178.1 R929.1 U6.DM70
REFCLK_PCIE_14C_CH0_P: R928.1 R936.1 U6.DR68
REFCLK_PCIE_14C_CH1_N: R179.1 R931.1 U6.CR70
REFCLK_PCIE_14C_CH1_P: R930.1 R937.1 U6.CU68
REFCLK_PCIE_EP_EDGE_N: C466.1 J5.A14
REFCLK_PCIE_EP_EDGE_P: C465.1 J5.A13
REFCLK_PCIE_EP_N: C468.1 R250.1
REFCLK_PCIE_EP_P: C467.1 R249.1
RUN0: C7578.2 R6066.1 R6273.1 U120.30
RUN1: C1729.2 R5884.1 R6274.1 U121.30
RUN2: C7580.2 R6067.1 R6275.1 U125.30
RUN3: C7582.2 R6068.1 R6276.1 U126.30
SEL_CXL_REFCLK: R281.2 SW3.2 U25.20
SEL_PCIE_REFCLK: R282.2 SW3.3 U24.20
SH_CLK: R5878.1 U119.29
SI2204_OUT0N: R250.2 U23.13
SI2204_OUT0P: R249.2 U23.12
SI2204_OUT1N: R254.2 U23.18
SI2204_OUT1P: R252.2 U23.17
SI2204_OUT2N: R256.2 U23.22
SI2204_OUT2P: R255.2 U23.21
SI2204_OUT3N: R262.2 U23.26
SI2204_OUT3P: R259.2 U23.25
SI5391_1P8V_VDDO: C437.1 C438.1 C439.1 C440.1 C441.1 C442.1 C443.1 C444.1 FB8.1 U22.26 U22.29 U22.33 U22.40 U22.49 U22.57
SI5391_2P5V_VDDO: C429.1 C430.1 C431.1 C432.1 C433.1 FB6.1 U22.22 U22.36 U22.43 U22.52
SI5391_A0: R223.1 U22.19
SI5391_A1: R225.1 U22.17
SI5391_ENN: R288.2 SW3.1 U22.11 U107.1
SI5391_I2C_SEL: R224.1 U22.39
SI5391_IN_SEL0: R227.1 U22.3
SI5391_IN_SEL1: R226.1 U22.4
SI5391_OUT0AN: C448.1 U22.20
SI5391_OUT0AP: C447.1 U22.21
SI5391_OUT0N: C446.1 U22.23
SI5391_OUT0P: C445.1 U22.24
SI5391_OUT1N: R232.2 U22.27
SI5391_OUT1P: R231.2 U22.28
SI5391_OUT2N: R230.2 U22.30
SI5391_OUT2P: R229.2 U22.31
SI5391_OUT3N: R1064.2 U22.34
SI5391_OUT3P: R1063.2 U22.35
SI5391_OUT4N: C452.1 U22.37
SI5391_OUT4P: C451.1 U22.38
SI5391_OUT5N: R1066.2 U22.41
SI5391_OUT5P: R1065.2 U22.42
SI5391_OUT6N: C454.1 U22.44
SI5391_OUT6P: C453.1 U22.45
SI5391_OUT7P: R239.2 U22.51
SI5391_OUT8N: C1452.1 U22.53
SI5391_OUT8P: C1451.1 U22.54
SI5391_OUT9A: R237.2 U22.59
SI5391_OUT9N: R236.2 U22.55
SI5391_OUT9P: R235.2 U22.56
SI5391_RSTN: R228.1 U22.6 U107.6
SI5391_VDD: C425.1 C426.1 C427.1 C428.1 FB5.2 U22.32 U22.46 U22.60
SI5391_VDDA: C435.1 C436.1 FB7.2 U22.13
SI5391_X1: U22.7 Y1.2
SI5391_X2: U22.10 Y1.4
SI5391_XA: U22.8 Y1.3
SI5391_XB: U22.9(XB) Y1.1
SI52204_FS: R257.1 R260.1 U23.11
SI52204_OE0N: R241.1 R242.1 U23.14
SI52204_OE1N: R245.1 R246.1 U23.16
SI52204_OE2N: R247.1 R248.1 U23.23
SI52204_OE3N: R243.1 R244.1 U23.27
SI52204_PWRDNB: R283.2 SW3.4 U23.2
SI52204_SA: R263.1 R264.1 U23.7
SI52204_SSEN: R251.1 R253.1 U23.1
STRAP_1_PCLASS1: R2206.2 R2727.2 R2730.2 R2734.2 SW5.2 TP27.1 U34.R6
STRAP_2_SMBUS_I2C_ADDR: R2721.1 R2726.2 TP28.1 U34.J1
STRAP_3_CVL_PRSNT0_N: R2725.2 R2732.2 R2735.1 SW5.4 U34.L6
STRAP_4_BRD_REV0: R2635.2 R2637.2 U34.F14
STRAP_5_BRD_REV1: R6192.2 R6193.2 U34.E16
SW1_3: R2721.2 R2731.2 SW5.3
SW1_5: R2719.2 R2732.1 SW5.5(B4)
SW1_6: R2718.2 R2731.1 SW5.6 TP25.1
SW1_7: R2717.2 R2730.1 SW5.7 TP24.1
SW_U120_FPGA_VCC: L27.1 U120.1 U120.2 U120.3 U120.4 U120.5 U120.6 U120.10 U120.11 U120.12 U120.13 U120.14 U120.15 U120.16 U120.42
SW_U121_FPGA_VCC: L28.1 U121.1 U121.2 U121.3 U121.4 U121.5 U121.6 U121.10 U121.11 U121.12 U121.13 U121.14 U121.15 U121.16 U121.42
SW_U125_FPGA_VCC: L23.1 U125.1 U125.2 U125.3 U125.4 U125.5 U125.6 U125.10 U125.11 U125.12 U125.13 U125.14 U125.15 U125.16 U125.42
SW_U126_FPGA_VCC: L29.1 U126.1 U126.2 U126.3 U126.4 U126.5 U126.6 U126.10 U126.11 U126.12 U126.13 U126.14 U126.15 U126.16 U126.42
SYNC: R5877.1 U119.14
TEMP1_THERMN: EU1.9 R453.1 U107.7
TEMP2_THERMN: EU2.9 R465.1 U107.8
TMON0: C7686.2 R6039.1 U120.22
TMON1: C7689.2 R5885.1 U121.22
TMON3: C2028.2 R5890.1 U125.22
TMON4: C7690.2 R5893.1 U126.22
TSNS0: C1719.1 R5885.2 R5890.2 R5893.2 R6039.2 U119.8
USB_DISABLEN: R6183.2 R6184.2 U34.T2
USB_MAX_JTAGSEL: R413.2 SW8.3 U34.F11 U38.15
USB_MAX_TCK: U34.H3 U38.2
USB_MAX_TDI: U34.G1 U38.7
USB_MAX_TDO: U34.H1 U38.10
USB_MAX_TMS: U34.H2 U38.5
USB_T_CLK: R378.1 U34.R10
VFB0: C7678.1 R5875.2 R5876.1 U119.12
VOSNS0_0P8V: R5925.2 U136.D7 U136.H7
VOSNS0_VCCR: R5835.2 U118.D7 U118.H7
VSENSE0+: R220.2 R5887.1 R6277.1
VSENSE0+_U119: R6277.2 U119.7
VSENSE0-: R221.2 R5888.1 R6278.1
VSENSE0-_U119: R6278.2 U119.6
VTT_DDR4_CH1_EN: R817.2 R6246.1
VTT_DDR4_CH2_EN: R823.2 R6247.1
VTT_DDR4_CH3_EN: R2781.2 R6248.1
N17328275: J1.1 J1.145 R77.2 R78.2
N17329090: J1.288 R94.2
N23628441: C196.1 R73.1 R74.1
N28015562: R1.1 U1.F9
N28022993: R2.1 U2.F9
N30715060: R7.1 U3.F9
N30715756: R8.1 U4.F9
N30729048: R62.1 U11.F9
N30732060: R51.2 U11.A3
N30732063: R52.2 U11.B8
N30732066: R53.2 U11.C3
N30732069: R54.2 U11.C7
N30732072: R55.2 U11.C2
N30732075: R56.2 U11.C8
N30732078: R57.2 U11.D3
N30732081: R58.2 U11.D7
N30732436: R59.2 U11.E2
N30732839: R60.2 U11.B7
N30732842: R61.2 U11.A7
N31250983: J5.B11(WAKE_N) R152.1
N31253147: R151.2 R155.1
N31253181: J5.B9 R150.2
N31257069: J5.B10 R151.1
N31314586: TP8.1 U122.B5
N31314601: TP9.1 U122.A5
N31314621: C716.2 R580.2 U122.C5
N31314744: R582.1 U122.B2
N31314754: C720.2 R581.1 U122.A1
N31314797: R583.1 R585.1 U122.C4
N31314853: R584.1 U122.A4
N31314899: C726.2 U122.A2
N31314949: R587.1 R589.1 U122.A3
N31314957: C725.1 C727.2 R586.2 R590.2 U122.B1
N31352894: R317.2 SW4.5(B4)
N31352897: R318.2 SW4.6
N31352900: R319.2 SW4.7
N31388806: D7.A R359.1
N31388830: D5.A R356.1
N31388866: D5.C(CATHODE) Q7.3
N31388880: D7.C(CATHODE) Q9.3
N31388890: D8.A R361.1
N31388919: D8.C(CATHODE) Q10.3
N31389008: D10.A R363.1
N31389082: D10.C(CATHODE) Q11.3
N31389320: D11.A R364.1
N31389364: D11.C(CATHODE) Q12.3
N31415897: Q13.4 R483.1
N31415950: C581.1 R483.2 U48.1
N31416024: Q14.3 R485.2 U48.5
N31416063: C582.2 R490.1 U48.6(VSS)
N31416065: C587.1 R487.2 R488.1 R489.2
N31416086: Q14.1 R489.1
N31558092: R3.1 U1.E9(ZQ1)
N31558448: R4.1 U2.E9(ZQ1)
N31558945: R9.1 U3.E9(ZQ1)
N31559300: R10.1 U4.E9(ZQ1)
