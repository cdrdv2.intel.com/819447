# Allegro board FM85_AGILEX_PCIE_DK_CMC_ADI_REVC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GND_CHS: length 2.5
  TOP w0.381: J8.7 5.12,30.53 5.28,30.37 R375.1 ; C496.1 4.51,26.14 J8.6
GND_QSFPDD0_CAGE: length 31
  BOTTOM w1.016: B1.12 B1.11 60.1,88.7 57.79,91.01 40.57,91.01 B1.1
  vias: v4(19.31,72.47) v4(19.31,71.45) v4(20.2,72.47) v4(20.2,71.45) v4(21.03,72.47) v4(21.03,71.45)
GND_QSFPDD1_CAGE: length 29
  BOTTOM w1.016: B2.11 B2.12 60.1,48.44 58.41,46.75 B2.6
  vias: v4(32.93,66.47) v4(32.93,65.46) v4(33.81,66.47) v4(33.81,65.46) v4(34.64,66.47)
GNDSENSE: length 29
  BOTTOM w0.203: R221.1 127.73,81.91 127.73,80.91 128.02,80.62 128.02,79.83 127.26,79.07 127.26,78.67 126.99,78.41 126.99,78.11 127.13,77.97 127.13,77.61 126.99,77.47 126.99,77.19 127.13,77.05 127.13,76.69 126.99,76.55 126.99,76.25 127.11,76.13 127.11,75.77 126.99,75.65 126.99,75.33 127.11,75.21 127.11,74.85 126.99,74.73 126.99,74.41 127.11,74.29 127.11,73.93 126.99,73.81 126.99,73.5 127.12,73.37 127.12,73 126.99,72.87 126.99,72.57 127.11,72.45 127.11,72.09 126.99,71.97 126.99,71.65 127.11,71.53 127.11,71.29 arc(127.09,71.19) 127.04,71.1 arc(127.01,71.04) 127,70.97 127,70.85 arc(127.01,70.75) 127.07,70.67 arc(127.11,70.61) 127.13,70.53 127.13,70.33 arc(127.11,70.25) 127.07,70.19 arc(127.01,70.1) 127,70.01 127,69.82 127.12,69.69 127.12,69.32 126.99,69.19 126.99,68.9 127.12,68.77 127.12,68.4 127.05,68.33 127.05,67.95 127.12,67.87 127.12,67.48 126.99,67.35 126.99,67.06 127.12,66.93 127.12,66.56 126.99,66.43 126.99,66.14 127.12,66.01 127.12,65.64 126.99,65.51 126.99,65.22 127.12,65.09 127.12,64.72 126.99,64.59 126.99,64.3 127.12,64.17 127.12,63.8 126.99,63.67 126.99,63.38 127.12,63.25 127.12,62.88 126.99,62.75 126.99,62.46 127.12,62.33 127.12,62 127.04,61.85 126.89,61.7 126.55,61.7 126.37,61.6 126.24,61.36 126.24,61.04 126.35,60.93 126.35,60.66 126.28,60.54 126.04,60.29 125.76,60.29 125.53,60.16 125.41,59.95 125.23,59.85 124.93,59.85 124.86,59.89 124.46,60.29 124.08,60.29 123.93,60.15 123.84,59.99 123.7,59.85 v1(122.7,59.85)
PVCC: length 13
  TOP w0.191: U120.28 173.83,83.7 173.93,83.6 174.2,83.6 v1(174.57,83.23)
  TOP w0.203: 173.88,55.66 174.32,55.66 C7581.2 ; 173.88,55.66 174.1,55.88 ; 173.88,55.66 U125.28 ; 174.3,41.05 174,41.35 U126.29 ; 174.3,41.05 174.93,41.05 v1(174.95,41.03) ; 174.3,41.05 174.11,40.85 U126.28 ; v1(174.67,83.87) 174.44,84.09 173.94,84.09 173.84,84.2 U120.29 ; 174.1,55.88 173.82,56.16 U125.29 ; 174.1,55.88 v1(174.53,55.45) ; U121.29 174,70.16 174.49,69.66 v1(174.49,69.46) 174.24,69.46 174.04,69.66 U121.28
  BOTTOM w0.381: v1(174.49,69.46) 174.49,69.46 C1728.2 ; C7579.2 v1(174.57,83.23)
  vias: v1(192.52,61.4) v1(192.82,64.06) v1(192.84,63.58) v1(192.82,58.92) v1(193.68,58.91) v1(193.93,64.79) v1(193.89,64.06) v1(194.49,64.45) v1(195.15,64.79) v1(195.18,64.14) v1(195.17,62.89) v1(195.18,60.33) v1(195.18,59.06) v1(198.99,65.06)
SVIN4: length 3
  TOP w0.254: R663.1 35.79,102 U68.3
  TOP w0.381: C808.1 R663.1
SVIN5: length 3
  TOP w0.254: U69.3 205.61,37.79 206.13,38.31 R673.1
  TOP w0.381: C825.1 R673.1
SVIN6: length 3
  TOP w0.254: R949.1 49.87,102.05 U71.3
  TOP w0.381: C1331.1 R949.1
VBUS_5V: length 4.2
  TOP w0.381: J8.1 6.3,29.6 6.78,30.08 6.78,31.25 R382.1
VCC_HSSI_AGND: length 3.5
  TOP w0.203: v4(176.92,36.02) 176.8,36.02 176.46,35.68 ST13.1
  BOTTOM w0.203: C7462.2 182.98,41.27 182.73,41.02 v1(182.58,41.02) ; C7461.2 181.95,41.66 v1(181.31,41.02)
  vias: v1(181.31,39.75) v1(182.58,39.75) v4(176.28,36.43) v4(176.92,36.91)
VCC_HSSI_GXF_EN: length 73.9
  TOP w0.149: R6231.1 v1(41.55,23.95)
  L05_SIG2 w0.081: v1(41.55,23.95) 41.76,23.74 42.37,23.74 43.06,24.43 43.06,25.85 42.83,26.08 42.83,28.21 43.4,28.77 43.4,29.22 45.16,30.97 45.16,31.7 45.39,31.93 45.61,31.93 45.94,32.26 45.94,33.71 45.67,33.98 45.67,41.03 45.23,41.48 45.23,42.25 44.44,43.03 44.44,44.08 43.05,45.47 43.05,48.82 v1(40.57,51.31)
  L07_SIG3 w0.089: v1(71.01,67.44) 70.2,67.44 69.97,67.21 69.87,67.21 69.64,66.98 69.64,66.88 68.71,65.95 65.25,65.95 65.12,66.08 61.84,66.08 61.15,65.39 60.97,65.39 57.14,61.56 57.14,61.39 55.43,59.68 55.43,58.77 55.43,58.76 55.12,58.45 54.21,58.45 53.81,58.05 48.93,58.05 48.35,58.63 44.01,58.63 41.31,55.93 41.31,53.21 41.6,52.92 41.6,52.33 v1(40.57,51.31)
VCC_HSSI_GXF_PG: length 79.2
  TOP w0.149: U34.D9 31.5,29.77 v1(31.01,29.29)
  L05_SIG2 w0.081: v1(64.42,67.41) 64.19,67.65 62.26,67.65 62.16,67.74 61.84,67.74 61.75,67.65 43.55,67.65 37.59,61.69 37.59,60.49 37.27,60.17 34.39,60.17 34,59.78 34,53.97 35.2,52.77 35.2,47.4 38.42,44.18 38.42,38.99 40.02,37.39 40.02,33.32 39.55,32.85 39.01,32.85 38.75,32.59 38.75,31.51 39.1,31.15 39.1,29.98 38.65,29.53 38.54,29.53 37.94,28.94 37.94,28.82 36.52,27.4 31.99,27.4 31.01,28.38 v1(31.01,29.29)
VCC_HSSI_GXR_EN: length 179.9
  TOP w0.149: R6232.1 41.6,22.35 v1(41.79,22.53) ; v1(177.11,41.35) 176.35,40.59 176.35,38.61 175.46,37.72 175.46,36.19 175.21,35.94 175.21,35.44 175.52,35.13 175.52,33.53 176.02,33.03 176.02,31.67 175.68,31.34 175.68,27.57 177.88,25.37 177.88,19.81 177.18,19.11 177.18,18.55 178.07,17.67 v1(178.07,14.24)
  L03_SIG1 w0.081: v1(178.07,14.24) 177.24,13.42 139.59,13.42 v1(138.65,12.48)
  L14_SIG5 w0.081: v1(41.79,22.53) 42.05,22.27 42.11,22.27 43.19,21.19 43.88,21.19 44.13,21.44 45.37,21.44 46.13,22.21 47.36,22.21 47.83,22.69 50.08,22.69 50.64,23.26 51.22,23.26 51.63,22.85 51.63,22.09 51.94,21.78 52.12,21.78 55.56,18.34 57.9,18.34 58.51,17.73 59.42,17.73 63.11,14.04 63.11,13.43 68.82,7.72 118.67,7.72 120.92,9.97 120.92,11.23 121.58,11.9 124.53,11.9 124.53,11.9 124.74,11.9 124.94,12.1 124.96,12.1 130.6,12.1 130.79,11.91 131.76,11.91 132.4,12.55 134.56,12.55 135.35,11.77 137.65,11.77 138.37,12.48 v1(138.65,12.48)
VCC_HSSI_GXR_PG: length 213.4
  L03_SIG1 w0.081: v2(31.5,27.9) 32.01,27.39 32.01,23.86 32.34,23.53 32.53,23.53 32.87,23.2 32.87,22.85 33.45,22.27 34.65,22.27 34.87,22.06 34.87,19.65 36.23,18.29 38.78,18.29 39.19,18.7 40.86,18.7 41.09,18.47 41.63,18.47 41.98,18.82 42.13,18.97 v1(42.56,18.97)
  L05_SIG2 w0.081: v1(171.32,16.81) 171.32,16.58 170.02,15.28 163.3,15.28 162.67,14.65 130.91,14.65 130.59,14.97 117.57,14.97 114.68,12.08 74.35,12.08 73.62,12.81 59.89,12.81 59.64,12.56 58.04,12.56 57.57,13.03 56.97,13.03 53.19,16.81 46.94,16.81 46.47,16.35 44.48,16.35 43.37,17.45 43.37,18.36 43.11,18.63 42.9,18.63 v1(42.56,18.97)
  L14_SIG5 w0.081: v1(185.12,43.56) 184.73,43.17 184.73,37.53 183.96,36.76 183.64,36.76 183.32,37.07 182.99,37.21 v1(182.58,37.21) 182.58,36.68 182.95,36.31 182.95,35.76 182.03,34.84 181.67,34.84 181.47,35.04 178.62,35.04 178.41,34.84 175.73,34.84 175.01,35.56 161.81,35.56 161.73,35.48 161.73,31.37 162.92,30.18 165.91,30.18 166.86,29.23 167.04,29.23 167.26,29.02 167.26,28.58 168.15,27.69 168.4,27.69 168.68,27.42 168.68,27.06 168.9,26.83 169.26,26.83 169.48,26.62 169.48,26.26 169.7,26.03 170.2,26.03 172.17,24.07 172.17,18.4 171.32,17.55 v1(171.32,16.81)
  BOTTOM w0.149: R6164.2 182.34,37.46 v1(182.58,37.21)
VCC_INT:
  vias: v1(185.12,38.48)
VCCA_PLL_FLTR: length 5.6
  BOTTOM w0.381: v1(130.67,82.2) 130.79,82.33 131.61,82.33 133.66,84.37 C783.2
  vias: v1(113.93,71.35) v1(113.93,47.43) v1(115.52,71.35) v1(115.52,47.43) v1(117.12,71.35) v1(117.12,47.43) v1(118.71,71.35) v1(118.71,47.43) v4(134.71,87.24) v4(134.71,85.97) v4(134.71,84.7) v4(136,85.97) v4(136,84.7) v4(137.31,87.24) v4(137.31,85.97) v4(137.31,84.7) v4(138.58,85.97) v4(138.58,84.7)
VCCCLK_GXR_EN: length 286.7
  TOP w0.149: U129.B3 183.14,68.59 183.41,68.86 184.83,68.86 v1(185.86,67.83)
  L03_SIG1 w0.081: v1(218.08,21.67) 218.08,21.96 217.73,22.32 217.73,31.66 218.83,32.77 218.83,35.51 217.73,36.62 217.73,49.45 218.09,49.82 218.09,60.01 217.41,60.69 214.87,60.69 214.54,61.02 214.54,67.04 214.77,67.27 214.77,68.15 213.79,69.12 210.77,69.12 208.79,67.14 207.92,67.14 206.36,65.58 204.89,65.58 202.16,68.32 199.67,68.32 198.62,69.36 195.57,69.36 194.97,68.76 192.03,68.76 191.08,69.72 189.83,69.72 188.35,68.24 186.27,68.24 v1(185.86,67.83) ; v1(214.07,14.12) 213.6,13.66 200.7,13.66 199.64,14.71 196.95,14.71 196.87,14.63 192.62,14.63 191.92,15.33 187.39,15.33 186.44,14.39 181.93,14.39 180.7,15.62 180.54,15.78 178.84,15.78 178.52,15.46 176.64,15.46 175.54,14.36 136.76,14.36 135.43,13.03 v1(135.43,12.43)
  L07_SIG3 w0.089: v1(218.08,21.67) 217.99,21.76 217.41,21.76 214.14,18.48 214.14,14.19 v1(214.07,14.12)
  L14_SIG5 w0.081: v1(135.43,12.43) 134.85,13.02 130.35,13.02 129.76,12.43 127.7,12.43 126.86,13.28 125.77,13.28 125.47,12.97 122.97,12.97 122.27,13.68 120.97,13.68 119.68,12.39 117.89,12.39 117.15,11.64 79.02,11.64 78.82,11.85 69.86,11.85 69.13,12.58 66.55,12.58 63.47,15.66 63.47,17.79 61.24,20.02 59.61,20.02 59.19,20.44 58.83,20.44 52.3,26.97 51.97,26.97 51.93,27.01 50.09,27.01 50.02,26.94 49.45,26.94 49.09,26.58 45.92,26.58 44.76,27.74 44.76,28.21 42.95,30.03 42.48,30.03 41.27,31.24 v1(40.91,31.24)
VCCCLK_GXR_PG: length 255.1
  TOP w0.149: U129.C3 v1(184.28,68.32)
  L05_SIG2 w0.081: v1(29.5,17.9) 30.61,16.79 34.82,16.79 35.59,16.01 35.59,15.84 36.16,15.27 45.73,15.27 47.12,13.88 47.56,13.88 48.38,13.06 48.77,13.06 49.14,13.43 49.77,13.43 49.89,13.56 52.34,13.56 52.5,13.4 54.24,13.4 54.4,13.55 55.18,13.55 56.56,12.17 57.39,12.17 59.45,10.1 114.1,10.1 118.38,14.38 130.14,14.38 130.55,13.97 170.45,13.97 172.39,15.9 v1(172.39,16.37)
  L14_SIG5 w0.081: v1(184.28,68.32) 183.89,67.94 183.89,67.25 184.12,67.02 184.25,67.02 184.53,66.74 184.53,66.73 184.76,66.5 184.77,66.5 186.51,64.76 190.89,64.76 192.47,63.19 192.9,63.19 194.87,61.21 195.08,61.21 196.06,60.23 196.06,60.17 196.29,59.94 196.35,59.94 199.42,56.87 199.42,54.87 199.64,54.65 199.94,54.65 200,54.59 200,54.55 200.16,54.39 200.16,54.07 199.94,53.85 199.94,53.84 200.22,53.57 200.22,52.47 200.49,52.2 204.74,52.2 205.83,51.11 205.83,50.37 207.63,48.58 210.39,48.58 211.87,47.09 211.87,43.45 210.49,42.06 209.62,42.06 206.78,39.22 206.78,38.28 205.31,36.82 204.1,36.82 204.04,36.88 203.73,36.88 201.22,34.37 193.28,34.37 190.69,31.78 186.8,31.78 185.35,30.34 176.26,30.34 175.41,31.19 174.48,31.19 174.02,30.72 174.02,30.04 175.12,28.94 175.12,26.83 174.87,26.57 174.87,26.43 173.24,24.8 173.24,17.22 v1(172.39,16.37)
VCCE_PLL_DTS_GXR: length 3.8
  TOP w0.381: v4(75.13,43.05) v4(74.49,43.05) ; TP985.1 v1(71.44,44.66)
  L16_SIG6 w0.508: v1(105.96,55.71) 105.63,55.71 v1(105.17,56.17) ; v1(127.48,53.41) 127.14,53.41 v1(126.68,53.87)
  vias: v4(72.73,43.05)
VCCED_AGND: length 3.6
  BOTTOM w0.203: ST31.2 199.49,55.82 v1(199.79,55.82)
  BOTTOM w0.381: C1348.2 203.27,48.39 203.78,48.9 v1(203.78,49.25) ; v1(206.31,51.41) 206.29,51.43 C1345.2
  vias: v1(206.08,49.29)
VCCED_GXR_EN: length 257.6
  TOP w0.149: R6239.1 41.36,32.69 42.08,33.41 v1(42.08,34.33)
  L12_SIG4 w0.089: v1(136.87,12.91) 137.57,13.61 190.92,13.61 v1(191.26,13.96)
  L14_SIG5 w0.081: v1(136.87,12.91) 136.01,13.77 129.64,13.77 128.77,14.63 120.85,14.63 119.55,13.33 66.91,13.33 64.22,16.02 64.22,18.05 64.21,18.06 64.21,18.1 61.55,20.76 60.9,20.76 59.13,22.53 59.13,24.42 56.3,27.24 55.85,27.24 55.62,27.47 55.62,27.93 55.24,28.31 50.05,28.31 49.04,29.32 49.04,30.31 47.93,31.42 47.54,31.42 45.84,33.13 45.84,33.58 45.08,34.34 42.09,34.34 42.07,34.33 v1(42.08,34.33) ; v1(200.59,53.42) 201,53.83 201,55.99 202.68,57.67 202.68,60.85 206.06,64.24 215.1,64.24 216.13,63.21 216.13,52.27 217.09,51.3 217.09,49.73 217.69,49.14 217.69,43.28 217.68,43.27 217.68,43.26 213.05,38.63 213.05,37.9 213.24,37.71 213.24,26.87 208.77,22.4 208.36,22.4 208.11,22.15 203.97,22.15 203.24,22.88 197.22,22.88 192.07,17.73 192.07,14.77 v1(191.26,13.96)
VCCED_GXR_PG: length 276.7
  L05_SIG2 w0.081: v1(31.5,19.9) 31.87,19.53 31.87,19 33.86,17.02 34.85,17.02 35.78,16.09 35.78,15.91 36.18,15.51 45.83,15.51 46.43,14.91 47.27,14.91 48.32,13.85 48.71,13.85 48.9,13.67 49.67,13.67 49.79,13.79 52.1,13.79 52.5,14.19 55.04,14.19 56.67,12.56 57.38,12.56 58.48,11.47 62.1,11.47 62.47,11.84 73.93,11.84 74.16,11.61 115.09,11.61 118.08,14.61 130.24,14.61 130.65,14.2 169.64,14.2 172.21,16.77 179.52,16.77 182.73,13.56 192.84,13.56 v1(193.51,14.23)
  L07_SIG3 w0.089: v1(199.07,54.17) 199.52,54.62 200.19,54.62 v1(200.59,54.22)
  L14_SIG5 w0.081: v1(200.59,54.22) 200.18,54.63 200.18,55.93 200.44,56.19 200.8,56.19 202.42,57.81 202.42,60.92 205.97,64.47 215.58,64.47 216.41,63.64 216.41,52.43 217.33,51.51 217.33,49.83 217.92,49.23 217.92,38.37 219.13,37.17 219.13,31.93 217.8,30.6 217.8,22.14 216.19,20.54 216.19,17.67 215.5,16.98 214.98,16.98 214.75,16.75 214.75,16.23 212.64,14.12 209.12,14.12 207.12,16.13 201.35,16.13 200.51,16.96 200.07,16.96 199.11,17.92 198.56,17.92 196.2,20.28 195.8,20.28 195.48,19.96 195.48,19.66 193.19,17.36 193.19,16.84 193.51,16.52 v1(193.51,14.23)
VCCED_SNS_N: length 132.8
  TOP w0.254: v1(98.84,36.01) 99.16,35.69 99.16,34.14 100.4,32.9 104.23,32.9 106,31.14 144.04,31.14 145.62,29.56 172.22,29.56 172.58,29.19 172.58,29.04 v1(172.25,28.71)
  L14_SIG5 w0.203: v1(172.25,28.71) 172.66,28.3 172.66,28.01 172.46,27.81 171.93,27.81 171.47,28.28 171.47,31.45 170.69,32.23 170.69,34.56 170.93,34.8 174.06,34.8 176.29,32.58 184.17,32.58 184.67,33.07 184.67,33.59 184.93,33.86 185.45,33.86 185.94,34.34 185.94,34.86 186.26,35.19 186.75,35.19 187.23,35.67 187.23,36.15 187.52,36.45 188.08,36.45 188.48,36.85 188.48,37.4 188.74,37.67 189.32,37.67 189.75,38.1 189.75,43.68 190.08,44.02 190.5,44.02 191.02,44.54 191.02,45.02 191.28,45.29 193.18,45.29 195.05,47.16 196.7,47.16 196.84,47.02 198.68,47.02 200.92,49.26 200.92,50.66 201.39,51.13 v1(201.39,51.82)
VCCED_SNS_P: length 133.1
  TOP w0.254: v1(99.85,36.01) 99.54,35.69 99.54,34.3 100.55,33.28 104.39,33.28 106.15,31.52 121.79,31.52 121.79,31.52 121.8,31.52 121.81,31.52 144.2,31.52 145.78,29.94 172.37,29.94 172.96,29.35 172.96,29.02 173.28,28.71 v1(173.4,28.71)
  L14_SIG5 w0.203: v1(173.4,28.71) 172.99,28.3 172.99,27.88 172.59,27.48 171.8,27.48 171.14,28.14 171.14,31.31 170.36,32.09 170.36,34.69 170.8,35.13 174.2,35.13 176.42,32.91 184.04,32.91 184.34,33.21 184.34,33.73 184.8,34.19 185.32,34.19 185.61,34.48 185.61,35 186.13,35.52 186.61,35.52 186.9,35.81 186.9,36.29 187.39,36.78 187.94,36.78 188.15,36.98 188.15,37.54 188.61,38 189.18,38 189.42,38.23 189.42,43.82 189.95,44.35 190.36,44.35 190.69,44.68 190.69,45.16 191.15,45.62 193.04,45.62 194.91,47.49 196.84,47.49 196.97,47.35 198.54,47.35 200.59,49.4 v1(200.59,51.02)
VCCEPLL_EN: length 53.4
  TOP w0.149: v1(42.48,23.08) 41.16,23.08 R6237.1
  L03_SIG1 w0.081: v1(43.7,43.77) 43.25,43.32 43.25,41.18 42.26,40.19 42.26,37.43 42.51,37.19 42.73,37.19 42.96,36.96 42.96,35.77 43.24,35.49 43.24,34.33 41.58,32.67 41.58,31.46 42.76,30.28 42.76,27.02 43.07,26.71 43.37,26.71 43.72,26.37 43.72,24.31 v1(42.48,23.08)
  L12_SIG4 w0.089: v1(43.7,43.77) 43.92,43.54 44.44,43.54 44.67,43.31 45,43.31 45.24,43.54 45.24,43.9 45.5,44.17 57.69,44.17 arc(57.74,44.18) 57.77,44.2 58.39,44.81 arc(58.43,44.85) 58.48,44.88 arc(58.52,44.9) 58.57,44.91 61.34,44.91 arc(61.4,44.9) 61.47,44.89 arc(61.59,44.87) 61.72,44.89 arc(61.78,44.9) 61.84,44.91 62.9,44.91 arc(62.95,44.9) 62.98,44.87 63.32,44.53 v1(63.49,44.53)
  BOTTOM w0.254: v1(63.49,44.53) 64.93,44.53 65.86,45.46 R916.2 R918.1 66.24,47.32 U132.3
VCCEPLL_PG: length 46.4
  TOP w0.149: v1(31.5,32.9) 31.5,34.68 31.68,34.86 31.68,35.39 31.46,35.61 31.46,36.2 31.77,36.51 32.44,36.51 33.24,37.31 35.3,37.31 40.09,42.11 41.2,42.11 42.81,43.71 v1(42.81,43.77)
  L12_SIG4 w0.089: v1(42.81,43.77) 43.54,44.5 44.78,44.5 44.97,44.31 45.3,44.31 45.49,44.5 50.02,44.5 50.62,45.11 57.03,45.11 arc(57.07,45.11) 57.11,45.14 60,48.03 arc(60.03,48.05) 60.08,48.06 65.24,48.06 v1(65.86,48.67)
  BOTTOM w0.254: v1(65.86,48.67) R920.1 66.12,47.82 U132.4
VCCERT_FGT_GXF_EN: length 93.3
  TOP w0.149: R6233.1 42.3,25.56 v1(42.43,25.43)
  TOP w0.254: v1(35.87,104.14) 35.97,104.04 35.97,102.75 36.23,102.5 U68.2
  L03_SIG1 w0.081: v1(35.87,104.14) 37.29,102.72 37.29,92.66 33.7,89.07 33.7,78.11 40.93,70.89 40.93,63.61 39.57,62.25 39.57,55.11 41.19,53.49 41.19,51.45 41.48,51.16 41.48,44.35 40.68,43.55 40.68,42.55 41.1,42.12 41.1,36.43 39.79,35.12 39.79,30.99 40.04,30.74 40.04,26.62 41.23,25.43 v1(42.43,25.43)
  BOTTOM w0.149: R662.2 36.01,104.52 R660.1
VCCERT_FGT_GXF_PG: length 140.3
  TOP w0.254: U68.26 v1(38.77,104.55)
  L07_SIG3 w0.089: v1(26.5,19.9) 26.5,20.8 25.81,21.49 25.38,21.49 25.12,21.75 25.12,21.98 24.57,22.53 24.34,22.53 24.12,22.75 24.12,22.98 23.57,23.53 23.34,23.53 22.95,23.91 22.95,24.18 21.86,25.28 11.07,25.28 10.25,26.1 9.49,26.1 9.26,26.33 9.26,26.66 7.73,28.19 7.73,34.95 4.02,38.66 4.02,57.91 1.51,60.41 1.51,95.02 3.58,97.09 19.21,97.09 21.29,99.17 23.65,99.17 24.39,98.43 34.62,98.43 36.91,100.72 36.91,102.69 v1(38.77,104.55) 40.16,104.55 v1(41.88,102.82)
VCCFUSE_GXR_PG: length 298.2
  TOP w0.149: v1(199.52,65.74) 199.1,66.16 U131.5
  L05_SIG2 w0.081: v1(24.49,19.9) 24.66,19.9 25.25,19.31 29.38,19.31 30.34,20.27 32.42,20.27 33.25,19.45 39.56,19.45 43.26,15.75 45.92,15.75 46.52,15.14 47.04,15.14 47.43,15.53 48.3,15.53 49.57,14.26 49.57,14.09 v1(49.52,14.04)
  L16_SIG6 w0.081: v1(199.52,65.74) 199.71,65.55 201.31,65.55 201.65,65.21 201.97,65.21 204.44,67.68 204.6,67.68 204.81,67.9 204.81,68.45 205.54,69.18 207.14,69.18 207.7,68.62 210.82,68.62 211.18,68.98 215.03,68.98 215.54,69.5 222.16,69.5 222.96,68.7 222.96,67.53 223.12,67.36 223.12,63.11 222.85,62.84 222.85,62.53 223.13,62.25 223.13,52.36 222.81,52.04 222.81,51.6 223.27,51.15 223.27,45.18 222.74,44.66 222.74,44.35 223.09,44.01 223.09,23.57 222.5,22.99 222.5,21.4 223.09,20.82 223.09,15.2 221.74,13.85 216.01,13.85 215.02,14.83 205.16,14.83 204.61,14.29 201.93,14.29 201.36,14.86 196.19,14.86 195.73,15.32 195.73,15.47 195.5,15.7 195.18,15.7 194.62,15.14 189.12,15.14 187.96,13.98 179.09,13.98 178.44,14.64 177.75,14.64 177.09,13.98 140.49,13.98 139.91,13.87 139.85,13.84 138.58,13.84 135.89,11.15 130.84,11.15 126.85,7.16 60.68,7.16 58.43,9.41 56.62,9.41 56.49,9.28 52.41,9.28 49.52,12.17 v1(49.52,14.04)
  BOTTOM w0.149: R6176.2 25.06,19.34 v1(24.49,19.9)
VCCFUSEWR_EN: length 94.2
  L07_SIG3 w0.127: v1(30.06,23.44) 30.06,23.85 29.4,24.51 29.33,24.51 28.93,24.91 28.93,25.67 27.91,26.69 27.91,33.37 28.19,33.65 28.19,34.11 27.9,34.4 27.55,34.4 26.36,35.58 26.36,37.05 25.88,37.53 25.88,44.39 30.07,48.58 30.07,52.13 30.14,52.2 30.14,60.37 40.27,70.49 52,70.49 57.11,75.61 57.11,77.09 61.11,81.09 62.36,81.09 65.27,84.01 65.27,87.97 66.28,88.98 v1(67.59,88.98)
  BOTTOM w0.381: v1(30.06,23.44) 30.1,23.44 30.1,23.39 30.2,23.29 30.24,23.29 30.41,23.11 R6230.2
VCCFUSEWR_GXF:
  vias: v1(104.37,65.86) v1(105.16,65.4) v1(187.15,69) v1(187.15,67.85) v1(188.42,69.91) v1(188.97,69.9)
VCCFUSEWR_GXF_PG: length 349.5
  L12_SIG4 w0.089: v1(192.34,67.06) 192.84,67.56 192.84,70.29 193.68,71.13 204.84,71.13 209.64,66.32 212.96,66.32 216.87,62.41 221.76,62.41 223.85,64.5 230.66,64.5 230.73,64.42 239.7,64.42 244.64,59.49 244.64,53.89 244.94,53.58 244.94,50.88 245.62,50.2 245.62,48.81 244.72,47.92 238.3,47.92 234.8,44.41 234.8,44.3 234.7,44.21 234.7,44.14 234.8,44.05 234.8,43.49 234.7,43.39 234.7,43.1 234.8,43.01 234.8,42.45 234.7,42.35 234.7,42.29 234.8,42.19 234.8,41.63 234.7,41.54 234.7,39.48 234.9,39.28 234.9,38 234.56,37.65 234.56,36.48 235,36.04 235.51,36.04 242.27,29.27 242.27,18.77 241.31,17.8 241.31,15.44 240.76,14.89 228.97,14.89 228.84,14.76 227.48,14.76 225.86,16.38 224.89,16.38 224.42,15.91 221.52,15.91 220.2,17.22 213.86,17.22 211.78,15.14 206.58,15.14 206.36,15.36 196.72,15.36 196.14,15.95 194.99,15.95 194.45,15.4 193.88,15.4 193.18,16.11 187.17,16.11 186.98,15.92 183.72,15.92 183.32,16.31 180.32,16.31 179.85,16.78 175.88,16.78 175.08,15.98 173.52,15.98 173.49,15.95 136.05,15.95 134.17,14.07 128.32,14.07 128.07,14.32 114.6,14.32 113.6,13.32 66.58,13.32 65.5,14.4 65.5,17.26 63.9,18.86 61.49,18.86 59.85,17.22 51.8,17.22 51.39,17.63 47.81,17.63 47.34,18.1 45.08,18.1 44.42,18.76 44.16,18.76 43.84,19.08 43.84,19.45 42.97,20.32 41.43,20.32 40.74,19.63 39.47,19.63 39.36,19.52 34.35,19.52 33.34,20.53 28,20.53 27.62,20.9 v1(27.5,20.9)
  BOTTOM w0.149: R6175.2 26.97,20.38 v1(27.5,20.9)
VCCFUSEWR_PG: length 96.8
  TOP w0.127: v1(23.49,18.9) 23.49,19.18 23.99,19.68 23.99,21.05 24.35,21.4 24.82,21.4 25.02,21.6 25.02,22.11 25.29,22.38 25.8,22.38 26.03,22.62 26.03,23.12 26.28,23.37 26.79,23.37 27,23.58 27,33.76 27.53,34.3 27.89,34.3 28.2,34.6 28.2,35.55 v1(27.87,35.88)
  L07_SIG3 w0.127: v1(27.87,35.88) 27.87,38.05 28.6,38.78 29.24,38.78 29.48,39.02 29.48,39.4 29.93,39.85 30.31,39.85 31.02,40.56 31.02,52.09 38.68,59.76 38.68,62.11 45.89,69.32 51.75,69.32 56.28,73.84 56.28,74.22 60.06,78 60.45,78 68.32,85.87 71.57,85.87 v1(71.99,85.46)
  BOTTOM w0.127: R6223.2 72.64,86.11 v1(71.99,85.46)
VCCFUSEWR_SDM: length 5.9
  TOP w0.381: C7520.2 77.2,91.14 77.98,91.92 81.26,91.92 TP986.1
  vias: v1(71.99,84.19) v1(73.26,85.46) v1(73.26,84.19) v1(74.53,85.46) v1(74.53,84.19) v1(109.13,66.76) v1(109.15,65.83) v4(39.76,74.75) v4(39.76,73.99) v4(81.48,72.83)
VCCH_AGND: length 1.4
  TOP w0.381: v1(52.46,106.31) v1(53.47,106.31)
  BOTTOM w0.203: ST30.2 52.93,106.46 52.91,106.44
  vias: v1(54.48,105.7) v1(58.81,105.43)
VCCH_EN: length 100.4
  TOP w0.149: R6235.1 v1(41.55,24.75)
  TOP w0.254: v1(49.94,104.3) 49.94,102.91 50.3,102.55 U71.2
  L03_SIG1 w0.081: v1(41.55,24.75) 42.28,24.75 42.8,25.27 42.8,25.64 42.12,26.32 42.12,27.33 41.69,27.76 41.69,30.18 41.01,30.86 40.76,30.86 40.54,31.08 40.54,34.24 42.03,35.72 42.03,40.29 42.5,40.77 42.5,41.47 41.94,42.03 41.94,51.35 41.65,51.64 41.65,53.68 42.03,54.06 42.03,58.68 41.73,58.99 41.73,62.15 41.54,62.34 41.54,70.96 39.31,73.18 39.31,80.48 41.83,82.99 42.44,82.99 43.44,83.98 43.44,86.76 43.14,87.06 43.14,89.15 42.35,89.94 42.35,98.77 41.37,99.75 41.37,103.15 43.44,105.23 49.01,105.23 v1(49.94,104.3)
  BOTTOM w0.149: R948.2 v1(49.94,104.3)
  BOTTOM w0.203: R948.2 49.94,104.38 49.94,105.06 50.12,105.23 R946.1
VCCH_FGT_GXF:
  vias: v1(85.94,58.09) v1(86.02,59.78) v1(86.44,58.24) v1(86.89,59.78) v1(86.89,57.11) v1(86.97,58.24) v1(101.18,64.91) v1(101.18,63.99) v1(101.18,63.07) v1(101.18,62.15) v1(101.18,61.23) v1(101.98,64.45) v1(101.97,62.62) v1(101.98,61.69)
VCCH_PG: length 115.3
  TOP w0.149: U71.26 v1(52.84,104.47)
  L03_SIG1 w0.081: v2(26.5,32.9) 26.12,33.28 25.99,33.28 24.72,34.54 24.72,35.62 22.66,37.67 22.66,54.8 21.43,56.04 21.43,64.17 22.36,65.1 22.36,74.91 23.69,76.24 23.69,76.27 26.29,78.87 26.29,80.74 26.22,80.81 26.22,82.61 26.68,83.07 26.68,90.85 27.03,91.2 27.03,100.22 26.79,100.45 26.79,104.46 27.57,105.24 27.57,106.39 28.6,107.42 51.91,107.42 52.85,106.48 52.85,104.48 v1(52.84,104.47)
  BOTTOM w0.149: v1(52.84,104.47) 52.86,104.45 57.03,104.45 57.32,104.16 57.32,102.48 57.19,102.34 56.33,102.34 55.96,102.7 v1(55.96,102.92)
VCCL_HPS_AGND: length 30.6
  TOP w0.381: v1(206.53,41.06) 206.14,40.67 v1(205.68,40.67)
  L07_SIG3 w0.508: v4(200.94,41.48) 200.97,41.45 200.97,38.41 202.27,37.11 205.19,37.11 206.96,38.88 206.96,40.64 v1(206.53,41.06) ; v1(206.53,41.06) 206.08,41.06 v1(205.68,40.67) ; v1(206.53,41.06) 207.27,41.79 207.27,42.87 v1(207.14,42.99) 207.65,43.5 207.65,47.14 206.74,48.05 202.24,48.05 201.7,47.51 v1(201.7,47.44)
  BOTTOM w0.203: ST32.2 200.57,41.48 v4(200.94,41.48)
  BOTTOM w0.381: C1369.2 200.94,40.76 v4(200.94,41.48) ; v1(206.53,41.06) 206.14,40.67 v1(205.68,40.67)
VCCL_HPS_EN: length 251.9
  TOP w0.127: R6236.1 41.12,21.54 41.42,21.24 v1(42.25,21.24)
  L07_SIG3 w0.127: v1(211.32,45) 213.6,45 214.39,45.79 220.49,45.79 221.74,44.54 223.08,44.54 v1(223.12,44.5)
  L14_SIG5 w0.127: v1(42.25,21.24) 42.55,20.93 43.98,20.93 44.24,21.19 46.7,21.19 47.94,22.43 50.18,22.43 50.75,23 51.12,23 51.38,22.74 51.38,21.98 51.83,21.53 52.01,21.53 56.06,17.48 59.31,17.48 61.99,14.79 61.99,13.92 62.23,13.68 62.5,13.68 68.71,7.46 118.77,7.46 121.17,9.86 121.17,11.12 121.7,11.65 124.42,11.65 124.42,11.64 124.85,11.64 125.05,11.84 130.49,11.84 130.68,11.65 132,11.65 132.65,12.3 134.43,12.3 135.26,11.47 138.04,11.47 v1(138.19,11.62) ; v1(202.5,45.04) 203.68,46.22 203.68,47.83 204.04,48.19 208.87,48.19 211.32,45.74 v1(211.32,45)
  L16_SIG6 w0.127: v1(138.19,11.62) 138.19,12.63 138.87,13.31 139.96,13.31 140.07,13.35 140.54,13.45 205.7,13.45 206.83,14.58 214.89,14.58 215.89,13.57 221.82,13.57 221.84,13.59 221.84,13.59 223.34,15.09 223.34,44.28 v1(223.12,44.5)
VCCL_HPS_PG: length 234
  L03_SIG1 w0.127: v1(212.44,39.42) 210.38,41.48 208.49,41.48 207.93,42.04 203.54,42.04 203.43,42.15 201.59,42.15 201.28,42.46 201.28,43.09 201.43,43.24 201.43,43.59 201.28,43.74 201.28,44.62 v1(202.5,45.84)
  L07_SIG3 w0.127: v1(28.5,21.9) 28.9,21.5 29.65,21.5 29.89,21.74 29.89,21.85 30.33,22.3 37.03,22.3 37.25,22.51 37.66,22.51 37.77,22.62 39.59,22.62 39.82,22.39 39.82,22.06 39.79,22.03 39.79,21.3 40.08,21.01 40.08,14.45 40.84,13.69 44.47,13.69 45.36,12.8 46.23,12.8 47.42,11.62 48.2,11.62 48.84,10.97 49.86,10.97 49.87,10.98 50.22,10.98 50.22,10.98 55.8,10.98 56.21,10.57 57.57,10.57 61.25,6.89 126.65,6.89 127.83,8.07 127.87,8.07 128.77,8.96 128.78,8.97 128.84,9.04 128.85,9.05 128.88,9.09 129.26,9.47 129.27,9.47 131.18,11.37 131.5,11.37 134.12,14 137.12,14 137.44,13.69 138.05,13.69 174.07,13.69 174.96,14.57 174.96,18.67 177.18,20.89 192.39,20.89 194.23,22.73 195.64,22.73 198.49,25.59 204.92,25.59 206.64,27.31 209.24,27.31 212.01,30.08 212.01,32.13 213.01,33.13 213.01,38.85 v1(212.44,39.42)
VCCL_HPS_SNS_N: length 97.7
  TOP w0.254: v1(126.25,36.21) 126.69,36.69 126.69,36.79 127.13,37.23 131.52,37.23 135.59,33.16 146.14,33.16 147.8,31.5 156.74,31.5 157.58,32.33 161.8,32.33 162.42,32.95 v1(162.42,33.05)
  L14_SIG5 w0.203: v1(203.3,43.44) 202.97,43.11 201.35,43.11 201.2,42.96 201.2,42.96 v1(200.83,42.6) 200.04,41.8 191.05,41.8 190.66,41.41 190.66,35.76 190.39,35.49 189.91,35.49 189.39,34.97 189.39,34.49 189.09,34.19 188.61,34.19 188.12,33.7 188.12,33.22 187.85,32.95 186.15,32.95 184.75,31.55 179.34,31.55 178.95,31.94 174.24,31.94 173.39,31.09 173.39,29.3 173.82,28.88 173.82,27.31 173.61,27.11 171.29,27.11 170.67,27.74 170.67,29.18 169.15,30.7 166.34,30.7 164.77,32.27 164.35,32.27 163.57,33.05 v1(162.42,33.05)
VCCL_HPS_SNS_P: length 95.7
  TOP w0.254: v1(127.13,36.25) 127.07,36.32 127.07,36.63 127.29,36.85 131.36,36.85 135.43,32.77 145.98,32.77 147.64,31.12 156.9,31.12 157.73,31.95 161.93,31.95 162.42,31.47 v1(162.42,31.37)
  L14_SIG5 w0.203: v1(202.5,42.64) 202,42.14 200.84,42.14 200.17,41.47 191.19,41.47 190.99,41.27 190.99,35.62 190.53,35.16 190.04,35.16 189.72,34.83 189.72,34.35 189.23,33.86 188.74,33.86 188.45,33.56 188.45,33.08 187.99,32.62 186.29,32.62 184.89,31.22 179.2,31.22 178.81,31.61 174.37,31.61 173.72,30.95 173.72,29.44 174.15,29.02 174.15,27.18 173.75,26.78 171.16,26.78 170.34,27.6 170.34,29.04 169.01,30.37 166.21,30.37 164.63,31.94 164.35,31.94 163.78,31.37 v1(162.42,31.37)
VCCLSENSE: length 30.8
  BOTTOM w0.203: R220.1 128.12,81.91 128.12,81.06 128.4,80.77 128.4,79.68 127.64,78.92 127.64,78.73 127.96,78.41 127.96,78.11 127.83,77.97 127.83,77.61 127.96,77.47 127.96,77.17 127.84,77.05 127.84,76.69 127.96,76.57 127.96,76.25 127.84,76.13 127.84,75.77 127.96,75.65 127.96,75.33 127.84,75.21 127.84,74.85 127.96,74.73 127.96,74.41 127.84,74.29 127.84,73.93 127.96,73.81 127.96,73.51 127.83,73.37 127.83,73 127.96,72.87 127.96,72.57 127.84,72.45 127.84,72.09 127.96,71.97 127.96,71.65 127.71,71.39 127.71,71.29 127.92,71.07 127.92,70.82 arc(127.9,70.72) 127.84,70.63 arc(127.79,70.54) 127.77,70.43 arc(127.79,70.32) 127.85,70.23 arc(127.96,69.97) 127.85,69.71 127.71,69.57 127.71,69.45 127.92,69.23 127.96,69.19 127.96,69.01 arc(127.95,68.91) 127.89,68.83 arc(127.85,68.76) 127.83,68.69 127.83,68.49 arc(127.85,68.41) 127.89,68.34 127.96,68.27 127.96,67.99 127.83,67.85 127.83,67.48 127.96,67.35 127.96,67.07 127.83,66.93 127.83,66.56 127.96,66.43 127.96,66.15 127.83,66.01 127.83,65.64 127.96,65.51 127.96,65.23 127.83,65.09 127.83,64.72 127.96,64.59 127.96,64.31 127.83,64.17 127.83,63.8 127.96,63.67 127.96,63.39 127.83,63.25 127.83,62.88 127.96,62.75 127.96,62.47 127.83,62.33 127.83,61.96 127.96,61.83 127.96,61.61 127.81,61.35 127.69,61.23 127.31,61.23 127.03,60.95 127.03,60.58 127.12,60.49 127.12,60.16 127.01,59.96 126.81,59.84 126.58,59.84 126.41,59.76 126.13,59.44 126.01,59.39 125.75,59.39 125.55,59.27 125.43,59.06 125.23,58.94 124.96,58.94 124.74,59.07 124.61,59.29 124.44,59.39 124.14,59.39 123.97,59.29 123.82,59.03 123.64,58.93 v1(122.7,58.93)
VCCPLLDIG_HPS:
  vias: v1(122.7,48.81) v1(123.49,48.35) v1(144.4,46.1) v1(148.72,46.31)
VCCPLLDIG_SDM:
  vias: v1(79.97,70.69) v1(80.5,70.69) v1(81.03,70.69) v1(87.04,67.14) v1(87.04,66.14) v1(108.35,69.05) v1(108.35,68.13)
VCCR_CORE: length 96.7
  L03_SIG1 w0.203: v1(192.64,77.04) 192.02,77.04 arc(192.01,77.03) 192,77.02 arc(192,77.01) 191.99,77 190.76,75.76 arc(190.75,75.76) 190.74,75.76 188.38,75.76 arc(188.37,75.75) 188.36,75.75 187.21,74.6 arc(187.2,74.59) 187.18,74.59 176.85,74.59 arc(176.83,74.59) 176.82,74.6 176.06,75.36 175.07,75.36 173.16,73.45 173.16,67.77 172.38,66.99 169.12,66.99 167.87,65.74 166.34,65.74 165.75,65.15 arc(165.67,65.1) 165.57,65.08 164.78,65.08 arc(164.68,65.06) 164.6,65 164.14,64.54 arc(164.05,64.49) 163.95,64.47 152.49,64.47 arc(152.39,64.48) 152.3,64.54 arc(152.1,64.72) 151.91,64.9 arc(151.77,65.02) 151.61,65.1 arc(151.51,65.13) 151.41,65.13 arc(151.34,65.14) 151.28,65.14 arc(151.18,65.15) 151.08,65.16 145.27,65.16 144.29,64.17 143.14,64.17 142.83,64.49 142.25,64.49 141.96,64.2 141.42,64.2 141.11,64.52 140.55,64.52 140.23,64.2 139.65,64.2 139.36,64.49 138.83,64.49 138.51,64.17 137.95,64.17 137.63,64.49 137.26,64.49 136.76,64.99 136.4,64.99 135.9,65.49 135.57,65.49 134.89,66.18 134.68,66.18 134.15,66.7 133.85,66.7 arc(133.84,66.71) 133.83,66.71 133.37,67.17 arc(133.36,67.18) 133.35,67.18 132.96,67.18 arc(132.95,67.18) 132.94,67.19 132.5,67.63 arc(132.48,67.64) 132.47,67.64 132.11,67.64 arc(132.1,67.64) 132.09,67.65 131.63,68.11 arc(131.62,68.12) 131.6,68.12 131.31,68.12 arc(131.3,68.12) 131.29,68.11 130.87,67.7 arc(130.86,67.69) 130.85,67.69 130.42,67.69 arc(130.41,67.69) 130.4,67.7 130.04,68.05 arc(130.03,68.06) 130.02,68.06 129.72,68.06 arc(129.71,68.06) 129.7,68.05 129.34,67.7 arc(129.33,67.69) 129.32,67.69 128.87,67.69 128.45,68.1 128.09,68.1 127.68,67.69 127.27,67.69 126.86,68.1 126.5,68.1 126.09,67.69 125.63,67.69 125.25,68.06 124.92,68.06 124.55,67.69 124.03,67.69 123.66,68.06 123.33,68.06 122.95,67.69 122.49,67.69 122.08,68.1 121.73,68.1 121.71,68.09 121.61,67.99 arc(121.59,67.97) 121.58,67.96 121.31,67.69 arc(121.3,67.68) 121.28,67.68 121.23,67.68 arc(121.2,67.67) 121.17,67.67 arc(121.09,67.67) 121.01,67.68 121,67.68 arc(120.83,67.76) 120.71,67.92 arc(120.67,67.99) 120.62,68.05 120.56,68.07 120.52,68.07 arc(120.46,68.08) 120.41,68.09 arc(120.13,68.06) 119.92,67.87 arc(119.89,67.82) 119.85,67.77 119.75,67.67 arc(119.74,67.66) 119.73,67.66 119.34,67.66 arc(119.33,67.66) 119.32,67.67 118.89,68.1 118.53,68.1 118.12,67.69 117.71,67.69 117.3,68.1 116.94,68.1 116.52,67.69 116.15,67.69 115.7,67.24 115.35,67.24 114.91,66.8 114.49,66.8 114.05,67.24 113.75,67.24 113.14,67.85 v1(113.14,68.11)
  BOTTOM w0.381: R5835.1 192.66,77.06 C1167.1
  vias: v1(110.74,51.11) v1(111.54,50.65) v1(111.54,49.73) v1(113.12,69.03) v1(121.1,50.65) v1(121.1,49.73) v1(122.7,69.03) v1(122.7,68.13) v1(124.29,68.13) v1(184.38,87.72) v1(184.38,86.45) v1(184.38,85.18) v1(184.38,83.91) v1(184.38,77.56) v1(184.38,76.29) v1(184.38,75.02) v1(184.38,73.75) v4(140.22,87.2) v4(140.22,86.18) v4(140.22,85.17) v4(141.23,87.2) v4(141.23,86.18) v4(141.23,85.17) v4(142.25,87.2) v4(142.25,86.18) v4(142.25,85.17) v4(176.69,78.49) v4(176.69,77.47) v4(176.69,76.46) v4(176.69,75.44) v4(177.71,79.5) v4(177.71,78.49) v4(177.71,77.47) v4(177.71,76.46) v4(177.71,75.44) v4(178.72,79.5) v4(178.72,78.49) v4(178.72,77.47) v4(178.72,76.46) v4(178.72,75.44) v4(179.81,77.42) v4(179.81,76.41) v4(179.81,75.39) v4(180.83,77.42) v4(180.83,76.41) v4(180.83,75.39) v4(181.85,77.42) v4(181.85,76.41) v4(181.85,75.39) v7(175.67,87.25) v7(175.67,86.34) v7(175.67,85.35) v7(176.56,87.3) v7(176.56,86.34) v7(176.56,85.37) v7(177.53,87.3) v7(177.53,86.34) v7(177.53,85.37) v7(178.49,87.3) v7(178.49,86.34) v7(178.49,85.37) v7(179.46,87.3) v7(179.46,86.34) v7(179.46,85.37) v7(180.42,87.3) v7(180.42,86.34) v7(180.42,85.37) v7(181.39,87.3) v7(181.39,86.34) v7(181.39,85.37) v7(182.35,87.3) v7(182.35,86.34) v7(182.35,85.37) v7(183.32,87.3) v7(183.32,86.34) v7(183.32,85.37)
VCCR_CORE_AGND: length 1.7
  BOTTOM w0.191: ST6.1 190.42,81.06 v1(190.73,81.37)
  BOTTOM w0.254: v1(190.73,80.1) 190.83,80.2 R6156.1 ; R5853.1 189.14,81.06 v1(189.46,81.37)
  vias: v1(186.28,80.75) v1(186.29,79.46) v1(188.82,76.92) v1(189.46,80.1)
VCCR_CORE_EN: length 273.9
  L03_SIG1 w0.081: v1(178.91,104.97) 178.87,105.01 178.77,105.01 178.37,105.41 178.37,108.89 177.87,109.39 66.08,109.39 59.94,103.25 56.19,103.25 56.13,103.32 55.57,103.32 54.2,101.95 54.2,101.67 53.84,101.31 51.97,101.31 50.31,102.97 50.31,104.46 49.24,105.52 43.31,105.52 41.12,103.34 41.12,88.09 41.68,87.52 42.35,87.52 43.2,86.66 43.2,84.08 42.35,83.22 41.73,83.22 39.08,80.57 39.08,73.06 40.88,71.27 40.88,71.26 41.16,70.98 41.16,63.31 40.66,62.82 40.66,60.45 40.21,60 40.21,54.8 41.42,53.59 41.42,51.55 41.71,51.26 41.71,36.54 40.15,34.98 40.15,31.2 v1(40.91,30.43)
  L16_SIG6 w0.081: v1(187.47,82.18) 186.82,82.18 185.3,83.7 185.3,89.73 187.39,91.81 187.39,99.01 188.47,100.1 188.47,101.1 189.26,101.89 192.44,101.89 194.22,103.67 194.22,105.43 193.71,105.94 184.79,105.94 183.88,105.03 180.14,105.03 180.03,104.92 178.96,104.92 v1(178.91,104.97)
VCCR_CORE_PG: length 407.5
  L07_SIG3 w0.089: v1(25.5,18.9) 25.87,19.28 26.7,19.28 27.12,19.7 27.12,22.06 27.59,22.53 29.94,22.53 30.23,22.82 30.81,22.82 31.3,23.3 37.07,23.3 37.25,23.49 39.47,23.49 40.75,22.21 40.75,22.2 40.87,22.08 40.87,20.86 41.16,20.57 41.16,19.97 40.58,19.39 40.58,17.27 42.25,15.6 44.2,15.6 47.67,12.13 51.31,12.13 52.24,13.05 53.89,13.05 54.39,13.56 55.78,13.56 59.3,10.05 59.86,10.05 61.3,8.6 61.82,8.6 62.77,7.65 126.7,7.65 127.62,8.57 127.66,8.57 128.46,9.37 128.49,9.41 129.05,9.97 129.07,9.97 130.99,11.89 131.31,11.89 133.92,14.5 137.33,14.5 137.64,14.19 137.84,14.19 173.76,14.19 174.44,14.87 174.44,18.86 177.26,21.68 177.8,21.68 179.92,23.79 179.92,23.82 180.35,24.25 180.35,24.27 180.74,24.67 180.74,25.26 181.71,26.23 204.85,26.23 206.67,28.05 208.31,28.05 210.16,29.91 210.16,33.03 208.01,35.19 208.01,35.99 208.97,36.95 210.03,36.95 211.52,38.45 211.52,39.81 213.2,41.49 222.65,41.49 223.99,42.83 223.99,45.26 226.52,47.8 242.15,47.8 245.31,50.96 245.69,50.96 245.93,51.19 245.93,51.68 247.66,53.41 247.66,66.62 249.82,68.77 249.82,98.21 242.67,105.35 235.9,105.35 234.28,106.97 227.99,106.97 227.41,107.55 197.41,107.55 194.89,105.04 194.89,103.91 194.08,103.1 193.29,103.1 192.96,102.77 191.48,102.77 191.39,102.68 188.56,102.68 187.77,103.47 186.68,103.47 184.34,101.13 184.34,95.87 183.49,95.02 183.49,93.18 183.87,92.8 183.87,81.17 v1(183.67,80.98)
VCCRT_GXR_EN: length 216.8
  TOP w0.254: v1(207.68,38.5) 207.36,38.18 206.64,38.18 206.11,37.65 U69.2
  L05_SIG2 w0.081: v1(213.18,15.29) 206.35,15.29 205.12,14.06 201.78,14.06 201.15,14.69 195.35,14.69 195.16,14.88 187.11,14.88 186.38,14.15 182.47,14.15 179.62,17.01 172.09,17.01 169.52,14.43 130.87,14.43 130.51,14.79 117.72,14.79 114.77,11.85 74.25,11.85 74.03,12.07 62.37,12.07 62,11.7 58.57,11.7 57.48,12.79 56.79,12.79 53.96,15.62 48.61,15.62 48.47,15.77 47.34,15.77 46.95,15.38 46.62,15.38 46.02,15.98 44.52,15.98 43.43,17.07 42.95,17.07 41.19,18.82 41.19,21.06 v1(41.96,21.83)
  L14_SIG5 w0.081: v1(213.18,15.29) 213.18,15.45 213.37,15.64 213.37,17.1 214.17,17.9 214.17,26.08 213.48,26.77 v1(213.48,38.5)
  BOTTOM w0.149: v1(213.48,38.5) 213.23,38.74 210.29,38.74 210.05,38.5 R671.1 R672.2 v1(207.68,38.5) ; R6234.1 41.23,21.83 41.96,21.83 41.96,21.83 v1(41.96,21.83)
VCCRT_GXR_PG: length 216.7
  TOP w0.149: v1(208.44,35.72) 208.23,35.51 U69.26
  L07_SIG3 w0.089: v1(208.44,35.72) 210.41,33.75 210.41,29.8 208.32,27.72 206.68,27.72 204.83,25.87 191.93,25.87 191.73,25.67 191.73,24.93 191.27,24.46 181.09,24.46 178.06,21.44 177.36,21.44 174.68,18.76 174.68,14.66 173.97,13.95 137.54,13.95 137.23,14.26 134.01,14.26 131.39,11.64 131.07,11.64 129.17,9.73 129.15,9.73 128.68,9.26 128.65,9.21 127.76,8.33 127.72,8.33 126.65,7.26 61.6,7.26 61.05,7.81 61.05,8.46 59.81,9.7 58.81,9.7 57.68,10.83 56.81,10.83 55.76,11.88 53.49,11.88 53.35,11.74 53.02,11.74 52.88,11.88 47.58,11.88 46.37,13.09 45.49,13.09 44.67,13.91 44.67,14.79 44.1,15.36 42.15,15.36 40.34,17.17 40.34,19.54 40.92,20.12 40.92,20.47 40.63,20.76 40.63,21.98 40.5,22.1 40.5,22.11 39.34,23.28 37.34,23.28 36.59,22.53 30.25,22.53 30.24,22.53 30.24,22.53 29.99,22.28 28.34,22.28 27.87,21.81 27.87,20.28 v1(27.5,19.9)
VDD33_OUT1: length 1.8
  TOP w0.254: v1(229.7,42.34) 229.71,42.33 v1(230.23,42.33) v1(230.78,42.33) 230.93,42.48 U137.20
  vias: v1(234.14,38.19) v1(236.15,38.17) v1(236.71,40.53)
0P6V_VREF_DDR4_CH01: length 161.8
  TOP w0.381: C983.1 v1(45.43,25.43)
  TOP w0.508: 77.78,16.07 77.78,16.63 78.53,17.39 78.53,19.63 79.04,20.14 v1(79.18,20.14) ; 77.78,16.07 77.78,16.03 ; 77.78,16.07 77.31,15.6 ; 108.5,15.9 108.8,15.6 ; 108.5,15.9 108.5,19.57 109.07,20.14 v1(109.66,20.14) ; 108.5,15.9 108.5,15.6 ; 108.5,15.9 108.49,15.9 108.19,15.6 ; 108.8,15.6 108.5,15.6 ; 108.8,15.6 TP990.1 121.15,15.6 ; v1(99.5,20.14) 98.89,20.14 98.38,19.63 98.38,15.95 ; 87.91,16.04 87.91,16 ; 87.91,16.04 88.35,15.6 ; 87.91,16.04 87.91,19.63 88.42,20.14 v1(89.34,20.14) ; 87.91,16 87.51,15.6 ; 87.91,16 87.91,15.6 ; 77.78,16.03 77.81,16.03 78.24,15.6 ; 77.78,16.03 77.78,15.6 ; 98.36,15.6 98.73,15.6 ; 98.36,15.6 98.03,15.6 ; 98.36,15.6 98.38,15.61 98.38,15.95 ; 98.73,15.6 98.38,15.95 ; 98.73,15.6 108.19,15.6 ; 108.5,15.6 108.19,15.6 ; 98.38,15.95 98.38,15.95 ; 98.38,15.95 98.03,15.6 ; 77.31,15.6 71.8,15.6 71.57,15.37 v1(67.55,15.37) v1(66.86,15.37) 66.4,15.83 66.38,15.83 65.87,16.33 65.87,18.49 66.63,19.26 67.24,19.26 68.12,20.13 v1(68.99,20.13) ; 77.31,15.6 77.78,15.6 ; 121.46,15.6 121.15,15.6 ; 121.46,15.6 121.46,15.9 ; 121.46,15.6 121.81,15.6 ; 121.15,15.6 121.46,15.9 ; 88.35,15.6 98.03,15.6 ; 88.35,15.6 87.91,15.6 ; 151.92,15.6 142.17,15.6 ; 151.92,15.6 152.23,15.9 ; 151.92,15.6 152.53,15.6 ; 142.17,15.6 141.86,15.6 ; 142.17,15.6 141.86,15.91 ; 78.24,15.6 77.78,15.6 ; 78.24,15.6 87.51,15.6 ; v1(153.35,20.1) 152.74,20.1 152.23,19.59 152.23,15.9 ; v1(122.87,20.06) 122.86,20.07 122.11,20.07 121.46,19.42 121.46,15.95 ; 121.46,15.95 121.46,15.9 ; 121.46,15.95 121.81,15.6 ; v1(163.51,20.06) 162,20.06 161.27,19.33 161.27,16.11 160.76,15.6 152.53,15.6 ; 141.55,15.6 141.86,15.91 141.86,15.91 ; 141.55,15.6 141.86,15.6 ; 141.55,15.6 v1(131.97,15.6) ; 141.86,15.6 141.86,15.91 ; 141.86,15.91 141.86,19.55 142.37,20.06 v1(143.19,20.06) ; 87.51,15.6 87.91,15.6 ; v1(133.03,20.06) 132.48,20.06 131.97,19.55 v1(131.97,15.6) ; 152.53,15.6 152.23,15.9 ; v1(131.97,15.6) v1(131.07,15.6) 121.81,15.6
  BOTTOM w0.381: C93.1 68.99,20.13 v1(68.99,20.13) ; v1(79.18,20.14) 79.15,20.11 C47.1 ; v1(45.45,26.02) 45.43,26 v1(45.43,25.43) ; v1(163.51,20.06) 163.5,20.06 C191.1
  vias: v1(110.74,47.43) v1(112.34,47.43) v1(119.02,28.09) v1(120.31,47.43) v1(121.9,47.43)
0P6V_VREF_DDR4_CH2: length 4.8
  TOP w0.279: 26.91,107.8 26.7,107.59 U85.6
  TOP w0.381: v3(118.97,85.21) C7436.1 ; v1(194.88,101.45) v1(194.88,100.56)
  TOP w0.508: C997.1 v4(29.03,107.89) v4(27.98,107.89) 26.99,107.89 26.91,107.8
  vias: v1(120.31,71.35) v1(121.9,71.35) v3(89.87,91.64) v3(89.87,90.84) v3(132.25,86.14) v3(132.25,85.14)
0P6V_VREF_DDR4_CH3: length 16.4
  TOP w0.381: C424.1 v3(116.46,85.22)
  L03_SIG1 w0.508: v1(194.94,93.41) 194.34,92.8 193.02,92.8 arc(192.83,92.76) 192.66,92.65 192.03,92.02 192.03,89.83 190.54,88.35 v1(186.68,88.35)
  L12_SIG4 w0.254: v1(112.34,71.35) v1(110.74,71.35)
  BOTTOM w0.254: 186.7,90.7 U108.6
  BOTTOM w0.381: 186.7,90.7 v1(186.7,89.44) C7433.1
  vias: v1(194.98,94.24)
0P6V_VTT_DDR4_CH01: length 10.6
  TOP w0.191: v1(41.54,26.82) 41.54,26.82 41.85,27.13 U84.3 ; U84.5 v1(41.61,26.13)
  TOP w0.381: v1(77.87,21) 77.87,20.58 77.13,19.84 77.13,18.73 v1(77.92,17.93)
  BOTTOM w0.203: 173.16,15.34 172.78,15.34 C195.2
  BOTTOM w0.305: 173.16,15.34 173.16,15.93 173.46,16.23 173.46,17.99 173.12,18.34 R897.1
  BOTTOM w0.381: v1(66.4,21.47) 66.42,21.48 66.62,21.48 66.92,21.78 R882.1
  vias: v1(65.66,21.52) v1(65.79,22.61) v1(65.8,22.11) v1(66.4,22) v1(66.46,22.61) v1(66.86,14) v1(163.45,14.8) v1(165.13,14.8) v1(167.02,14.91) v1(167.68,14.91) v1(170.9,14.94) v1(172.7,14.94)
0P6V_VTT_DDR4_CH2: length 0.9
  TOP w0.254: U85.3 25.7,103.52 25.9,103.31
  vias: v1(27.51,102.42) v1(28.9,102.43) v1(29,103.73) v1(30.53,103.73) v1(53.41,109.03) v1(53.53,108.13) v1(131.19,106.89) v1(131.19,105.62) v1(132.09,103.96) v3(131.18,102.31)
0P6V_VTT_DDR4_CH3: length 3.5
  TOP w0.381: v1(198.61,93.47) 198.98,93.11 C7428.1
  BOTTOM w0.254: U108.3 v1(190.61,91.8)
  BOTTOM w0.381: C224.1 v3(131.19,93.42) C226.1
  vias: v1(131.19,98) v1(191.37,91.8) v1(193.21,92.08) v1(194.64,92.08) v1(196.08,92.08) v1(197.51,92.08) v3(129.52,96.88) v3(131.19,99.27) v3(131.24,96.34) v3(131.19,94.69) v3(137.92,92.43) v3(138.58,92.44) v3(139.22,92.45)
0P8V_VCC_HSSI_GXF: length 42.9
  L12_SIG4 w0.229: v1(79.49,74.64) 80.2,73.93 83.58,73.93 86.57,70.95 87.67,70.95 87.86,71.14 89.92,71.14 90.37,71.59 90.89,71.59 91.29,71.19 91.68,71.19 92.14,70.73 92.58,70.73 92.99,71.14 95.05,71.14 95.53,71.62 96.07,71.62 96.45,71.23 96.98,71.23 97.3,71.55 97.84,71.55 98.25,71.14 99.17,71.14 99.37,70.94 99.86,70.94 100.22,71.3 100.55,71.3 100.96,70.89 101.35,70.89 101.86,71.4 102.15,71.4 102.68,70.87 102.92,70.87 103.37,70.43 103.78,70.43 104.03,70.18 104.03,69.8 103.92,69.69 103.92,69.32 104.18,69.06 104.56,69.06 105,68.63 105.36,68.63 105.86,69.13 106.19,69.13 106.58,69.52 106.91,69.52 107.2,69.23 107.24,69.15 107.41,69.04 107.68,69.04 108.14,68.58 108.56,68.58 109.03,69.05 v1(109.95,69.05)
  BOTTOM w0.203: R5925.1 73.93,73.97 78.81,73.97 v1(79.49,74.64)
  vias: v1(63.68,65.55) v1(64.95,65.55) v1(66.22,65.55) v1(67.49,65.55) v1(73.84,65.55) v1(75.11,65.55) v1(76.38,65.55) v1(77.65,65.55) v1(80.6,64.76) v1(82.89,69.01) v1(83.77,67.71) v1(83.89,53.14) v1(84.02,56.14) v1(84.79,69.01) v1(105.96,64.95) v1(105.96,63.99) v1(105.96,63.07) v1(105.96,62.15) v1(105.96,59.39) v1(105.96,57.55) v1(106.76,63.53) v1(106.76,62.61) v1(106.76,61.69) v1(106.76,59.85) v1(106.76,58.93) v1(106.76,58.01) v1(107.55,64.92) v1(107.56,63.97) v1(107.56,62.15) v1(107.56,61.23) v1(107.56,60.31) v1(107.56,59.39) v1(109.93,68.14) v1(111.54,68.13) v1(111.56,69.02)
0P8V_VCCH: length 42.2
  BOTTOM w0.203: R952.1 112.07,83.2 111.58,82.71 111.01,82.71 109.5,81.19 109.5,80.83 109.55,80.78 109.57,80.75 arc(109.61,80.53) 109.55,80.32 109.55,80.31 arc(109.49,80.09) 109.55,79.86 arc(109.61,79.63) 109.55,79.4 109.55,79.4 arc(109.49,79.17) 109.55,78.94 arc(109.61,78.71) 109.55,78.48 109.55,78.48 arc(109.49,78.25) 109.55,78.02 arc(109.61,77.79) 109.55,77.56 109.55,77.56 arc(109.49,77.33) 109.55,77.1 arc(109.61,76.88) 109.56,76.67 109.55,76.64 arc(109.49,76.41) 109.55,76.18 arc(109.71,76.02) 109.92,75.95 109.95,75.95 arc(110.17,75.89) 110.33,75.74 110.36,75.7 arc(110.52,75.54) 110.74,75.49 arc(110.97,75.43) 111.14,75.27 111.15,75.25 arc(111.31,75.09) 111.54,75.03 111.55,75.03 arc(111.77,74.97) 111.94,74.8 arc(112.1,74.63) 112.33,74.57 112.36,74.57 arc(112.58,74.5) 112.74,74.34 arc(112.89,74.18) 113.11,74.11 113.14,74.11 arc(113.37,74.05) 113.53,73.88 113.54,73.87 arc(113.7,73.71) 113.93,73.65 113.94,73.65 arc(114.16,73.59) 114.33,73.42 arc(114.73,73.19) 115.12,73.42 115.13,73.42 arc(115.52,73.65) 115.92,73.42 arc(116.09,73.25) 116.32,73.19 116.32,73.19 arc(116.55,73.25) 116.72,73.42 arc(117.12,73.65) 117.52,73.42 arc(117.91,73.19) 118.31,73.42 118.31,73.42 arc(118.48,73.59) 118.71,73.65 118.71,73.65 arc(118.94,73.71) 119.11,73.88 119.11,73.88 arc(119.28,74.05) 119.5,74.11 119.51,74.11 arc(119.74,74.05) 119.91,73.88 119.91,73.87 arc(120.31,73.65) 120.7,73.88 120.7,73.88 arc(120.87,74.05) 121.1,74.11 121.11,74.11 arc(121.33,74.05) 121.5,73.88 121.5,73.87 arc(121.9,73.65) 122.3,73.88 122.3,73.88 arc(122.47,74.05) 122.7,74.11 122.7,74.11 arc(122.93,74.05) 123.09,73.88 123.1,73.87 arc(123.27,73.71) 123.49,73.65 123.5,73.65 arc(123.73,73.59) 123.89,73.42 123.9,73.41 arc(123.95,73.18) 123.89,72.96 123.89,72.95 arc(123.89,72.5) 124.28,72.27 124.29,72.27 arc(124.51,72.21) 124.68,72.05 124.69,72.03 arc(124.86,71.87) 125.09,71.81 125.11,71.78 125.27,71.78 125.52,71.53 125.52,71.17 125.4,71.06 125.4,69.82 125.53,69.69 125.53,69.32 125.27,69.06 125.25,69.06 125.22,69.05 124.95,69.05 124.75,68.93 124.62,68.7 124.42,68.59 124.16,68.59 123.96,68.47 123.82,68.24 123.63,68.13 123.36,68.13 123.16,68.01 123.03,67.79 122.82,67.67 122.56,67.67 122.36,67.55 122.23,67.32 122.03,67.21 121.77,67.21 121.57,67.09 121.43,66.86 121.24,66.75 120.97,66.75 120.77,66.63 120.64,66.4 120.44,66.29 120.17,66.29 119.97,66.17 119.84,65.94 119.64,65.83 119.37,65.83 119.18,65.71 119.04,65.48 118.85,65.37 118.83,65.36 118.58,65.36 118.44,65.3 118.34,65.2 118.27,65.02 118.27,64.64 v1(117.97,64.34)
  BOTTOM w0.381: C1175.2 125.2,64.11 v1(125.09,63.99) ; C1168.2 v1(125.09,54.79)
  vias: v1(80.91,67.39) v1(82.56,61.39) v1(83.89,47.14) v1(83.89,46.26) v1(83.89,42.95) v1(84.02,64.14) v1(83.97,63.14) v1(84.02,55.14) v1(86.85,55.14) v1(86.89,52.01) v1(94.72,36.71) v1(96.82,36.64) v1(105.18,36.67) v1(107.56,57.55) v1(107.56,55.71) v1(107.56,53.87) v1(107.56,52.03) v1(108.35,65.37) v1(108.35,63.53) v1(108.35,61.69) v1(108.35,59.85) v1(109.95,36.67) v1(110.74,67.67) v1(125.09,65.83) v1(125.09,62.15) v1(125.09,60.31) v1(125.09,58.47) v1(125.09,56.63) v1(125.09,52.95) v4(47.51,93.93) v4(47.51,92.59) v4(48.78,93.93) v4(48.78,92.59) v4(50.05,93.93) v4(50.05,92.59) v4(51.32,93.93) v4(51.32,92.59) v4(52.59,93.93) v4(52.59,92.59) v4(53.86,93.93) v4(53.86,92.59) v4(55.13,93.93) v4(55.13,92.59) v4(56.4,93.93) v4(56.4,92.59) v4(57.67,93.93) v4(57.67,92.59)
0P9V_VCC_HSSI_GXR: length 79.2
  L05_SIG2 w0.203: v1(175.31,46.77) 174.75,47.34 173.94,47.34 172.19,45.59 171.51,45.59 158.42,32.5 140.21,32.5 137.83,34.88 137.39,34.88 137.12,35.15 137.12,35.29 135.88,36.52 135.88,37.94 135.62,38.2 135.31,38.2 134.85,38.66 134.44,38.66 134.01,39.08 133.73,39.08 133.23,39.58 132.9,39.58 132.44,40.04 132.1,40.04 131.64,40.5 131.3,40.5 130.84,40.96 130.48,40.96 130.02,40.5 129.71,40.5 129.25,40.96 128.89,40.96 128.64,41.21 128.64,41.66 128.7,41.73 128.7,42.09 128.45,42.34 128.12,42.34 127.56,42.89 127.26,42.89 127.05,43.09 127.05,43.51 127.11,43.57 127.11,43.93 126.8,44.23 126.5,44.23 126.04,44.7 125.7,44.7 125.21,45.19 124.83,45.19 124.41,45.62 124.02,45.62 123.66,45.98 123.24,45.98 122.87,45.62 122.43,45.62 122.06,45.98 121.78,45.98 121.19,46.57 120.94,46.57 120.71,46.8 120.71,47.22 120.74,47.25 120.74,47.61 120.48,47.86 120.15,47.86 119.81,48.2 119.81,48.5 119.94,48.63 119.94,48.99 119.81,49.12 119.81,49.42 119.94,49.55 119.94,49.91 119.81,50.04 119.81,50.34 119.94,50.47 119.94,50.86 119.87,50.93 119.87,51.29 119.94,51.35 119.94,51.75 119.63,52.06 119.33,52.06 119.08,52.31 119.08,52.67 119.15,52.74 119.15,53.21 119.12,53.24 119.12,53.86 v1(119.51,54.25)
  BOTTOM w0.381: C1127.1 v1(145.24,58.49)
  vias: v1(105.17,55.25) v1(105.17,54.33) v1(105.17,53.41) v1(105.17,51.57) v1(105.17,50.65) v1(105.96,54.79) v1(105.96,53.87) v1(105.96,52.03) v1(105.96,51.11) v1(106.76,54.33) v1(106.76,53.41) v1(106.76,51.57) v1(125.88,58.01) v1(125.88,56.17) v1(125.88,55.25) v1(126.68,58.47) v1(126.68,57.55) v1(126.68,55.71) v1(126.68,54.79) v1(127.48,58.93) v1(127.48,58.01) v1(127.48,56.17) v1(127.48,55.25) v1(127.48,54.33) v1(145.23,67.6) v1(145.23,63.6) v1(145.48,59.6) v1(146.78,67.6) v1(148.56,63.67) v1(148.56,59.09) v1(178.77,46.13) v1(178.77,34.67) v1(180.04,46.1) v1(180.04,44.83) v1(180.04,34.67) v1(181.31,47.37) v1(181.31,46.1) v1(181.31,44.83) v1(181.31,34.67) v1(181.31,33.4) v1(182.58,47.37) v1(182.58,46.1) v1(182.58,44.83) v1(182.58,35.94) v1(182.58,34.67) v1(182.58,33.4) v1(183.85,47.37) v1(183.85,46.1) v1(183.85,44.83) v1(183.85,35.94) v1(183.85,34.67) v1(183.85,33.4) v1(185.12,47.37) v1(185.12,46.1) v1(185.12,44.83) v1(185.12,37.21) v1(185.12,35.94) v1(185.12,34.67) v1(185.12,33.4) v4(177.63,49.36) v4(177.67,50.65) v4(177.65,49.94) v4(177.68,48.76) v4(178.43,50.65) v4(178.42,49.95) v4(178.39,49.36) v4(178.4,48.75) v4(179.6,50.68) v4(179.6,49.91) v4(179.55,32.05) v4(180.36,50.68) v4(180.36,49.91) v4(181.83,50.7) v4(181.83,49.94) v4(181.87,32.05) v4(182.59,50.7) v4(182.59,49.94) v4(183.22,27.82) v4(183.82,50.69) v4(183.82,49.93) v4(184.15,32.05) v4(184.18,27.84) v4(184.58,50.69) v4(184.58,49.93) v4(186.44,32.05) v4(187.84,29.54) v4(187.87,28.63) v7(179.09,49.31) v7(179.09,48.67) v7(179.73,49.31) v7(179.73,48.67) v7(180.36,49.31) v7(180.36,48.67) v7(181,49.31) v7(181,48.67) v7(181.63,49.31) v7(181.63,48.67) v7(182.27,49.31) v7(182.27,48.67) v7(182.9,49.31) v7(182.9,48.67) v7(183.54,49.31) v7(183.54,48.67) v7(184.17,49.31) v7(184.17,48.67) v7(184.81,49.31) v7(184.81,48.67)
0P9V_VCCED_GXR: length 21.2
  BOTTOM w0.203: v1(104.37,52.03) 104.35,52.01 104.35,52 103.89,51.2 103.89,51.01 104.02,50.79 104.02,50.47 103.92,50.37 103.92,50 104.18,49.74 104.58,49.74 104.72,49.61 104.72,49.54 105.02,49.24 105.34,49.24 105.67,48.91 105.67,47.75 105.53,47.61 105.53,47.25 105.67,47.1 105.67,46.85 105.52,46.69 105.52,46.32 105.67,46.17 105.67,45.93 105.52,45.77 105.52,45.4 105.67,45.25 105.67,44.99 105.53,44.85 105.53,44.49 105.67,44.34 105.67,44.09 105.52,43.93 105.52,43.56 105.67,43.41 105.67,43.15 105.53,43.01 105.53,42.65 105.67,42.5 105.67,42.25 105.32,41.89 104.98,41.89 104.72,41.63 104.55,41.46 104.17,41.46 104.02,41.3 104.02,41.26 103.72,40.97 103.39,40.97 103.13,40.71 102.94,40.52 102.62,40.52 102.45,40.42 102.31,40.18 102.12,40.07 101.84,40.07 101.65,39.96 101.49,39.68 101.49,38.94 101.44,38.83 101.33,38.71 101.15,38.64 100.98,38.64 100.79,38.56 100.42,38.19 100.21,38.1 100.07,38.1 99.91,38.04 99.75,37.88 99.65,37.64 99.65,37.1 R961.2
  vias: v1(104.37,52.95) v1(128.27,57.55) v1(128.27,56.63) v1(144.4,53.1) v1(144.4,52.1) v1(144.4,51.1) v1(144.4,50.1) v1(144.4,49.1) v1(144.4,48.1) v1(145.4,55.1) v1(148.56,57.38) v1(195.94,53.6) v1(196.65,53.32) v1(196.7,51.41) v1(196.7,50.52) v1(196.7,49.66) v1(196.76,52.45) v1(197.64,52.4) v1(197.64,51.41) v1(197.64,49.66) v1(197.67,50.55) v1(198.61,52.4) v1(198.58,51.39) v1(198.58,50.55) v1(198.61,49.66) v1(199.55,49.63) v1(199.79,54.22) v1(199.79,53.42) v1(199.79,52.62) v1(199.79,51.82) v1(199.79,51.02) v1(203.79,52.62) v1(204.5,49.63) v1(204.59,52.62) v1(204.59,51.82) v1(204.59,51.02) v1(205.26,49.71) v1(205.42,50.57)
