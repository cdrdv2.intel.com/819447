# Allegro board FM85_AGILEX_PCIE_DK_CMC_ADI_REVC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_DDIMM2_DQ37: length 52.6
  L03_SIG1 w0.081: v1(109.94,93.34) 109.94,94.88 110.55,95.48 110.55,96.08 110.55,96.08 110.55,98.46 110.18,98.84 110.18,100.68 110.33,100.82 110.33,102.73 109.44,103.62 105.81,103.62 105.5,103.31 105.5,101.86 105.32,101.68 105.32,100.06 104.38,99.12 104.38,98.99 103.03,97.65 103.03,96.48 102.89,96.34 102.89,95.01 102.62,94.74 102.62,93.81 103.22,93.21 103.22,92.82 108.42,87.62 109.04,87.62 110.11,86.56 110.12,86.56 110.37,86.31 110.37,86.3 110.37,86.29 110.37,77.51 110.45,77.43 111.12,77.43 111.39,77.7 111.83,77.7 111.91,77.78 111.91,78.49 111.6,78.8 111.39,78.8 111.17,79.02 111.17,80.19 111.41,80.42 111.54,80.42 112.12,81.01 v2(113.13,81.01)
DDR4_DDIMM2_DQ38: length 52.3
  L03_SIG1 w0.081: v1(104.83,97.97) 104.52,97.97 104.15,97.6 103.64,97.6 103.5,97.46 103.5,96.91 103.63,96.78 103.63,96.58 103.5,96.44 103.5,96.26 103.67,96.09 103.67,95.78 103.36,95.48 103.36,94.82 103.08,94.54 103.08,94.09 103.68,93.5 103.68,93.01 108.61,88.08 109.24,88.08 110.3,87.02 110.31,87.02 110.83,86.51 110.83,86.49 110.84,86.48 110.84,85.54 111.49,84.89 111.49,84.49 110.84,83.85 110.84,81.52 110.97,81.39 113.27,81.39 113.5,81.16 113.5,80.34 113.55,80.29 113.55,79.95 113.43,79.84 113.43,79.42 113.55,79.3 113.55,77.22 113.5,77.17 113.5,76.56 113.51,76.56 113.51,76.26 113.5,76.25 113.5,75.14 113.36,75 112.91,75 112.51,74.6 112.14,74.6 111.76,74.97 111.21,74.97 110.9,74.66 110.59,74.66 110.31,74.94 109.59,74.94 109.3,74.66 109,74.66 108.72,74.94 108.27,74.94 107.72,75.49 107.37,75.49 107.02,75.14 107.02,74.93 107.43,74.52 107.68,74.52 108.17,74.03 110.3,74.03 110.59,73.74 110.9,73.74 111.19,74.03 111.89,74.03 112.18,73.74 112.49,73.74 112.95,74.2 113.37,74.2 113.83,74.66 114.09,74.66 114.3,74.88 114.3,79.01 113.93,79.38 v2(113.93,79.63)
DDR4_DDIMM2_DQ39: length 52.4
  L03_SIG1 w0.081: v1(104.01,93.92) 103.91,93.92 103.73,94.1 103.73,94.38 103.84,94.5 104.66,94.5 104.78,94.38 104.78,94.08 104.47,93.77 104.47,93.56 104.39,93.48 104.22,93.48 104.14,93.4 104.14,93.21 104.2,93.14 104.39,93.14 104.47,93.06 104.47,92.9 107.27,90.1 107.54,90.1 107.62,90.02 107.62,89.73 107.74,89.6 107.83,89.6 107.96,89.73 107.96,90.02 108.04,90.1 108.23,90.1 108.32,90.02 108.32,89.1 108.4,89.01 108.55,89.01 108.66,89.12 108.66,90.02 108.74,90.1 109.13,90.1 109.37,89.87 109.37,89.66 109,89.29 109,89.14 109.08,89.06 109.23,89.06 109.6,89.43 109.72,89.43 109.84,89.3 109.84,89.19 109.38,88.73 109.38,88.59 109.49,88.48 109.61,88.48 110.08,88.95 110.19,88.95 110.31,88.83 110.31,88.71 109.89,88.29 109.89,88.18 110.02,88.06 110.13,88.06 110.55,88.48 110.67,88.48 110.79,88.36 110.79,88.24 110.37,87.82 110.37,87.7 110.49,87.58 110.6,87.58 111.03,88 111.14,88 111.26,87.88 111.26,87.77 110.84,87.34 110.84,87.23 110.96,87.11 111.08,87.11 111.5,87.53 111.61,87.53 111.74,87.41 111.74,87.29 111.32,86.87 111.32,86.76 111.44,86.63 111.55,86.63 111.9,86.98 112.01,86.98 112.13,86.86 112.13,86.72 111.31,85.9 111.31,85.78 111.46,85.63 111.58,85.63 112.46,86.51 112.69,86.51 112.89,86.71 113.07,86.71 113.54,86.24 113.54,84.84 113.46,84.76 113.31,84.76 113.22,84.68 113.22,84.51 113.31,84.43 113.48,84.43 113.54,84.37 113.54,84.12 113.45,84.02 113,84.02 112.89,84.13 112.89,85.06 112.67,85.28 112.67,85.8 112.59,85.88 112.34,85.88 112.25,85.79 112.25,84.97 112.47,84.75 112.47,84.13 112.38,84.05 111.7,84.05 111.58,83.92 111.58,83.73 111.66,83.65 113.42,83.65 113.5,83.56 113.5,83.39 113.42,83.31 111.42,83.31 111.34,83.23 111.34,83.07 111.43,82.98 113.42,82.98 113.5,82.89 113.5,82.72 113.42,82.64 111.42,82.64 111.34,82.56 111.34,82.4 111.43,82.3 111.78,82.3 111.86,82.22 111.86,81.95 111.95,81.86 112.11,81.86 112.19,81.94 112.19,82.22 112.28,82.3 112.45,82.3 112.53,82.22 112.53,81.94 112.61,81.86 112.8,81.86 112.86,81.93 112.86,82.22 112.95,82.3 113.42,82.3 113.5,82.22 113.5,82.01 113.77,81.74 113.77,80.68 v2(113.92,80.53)
DDR4_DDIMM2_DQ40: length 51.5
  L03_SIG1 w0.081: v2(106.76,81.01) 106.69,81.08 106.69,81.14 106.46,81.38 106.46,82.36 106.69,82.6 106.69,84.08 105.24,85.53 105.24,86.62 100.14,91.72 98.97,91.72 98.36,92.33 98.36,93.84 98.41,93.89 98.41,94.3 99.74,95.63 99.74,98.3 98.16,99.88 97.56,99.88 97.47,99.97 97.47,100.51 97.39,100.59 97.22,100.59 97.14,100.51 97.14,99.95 97.06,99.87 96.88,99.87 96.8,99.95 96.8,100.51 96.72,100.59 96.55,100.59 96.47,100.51 96.47,99.95 96.38,99.87 96.21,99.87 96.13,99.95 96.13,100.51 96.05,100.59 95.88,100.59 95.8,100.51 95.8,99.95 95.71,99.87 95.54,99.87 95.46,99.95 95.46,101.17 95.37,101.25 95.21,101.25 95.13,101.17 95.13,99.95 95.04,99.87 94.63,99.87 93.42,101.08 93.42,101.88 93.64,102.1 95.91,102.1 95.99,102.02 95.99,101.4 96.07,101.32 96.24,101.32 96.32,101.4 96.32,102.02 96.4,102.1 96.58,102.1 96.66,102.02 96.66,101.4 96.74,101.32 96.91,101.32 96.99,101.4 96.99,102.02 97.08,102.1 97.25,102.1 97.33,102.02 97.33,101.4 97.41,101.32 97.58,101.32 97.66,101.4 97.66,102.02 97.75,102.1 98.83,102.1 99.31,101.62 99.31,100.53 99.23,100.45 98.4,100.45 98.32,100.37 98.32,100.25 98.46,100.11 99.63,100.11 99.74,100 v1(99.74,99.34)
DDR4_DDIMM2_DQ41: length 51.7
  TOP w0.149: v1(99.52,92.76) 99.06,92.76 98.89,92.92 J1.253
  L03_SIG1 w0.081: v1(99.52,92.76) 99.52,93.64 101.07,95.19 101.07,96.31 100.7,96.67 100.7,98.68 100.91,98.88 101.63,98.88 101.91,99.15 101.91,99.54 101.84,99.6 101.84,103.85 101.99,104 102.51,104 102.66,103.85 102.66,103.39 102.75,103.31 103.44,103.31 103.52,103.23 103.52,103.06 103.44,102.97 102.55,102.97 102.47,102.89 102.47,102.72 102.55,102.64 103.98,102.64 104.07,102.56 104.07,102.39 103.98,102.3 102.56,102.3 102.48,102.22 102.48,101.5 102.75,101.24 103.53,101.24 103.61,101.16 103.61,100.99 103.53,100.9 102.75,100.9 102.66,100.82 102.66,100.65 102.75,100.57 103.18,100.57 103.26,100.49 103.26,100.32 103.18,100.23 102.75,100.23 102.66,100.15 102.66,98.95 102.11,98.4 102.11,96.86 102.03,96.78 101.56,96.78 101.48,96.7 101.48,96.53 101.56,96.45 101.89,96.45 101.97,96.36 101.97,95.42 99.97,93.42 99.97,93.2 106.82,86.35 106.82,85.88 107.71,85 107.71,81.82 107.66,81.76 107.66,81.23 107.56,81.13 v2(107.56,80.55)
DDR4_DDIMM2_DQ42: length 53.8
  L03_SIG1 w0.081: v2(106.76,79.17) 107.13,79.54 107.13,81.89 107.25,82.01 107.25,84.81 106.29,85.77 106.08,85.77 105.83,86.02 105.83,86.69 100.31,92.2 99.23,92.2 98.82,92.61 98.82,93.64 98.88,93.7 98.88,94.11 100.21,95.44 100.21,101.91 99.45,102.67 92.69,102.67 92.61,102.59 92.61,101.44 92.53,101.36 92.35,101.36 92.27,101.44 92.27,102.59 92.19,102.67 92.02,102.67 91.94,102.59 91.94,101.44 91.86,101.36 91.68,101.36 91.6,101.44 91.6,102.59 91.52,102.67 91.35,102.67 91.27,102.59 91.27,101.44 91.19,101.36 91.01,101.36 90.93,101.44 90.93,102.59 90.85,102.67 90.1,102.67 90.02,102.59 90.02,101.88 90.02,101.88 90.02,101.57 90.02,101.57 90.02,101.33 89.94,101.25 89.27,101.25 89.18,101.17 89.18,100.99 89.27,100.91 89.94,100.91 90.02,100.83 90.02,100.5 90.19,100.33 93.37,100.33 93.79,99.91 v1(93.79,99.34)
DDR4_DDIMM2_DQ43: length 53.8
  L03_SIG1 w0.081: v2(107.56,79.63) 107.56,79.24 107.1,78.78 106.65,78.78 106.18,78.31 105.75,78.31 105.44,78.62 105,78.62 104.46,79.16 104.21,79.16 103.79,79.58 103.57,79.58 103.21,79.94 103.21,80.81 97.12,86.9 92.69,86.9 87.47,92.12 87.47,94.41 87.55,94.49 89.56,94.49 89.65,94.58 89.65,94.75 89.57,94.83 86.88,94.83 86.8,94.91 86.8,95.08 86.88,95.16 89.51,95.16 89.59,95.24 89.59,95.42 89.51,95.5 86.88,95.5 86.8,95.58 86.8,95.75 86.88,95.83 89.06,95.83 89.14,95.91 89.14,96.09 89.06,96.17 87.21,96.17 87.07,96.3 87.07,96.62 87.15,96.71 89.3,96.71 90.3,95.7 90.3,94.84 91.4,93.74 92.38,93.74 92.77,93.34 v1(92.94,93.34)
DDR4_DDIMM2_DQ44: length 51.9
  L03_SIG1 w0.081: v1(101.44,99.34) 101.01,99.78 101.01,103.05 100.93,103.13 87.75,103.13 87.4,102.78 87.4,97.95 88.16,97.19 89.64,97.19 90.69,96.13 90.85,96.13 91.07,95.91 91.07,95.75 93.36,93.46 93.36,92.94 90.82,90.39 90.82,89.43 92.88,87.36 97.31,87.36 103.12,81.55 103.12,81.31 103.42,81.01 v2(103.57,81.01)
DDR4_DDIMM2_DQ45: length 52.9
  L03_SIG1 w0.081: v2(103.58,79.17) 102.66,79.17 102.26,79.57 101.72,79.57 101.35,79.2 101.35,79 101.16,78.81 100.96,78.81 100.61,78.45 100.61,75.74 100.72,75.63 100.72,74.75 100.99,74.48 101.47,74.48 101.61,74.62 101.61,75.13 101.53,75.2 101.53,78.44 101.72,78.62 102.22,78.62 102.42,78.42 102.42,77.24 102.31,77.14 102.31,74.78 102.43,74.66 103.03,74.66 103.18,74.8 103.18,78.54 103.26,78.62 103.82,78.62 103.95,78.5 103.95,74.67 104.13,74.48 104.56,74.48 104.74,74.66 104.74,77.73 104.86,77.86 105.4,77.86 105.8,77.46 106.37,77.46 106.77,77.86 107.16,77.86 107.42,78.12 107.53,78.12 107.98,78.57 107.98,81.16 108.17,81.36 108.17,85.77 107.8,86.13 107.69,86.13 107.59,86.04 107.48,86.04 107.36,86.16 107.36,86.28 107.45,86.37 107.45,86.49 101.56,92.38 101.56,92.59 101.42,92.72 101.21,92.72 v1(100.59,93.34)
DDR4_DDIMM2_DQ46: length 52
  TOP w0.149: v2(104.22,81.41) 104.21,81.41 104.21,81.4 104.22,81.4 104.37,81.25 U6.MH62
  L03_SIG1 w0.081: v1(95.49,99.34) 94.74,99.34 94.33,98.94 93.55,98.94 93.33,99.15 93.33,99.71 93.17,99.87 90.16,99.87 90.08,99.79 90.08,99.58 90,99.5 89.83,99.5 89.74,99.58 89.74,99.79 89.66,99.87 89.49,99.87 89.41,99.79 89.41,99.39 89.33,99.31 89.18,99.31 89.07,99.42 89.07,99.79 88.99,99.87 88.34,99.87 88.21,99.75 88.21,99.19 87.95,98.92 87.95,98.63 88.93,97.65 89.83,97.65 90.05,97.42 90.64,97.42 92.07,96 92.07,95.41 93.6,93.88 94.79,93.88 95.09,93.58 95.09,91.83 95.01,91.75 94.72,91.75 94.64,91.66 94.64,91.49 94.72,91.41 95.01,91.41 95.09,91.33 95.09,91.16 95.01,91.07 94.41,91.07 94.33,90.99 94.33,90.85 94.44,90.74 95.01,90.74 95.09,90.66 95.09,90.53 95.21,90.41 96.18,90.41 96.97,89.62 96.97,89.01 97.49,88.49 97.6,88.49 97.82,88.7 97.94,88.7 98.06,88.58 98.06,88.47 97.84,88.25 97.84,88.14 98.16,87.82 98.27,87.82 98.56,88.1 98.67,88.1 98.8,87.98 98.8,87.87 98.51,87.58 98.51,87.47 98.63,87.34 98.75,87.34 99.03,87.63 99.15,87.63 99.27,87.51 99.27,87.39 98.99,87.11 98.99,86.99 99.11,86.87 99.22,86.87 99.51,87.16 99.62,87.16 99.74,87.03 99.74,86.92 99.46,86.63 99.46,86.52 99.58,86.4 99.7,86.4 99.98,86.68 100.1,86.68 100.22,86.56 100.22,86.44 99.93,86.16 99.93,86.04 100.06,85.92 100.17,85.92 100.46,86.21 100.57,86.21 100.69,86.09 100.69,85.97 100.41,85.69 100.41,85.57 100.53,85.45 100.64,85.45 100.93,85.73 101.05,85.73 101.17,85.61 101.17,85.5 100.88,85.21 100.88,85.1 101,84.97 101.12,84.97 101.4,85.26 101.52,85.26 101.64,85.14 101.64,85.02 101.36,84.74 101.36,84.62 101.48,84.5 101.59,84.5 101.88,84.79 101.99,84.79 102.12,84.66 102.12,84.55 101.83,84.26 101.83,84.15 101.95,84.03 102.07,84.03 102.35,84.31 102.47,84.31 102.59,84.19 102.59,84.07 102.3,83.79 102.3,83.67 102.43,83.55 102.54,83.55 102.83,83.84 102.94,83.84 103.06,83.71 103.06,83.6 102.78,83.31 102.78,83.2 102.9,83.08 103.02,83.08 103.3,83.36 103.42,83.36 103.54,83.24 103.54,83.13 103.25,82.84 103.25,82.73 103.37,82.6 103.49,82.6 103.78,82.89 103.89,82.89 104.01,82.77 104.01,82.65 103.73,82.37 103.73,82.25 104.04,81.93 104.04,81.71 104.21,81.55 104.21,81.41 v2(104.22,81.41)
DDR4_DDIMM2_DQ47: length 53.1
  L03_SIG1 w0.081: v1(94.64,93.34) 94.37,93.34 94.09,93.07 94.09,92.89 94.6,92.39 94.6,92.27 94.47,92.15 94.36,92.15 93.85,92.66 93.74,92.66 92.91,91.83 92.91,91.71 93.51,91.11 93.51,91 93.38,90.88 93.27,90.88 92.67,91.48 92.55,91.48 92.43,91.35 92.43,91.24 93.54,90.13 93.54,90.01 93.43,89.9 93.3,89.9 92.2,91 92.08,91 91.96,90.88 91.96,90.76 93.2,89.53 93.2,89.41 93.08,89.3 92.95,89.3 91.72,90.53 91.61,90.53 91.28,90.2 91.28,89.62 91.43,89.47 91.54,89.47 91.77,89.7 91.89,89.7 92.01,89.58 92.01,89.47 91.78,89.23 91.78,89.12 91.9,89 92.02,89 92.25,89.23 92.36,89.23 92.48,89.11 92.48,88.99 92.25,88.76 92.25,88.65 92.37,88.52 92.49,88.52 92.72,88.76 92.84,88.76 92.96,88.63 92.96,88.52 92.73,88.29 92.73,88.17 93.07,87.83 93.41,87.83 93.49,87.91 93.49,88.99 93.57,89.07 93.74,89.07 93.83,88.99 93.83,87.91 93.91,87.83 94.08,87.83 94.16,87.91 94.16,89.86 94.25,89.95 94.42,89.95 94.5,89.87 94.5,87.91 94.58,87.83 94.75,87.83 94.83,87.91 94.83,89.86 94.92,89.95 95.09,89.95 95.17,89.87 95.17,87.91 95.25,87.83 95.42,87.83 95.5,87.91 95.5,89.73 95.59,89.81 95.75,89.81 95.84,89.72 95.84,87.91 95.92,87.83 96.09,87.83 96.17,87.91 96.17,89.31 96.25,89.4 96.41,89.4 96.51,89.3 96.51,87.91 96.59,87.83 97.5,87.83 103.58,81.74 103.58,81.52 103.94,81.16 103.94,80.06 v2(104.37,79.63)
DDR4_DDIMM2_DQ48: length 53.7
  L05_SIG2 w0.081: v1(111.54,79.17) 111.92,79.55 111.92,81.55 110.58,82.89 110.06,82.89 109.05,83.9 109.05,86.57 108.22,87.4 108.22,89.15 106.79,90.58 106.52,90.58 105.81,91.29 100.77,91.29 100.69,91.21 100.69,90.08 100.61,89.99 100.43,89.99 100.35,90.08 100.35,91.21 100.27,91.29 100.1,91.29 100.02,91.21 100.02,90.08 99.94,89.99 99.76,89.99 99.68,90.08 99.68,91.21 99.6,91.29 99.43,91.29 99.35,91.21 99.35,90.08 99.27,89.99 99.09,89.99 99.01,90.08 99.01,91.21 98.93,91.29 98.76,91.29 98.68,91.21 98.68,90.08 98.59,89.99 98.42,89.99 98.34,90.08 98.34,91.21 98.26,91.29 98.09,91.29 98.01,91.21 98.01,90.08 97.92,89.99 97.75,89.99 97.67,90.08 97.67,91.21 97.59,91.29 97.42,91.29 97.33,91.21 97.33,90.08 97.25,89.99 97.08,89.99 97,90.08 97,91.21 96.92,91.29 96.75,91.29 96.66,91.21 96.66,90.08 96.58,89.99 96.41,89.99 96.33,90.08 96.33,91.21 96.25,91.29 95.93,91.29 95.91,91.31 95.89,91.31 94.69,92.51 93.85,92.51 93.4,92.96 93.4,93.81 91.82,95.39 91.43,95.39 91.22,95.61 91.22,95.99 90.55,96.66 90.18,96.66 89.94,96.9 89.94,99.07 90.22,99.34 v1(90.39,99.34)
DDR4_DDIMM2_DQ49: length 52.1
  L05_SIG2 w0.081: v1(89.54,93.34) 90.93,93.34 91.63,92.65 91.75,92.65 92.01,92.92 92.13,92.92 92.25,92.79 92.25,92.68 91.98,92.41 91.98,92.3 92.1,92.17 92.22,92.17 92.72,92.68 92.86,92.68 92.97,92.57 92.97,92.45 92.46,91.94 92.46,91.82 92.58,91.7 92.69,91.7 93.27,92.28 93.41,92.28 93.52,92.16 93.52,92.05 92.93,91.46 92.93,91.35 94.77,89.5 101.19,89.5 101.27,89.59 101.27,90.73 101.35,90.81 101.52,90.81 101.61,90.73 101.61,89.59 101.69,89.5 101.86,89.5 101.94,89.59 101.94,90.73 102.02,90.81 102.19,90.81 102.28,90.73 102.28,89.59 102.36,89.5 102.53,89.5 102.61,89.59 102.61,90.73 102.69,90.81 102.87,90.81 102.95,90.73 102.95,89.59 103.03,89.5 103.2,89.5 103.28,89.59 103.28,90.73 103.36,90.81 103.54,90.81 103.62,90.73 103.62,89.59 103.7,89.5 103.87,89.5 103.95,89.59 103.95,90.73 104.03,90.81 104.21,90.81 104.29,90.73 104.29,89.59 104.37,89.5 104.54,89.5 104.62,89.59 104.62,90.73 104.7,90.81 104.88,90.81 104.96,90.73 104.96,89.59 105.04,89.5 105.21,89.5 105.29,89.59 105.29,90.73 105.37,90.81 105.55,90.81 105.63,90.73 105.63,89.59 105.71,89.5 106.2,89.5 106.28,89.59 106.28,90.04 106.36,90.12 106.54,90.12 106.62,90.04 106.62,89.59 106.7,89.5 107.21,89.5 107.76,88.96 107.76,84.53 109.87,82.43 110.39,82.43 111.46,81.36 111.46,81.17 111.54,81.09 v1(111.54,81.01)
DDR4_DDIMM2_DQ50: length 52
  L05_SIG2 w0.081: v1(112.34,80.55) 112.34,81.12 112.38,81.17 112.38,81.74 110.38,83.74 110.38,84.1 110.09,84.39 110.09,84.4 109.77,84.72 109.52,84.97 109.52,85.31 109.72,85.51 109.72,85.77 109.52,85.97 109.52,86.31 109.72,86.51 109.72,87.03 108.86,87.89 108.86,87.9 108.69,88.08 108.69,89.34 106.98,91.04 106.71,91.04 106,91.75 96.12,91.75 96.1,91.78 96.08,91.78 94.89,92.97 94.49,92.97 94.27,93.19 94.27,93.6 90.87,97 90.87,97.6 90.95,97.68 93.65,97.68 93.73,97.76 93.73,97.93 93.64,98.02 90.95,98.02 90.87,98.1 90.87,98.27 90.95,98.35 93.54,98.35 93.62,98.43 93.62,98.61 93.54,98.69 90.95,98.69 90.87,98.77 90.87,99.52 90.58,99.81 84.91,99.81 v1(84.44,99.34)
DDR4_DDIMM2_DQ51: length 54.6
  TOP w0.149: J1.271 83.59,95.36 84.71,96.48 v1(95.11,96.48)
  L05_SIG2 w0.081: v1(95.11,96.48) 94.8,96.17 94.8,95.69 95.03,95.46 95.03,93.49 96.28,92.24 102.74,92.24 102.82,92.32 102.82,93.63 102.9,93.71 103.07,93.71 103.15,93.63 103.15,92.32 103.24,92.24 103.41,92.24 103.49,92.32 103.49,93.63 103.57,93.72 103.69,93.72 103.82,93.59 103.82,92.32 103.91,92.24 104.08,92.24 104.16,92.32 104.16,93.48 104.24,93.56 104.41,93.56 104.5,93.48 104.5,92.32 104.58,92.24 104.75,92.24 104.83,92.32 104.83,93.48 104.91,93.56 105.08,93.56 105.17,93.48 105.17,92.32 105.27,92.21 106.19,92.21 106.9,91.5 107.18,91.5 109.15,89.53 109.15,88.27 109.33,88.09 109.33,88.08 110.84,86.56 110.84,85.15 110.55,84.86 110.55,84.58 110.84,84.29 110.84,83.93 112.84,81.93 112.84,81.17 112.76,81.08 112.76,80.05 v1(112.34,79.63)
DDR4_DDIMM2_DQ52: length 52.4
  L05_SIG2 w0.081: v1(109.15,80.55) 106.43,80.55 104.03,82.95 93.81,82.95 85.83,90.93 85.83,91.31 85.83,93.6 85.24,94.2 85.24,96.01 83.98,97.26 83.98,99.54 84.71,100.27 85.53,100.27 85.61,100.35 85.61,101.08 85.69,101.17 85.86,101.17 85.94,101.08 85.94,100.35 86.03,100.27 86.2,100.27 86.28,100.35 86.28,101.08 86.36,101.17 86.53,101.17 86.62,101.08 86.62,100.35 86.7,100.27 86.87,100.27 86.95,100.35 86.95,101.08 87.03,101.17 87.2,101.17 87.29,101.08 87.29,100.35 87.37,100.27 87.54,100.27 87.62,100.35 87.62,101.08 87.7,101.17 87.88,101.17 87.96,101.08 87.96,100.35 88.04,100.27 91.58,100.27 92.09,99.75 v1(92.09,99.34)
DDR4_DDIMM2_DQ53: length 53.6
  TOP w0.149: v1(84.75,95.67) 89.62,95.67 90.06,95.22 90.8,95.22 90.96,95.06 90.96,94.33 J1.262
  L05_SIG2 w0.081: v1(108.36,79.17) 105.16,79.17 102.73,81.6 92.55,81.6 92.28,81.87 92.28,81.99 92.73,82.44 92.73,82.56 92.61,82.68 92.49,82.68 92.04,82.22 91.92,82.22 91.8,82.35 91.8,82.46 92.25,82.92 92.25,83.03 92.13,83.15 92.02,83.15 91.56,82.7 91.45,82.7 91.33,82.82 91.33,82.94 91.78,83.39 91.78,83.5 91.66,83.63 91.54,83.63 91.09,83.17 90.97,83.17 90.85,83.29 90.85,83.41 91.31,83.86 91.31,83.98 91.18,84.1 91.07,84.1 90.62,83.65 90.5,83.65 90.38,83.77 90.38,83.88 90.83,84.34 90.83,84.45 90.71,84.57 90.6,84.57 90.14,84.12 90.03,84.12 89.9,84.24 89.9,84.36 90.36,84.81 90.36,84.93 90.24,85.05 90.12,85.05 89.67,84.59 89.55,84.59 89.43,84.72 89.43,84.83 89.88,85.29 89.88,85.4 89.76,85.52 89.65,85.52 89.19,85.07 89.08,85.07 83.29,90.86 83.29,95.42 83.53,95.67 v1(84.75,95.67)
DDR4_DDIMM2_DQ54: length 52.2
  L05_SIG2 w0.081: v1(86.14,99.34) 86.02,99.22 86.02,98.31 86.22,98.11 87.48,98.11 87.56,98.02 87.56,97.85 87.48,97.77 85.26,97.77 85.17,97.68 85.17,97.52 85.25,97.43 87.48,97.43 87.56,97.35 87.56,97.18 87.48,97.1 85.26,97.1 85.17,97.01 85.17,96.85 85.25,96.76 87.48,96.76 87.56,96.68 87.56,96.51 87.48,96.43 86.22,96.43 86.14,96.35 86.14,96.17 86.22,96.09 87.48,96.09 87.56,96.01 87.56,95.84 87.48,95.76 86.22,95.76 86.14,95.68 86.14,95.5 86.22,95.42 87.48,95.42 87.56,95.34 87.56,95.17 87.48,95.09 86.22,95.09 86.14,95.01 86.14,94.83 86.88,94.09 86.88,93.83 86.3,93.25 86.3,91.12 93.96,83.46 104.17,83.46 106.62,81.01 v1(108.35,81.01)
DDR4_DDIMM2_DQ55: length 53.4
  L05_SIG2 w0.081: v1(109.15,79.63) 106.52,79.63 103.7,82.45 93.6,82.45 89.71,86.34 89.59,86.34 89.1,85.85 88.99,85.85 88.86,85.98 88.86,86.09 89.36,86.58 89.36,86.7 89.23,86.82 89.12,86.82 88.63,86.33 88.51,86.33 88.39,86.45 88.39,86.57 88.88,87.06 88.88,87.17 88.76,87.29 88.64,87.29 88.15,86.8 88.04,86.8 87.92,86.92 87.92,87.04 88.41,87.53 88.41,87.65 88.28,87.77 88.17,87.77 87.68,87.28 87.56,87.28 87.44,87.4 87.44,87.51 87.93,88 87.93,88.12 87.81,88.24 87.7,88.24 87.2,87.75 87.09,87.75 86.97,87.87 86.97,87.99 87.46,88.48 87.46,88.59 87.34,88.72 87.22,88.72 86.73,88.22 86.62,88.22 86.49,88.35 86.49,88.46 86.98,88.95 86.98,89.07 86.86,89.19 86.75,89.19 86.26,88.7 86.14,88.7 86.02,88.82 86.02,88.94 86.51,89.43 86.51,89.54 86.39,89.66 86.27,89.66 85.78,89.17 85.67,89.17 85.55,89.3 85.55,89.41 86.04,89.9 86.04,90.02 85.91,90.14 85.8,90.14 85.31,89.65 85.19,89.65 85.07,89.77 85.07,89.88 85.56,90.38 85.56,90.49 85.29,90.76 85.29,91.1 85.21,91.18 83.85,91.18 83.76,91.27 83.76,91.44 83.84,91.52 85.28,91.52 85.36,91.6 85.36,91.77 85.28,91.85 83.88,91.85 83.79,91.93 83.79,92.11 83.88,92.19 85.21,92.19 85.29,92.27 85.29,92.44 85.21,92.52 83.88,92.52 83.79,92.6 83.79,92.78 83.88,92.86 85.21,92.86 85.29,92.94 v1(85.29,93.34)
DDR4_DDIMM2_DQ56: length 65.5
  L14_SIG5 w0.081: v1(81.04,99.34) 81.04,98.83 79.94,97.72 79.94,93.83 79.65,93.54 79.65,92.92 79.92,92.64 80.81,92.64 80.89,92.72 80.89,93.87 80.97,93.95 81.14,93.95 81.22,93.87 81.22,92.72 81.3,92.64 81.48,92.64 81.56,92.72 81.56,93.87 81.64,93.95 81.81,93.95 81.89,93.87 81.89,92.72 81.97,92.64 83.24,92.64 83.32,92.72 83.32,93.78 83.4,93.86 83.58,93.86 83.66,93.78 83.66,92.72 83.74,92.64 85.82,92.64 85.9,92.72 85.9,93.5 85.98,93.58 86.16,93.58 86.24,93.5 86.24,92.72 86.32,92.64 87.4,92.64 87.58,92.46 87.58,92.34 87.26,92.02 87.26,91.91 87.38,91.79 87.5,91.79 87.82,92.11 87.93,92.11 88.06,91.98 88.06,91.87 87.74,91.55 87.74,91.43 87.86,91.31 87.97,91.31 88.29,91.63 88.41,91.63 88.53,91.51 88.53,91.39 88.21,91.07 88.21,90.96 88.33,90.84 88.45,90.84 88.77,91.16 88.88,91.16 89,91.04 89,90.92 88.68,90.6 88.68,90.49 88.81,90.36 88.92,90.36 89.24,90.68 89.36,90.68 89.71,90.33 91.78,90.33 94.61,87.5 95.14,87.5 95.14,87.5 110.27,87.5 113.4,84.37 113.4,80.84 arc(113.43,80.57) 113.53,80.33 113.54,80.31 arc(113.6,80.08) 113.53,79.86 arc(113.47,79.63) 113.53,79.41 113.53,79.4 arc(113.59,79.24) 113.59,79.08 arc(113.57,79.01) 113.53,78.94 arc(113.47,78.71) 113.53,78.48 arc(113.6,78.25) 113.53,78.02 arc(113.47,77.79) 113.53,77.56 113.54,77.56 arc(113.6,77.34) 113.54,77.11 arc(113.54,77.11) 113.53,77.1 v1(113.13,76.41)
DDR4_DDIMM2_DQ57: length 68.1
  L14_SIG5 w0.081: v1(113.13,74.57) 113.53,75.26 arc(113.59,75.48) 113.54,75.7 113.53,75.72 arc(113.47,75.95) 113.53,76.18 113.54,76.2 arc(113.71,76.35) 113.93,76.41 arc(114.16,76.47) 114.33,76.63 114.34,76.66 arc(114.39,76.88) 114.33,77.1 arc(114.27,77.33) 114.33,77.56 114.33,77.56 arc(114.39,77.79) 114.33,78.02 arc(114.27,78.25) 114.33,78.48 114.33,78.48 arc(114.39,78.71) 114.33,78.94 arc(114.27,79.17) 114.33,79.39 114.34,79.41 arc(114.39,79.63) 114.33,79.86 114.3,79.89 arc(114.07,80.19) 113.91,80.53 arc(113.9,80.57) 113.89,80.61 113.87,80.75 arc(113.86,80.8) 113.86,80.84 113.86,84.57 113.59,84.84 113.59,86.54 112.19,87.94 arc(112.17,87.95) 112.13,87.96 95.33,87.96 95.33,87.96 94.81,87.96 90.26,92.51 89.2,92.51 88.71,93 88.71,93.5 88.32,93.89 88.32,95.49 87.67,96.15 87.29,96.15 87.21,96.23 87.21,96.91 87.13,96.99 86.96,96.99 86.87,96.91 86.87,96.23 86.79,96.15 86.62,96.15 86.54,96.23 86.54,96.91 86.46,96.99 86.29,96.99 86.2,96.91 86.2,96.23 86.12,96.15 85.95,96.15 85.87,96.23 85.87,96.94 85.79,97.02 85.61,97.02 85.53,96.94 85.53,96.23 85.45,96.15 83.94,96.15 83.86,96.07 83.86,94.48 83.78,94.4 83.61,94.4 83.53,94.48 83.53,96.07 83.45,96.15 83.27,96.15 83.19,96.07 83.19,94.48 83.11,94.4 82.94,94.4 82.86,94.48 82.86,96.07 82.78,96.15 82.6,96.15 82.52,96.07 82.52,94.48 82.44,94.4 82.27,94.4 82.19,94.48 82.19,96.07 82.11,96.15 81.84,96.15 81.58,95.9 81.58,95.34 81.31,95.07 80.93,95.07 80.4,94.54 80.4,93.64 80.19,93.43 v1(80.19,93.34)
DDR4_DDIMM2_DQ58: length 67.9
  L14_SIG5 w0.081: v1(75.09,99.34) 75.09,99.88 76.62,101.41 76.93,101.41 77.33,101.01 82.52,101.01 84.07,99.47 84.07,99.19 85.2,98.07 87.71,98.07 87.92,97.85 88.04,97.85 88.68,98.49 88.79,98.49 88.91,98.37 88.91,98.25 88.28,97.61 88.28,97.5 88.4,97.38 88.51,97.38 89.15,98.01 89.27,98.01 89.39,97.89 89.39,97.78 88.75,97.14 88.75,97.02 88.87,96.9 88.99,96.9 89.62,97.54 89.74,97.54 89.86,97.42 89.86,97.3 89.22,96.66 89.22,96.55 90,95.78 90,93.94 90.23,93.71 90.37,93.71 95.19,88.89 99.31,88.89 99.31,88.89 110.07,88.89 112.68,88.89 115.14,86.43 115.14,81.69 115.92,80.91 115.92,79.4 arc(115.86,79.17) 115.92,78.94 arc(115.99,78.71) 115.92,78.48 arc(115.86,78.25) 115.92,78.02 arc(115.99,77.79) 115.92,77.56 115.92,77.56 arc(115.86,77.33) 115.92,77.1 arc(115.99,76.88) 115.94,76.66 115.91,76.62 arc(115.86,76.4) 115.92,76.18 arc(115.98,75.95) 115.92,75.72 115.92,75.72 arc(115.76,75.56) 115.54,75.49 115.52,75.49 arc(115.29,75.43) 115.13,75.26 arc(114.96,75.09) 114.73,75.03 114.27,75.03 v1(113.93,75.03)
DDR4_DDIMM2_DQ59: length 66.2
  TOP w0.149: J1.282 74.24,94.78 74.69,95.22 75.42,95.22 76.74,96.55 80.11,96.55 v1(81.12,95.53)
  L14_SIG5 w0.081: v1(113.93,75.95) 114.87,75.95 115.13,76.18 115.14,76.2 arc(115.19,76.42) 115.13,76.64 arc(115.07,76.86) 115.11,77.08 115.13,77.1 arc(115.19,77.33) 115.13,77.56 115.13,77.56 arc(115.07,77.79) 115.13,78.02 arc(115.19,78.25) 115.13,78.48 115.13,78.48 arc(115.07,78.71) 115.13,78.94 arc(115.19,79.17) 115.13,79.39 115.12,79.41 arc(115.07,79.63) 115.13,79.86 arc(115.19,80.08) 115.13,80.31 115.14,80.32 115.14,80.86 114.32,81.68 114.32,84.76 114.05,85.03 114.05,86.8 112.43,88.42 110.47,88.42 99.12,88.42 99.12,88.43 95,88.43 90.45,92.97 89.39,92.97 89.17,93.19 89.17,95.71 87.38,97.5 85.12,97.5 85.04,97.42 85.04,96.91 84.96,96.83 84.78,96.83 84.7,96.91 84.7,97.42 84.62,97.5 84.45,97.5 84.37,97.42 84.37,96.91 84.29,96.83 84.11,96.83 84.03,96.91 84.03,97.42 83.95,97.5 83.78,97.5 83.7,97.42 83.7,96.91 83.62,96.83 83.44,96.83 83.36,96.91 83.36,97.42 83.28,97.5 83.11,97.5 83.03,97.42 83.03,96.91 82.94,96.83 82.77,96.83 82.69,96.91 82.69,97.42 82.61,97.5 82.02,97.5 81.12,96.61 v1(81.12,95.53)
DDR4_DDIMM2_DQ60: length 68.3
  L14_SIG5 w0.081: v1(109.95,76.41) 109.67,76.9 109.42,77.14 arc(109.18,77.3) 108.91,77.36 arc(108.82,77.39) 108.78,77.48 108.78,81.64 arc(108.7,82.05) 108.47,82.4 arc(108.14,82.62) 107.75,82.7 101.97,82.7 101.31,83.36 94.47,83.36 90.62,87.21 79.57,87.21 75.36,91.42 75.14,91.42 74.69,91.87 74.69,95.72 75.14,96.17 75.3,96.17 76.33,97.2 76.33,97.53 76.25,97.61 73.82,97.61 73.74,97.69 73.74,97.87 73.82,97.95 76.25,97.95 76.33,98.03 76.33,99.54 76.6,99.81 77.5,99.81 77.58,99.89 77.58,100.41 77.66,100.49 77.83,100.49 77.91,100.41 77.91,99.89 78,99.81 78.17,99.81 78.25,99.89 78.25,100.41 78.33,100.49 78.5,100.49 78.59,100.41 78.59,99.89 78.67,99.81 78.84,99.81 78.92,99.89 78.92,100.41 79,100.49 79.17,100.49 79.26,100.41 79.26,99.89 79.34,99.81 79.71,99.81 79.78,99.74 81.65,99.74 v1(82.74,98.64)
DDR4_DDIMM2_DQ61: length 67.2
  TOP w0.149: v1(74.23,96.95) 74.57,96.95 74.88,97.26 80.5,97.26 81.89,95.87 J1.273
  L14_SIG5 w0.081: v1(74.23,96.95) 74.38,96.95 74.57,96.76 74.57,96.44 74.1,95.98 74.1,95.64 74.02,95.56 73.21,95.56 73.13,95.47 73.13,95.3 73.21,95.22 74.02,95.22 74.1,95.14 74.1,94.97 74.02,94.89 73.21,94.89 73.13,94.8 73.13,94.63 73.21,94.55 74.02,94.55 74.1,94.47 74.1,94.3 74.02,94.22 73.21,94.22 73.13,94.13 73.13,93.96 73.21,93.88 74.02,93.88 74.1,93.8 74.1,91.55 78.91,86.75 90.4,86.75 94.24,82.9 101.12,82.9 102.24,81.78 105.57,81.78 arc(106.34,81.67) 107.06,81.36 arc(107.34,81.16) 107.6,80.93 107.75,80.78 arc(107.89,80.57) 107.94,80.32 107.94,77.3 arc(107.95,77.15) 108,77.01 arc(108.09,76.91) 108.22,76.87 108.45,76.87 arc(108.5,76.86) 108.53,76.84 108.81,76.56 arc(108.96,76.45) 109.15,76.41 109.15,76.41 arc(109.38,76.35) 109.55,76.18 arc(109.57,76.14) 109.59,76.09 109.59,76.06 arc(109.64,75.93) 109.78,75.87 110.04,75.87 arc(110.25,75.78) 110.33,75.57 110.33,75.28 arc(110.3,75.13) 110.22,74.99 110.06,74.84 arc(109.98,74.71) v1(109.95,74.57)
DDR4_DDIMM2_DQ62: length 68.5
  L14_SIG5 w0.081: v1(110.74,75.95) 110.35,76.64 arc(110.28,76.86) 110.33,77.07 110.35,77.1 arc(110.41,77.33) 110.35,77.56 arc(110.26,77.67) 110.15,77.77 arc(110.12,77.78) 110.08,77.79 109.84,77.79 arc(109.72,77.81) 109.62,77.88 arc(109.57,77.95) 109.55,78.04 109.55,82.54 arc(109.55,82.58) 109.54,82.62 arc(109.45,82.86) 109.29,83.07 arc(109.18,83.14) 109.05,83.16 102.16,83.16 101.5,83.83 94.82,83.83 90.78,87.86 87.88,87.86 87.87,87.87 82.97,87.87 82.88,87.96 82.88,89.06 82.8,89.14 82.63,89.14 82.55,89.06 82.55,87.96 82.47,87.87 82.29,87.87 82.21,87.96 82.21,89.06 82.13,89.14 81.96,89.14 81.88,89.06 81.88,87.96 81.8,87.87 81.62,87.87 81.54,87.96 81.54,89.06 81.46,89.14 81.29,89.14 81.21,89.06 81.21,87.96 81.13,87.87 80.72,87.87 80.53,88.07 79.44,88.07 79.17,88.35 79.17,88.46 79.65,88.94 79.65,89.06 79.53,89.18 79.41,89.18 78.93,88.7 78.81,88.7 78.69,88.82 78.69,88.93 79.18,89.42 79.18,89.53 79.05,89.66 78.94,89.66 78.45,89.17 78.34,89.17 75.63,91.89 75.63,93.01 75.48,93.15 75.48,93.17 75.49,93.18 75.49,94.03 75.57,94.11 76.26,94.11 76.34,94.19 76.34,94.36 76.26,94.45 75.57,94.45 75.49,94.53 75.49,94.7 75.57,94.78 76.88,94.78 76.96,94.86 76.96,95.03 76.88,95.12 75.57,95.12 75.49,95.2 75.49,95.47 75.92,95.9 76.03,95.9 76.33,95.6 76.44,95.6 76.56,95.73 76.56,95.84 76.27,96.13 76.27,96.25 76.79,96.77 v1(76.79,99.34)
DDR4_DDIMM2_DQ63: length 66.2
  L14_SIG5 w0.081: v1(75.94,93.34) 76.74,92.55 76.74,91.79 78.4,90.14 79.7,90.14 80.22,89.62 83.31,89.62 83.39,89.54 83.39,88.56 83.47,88.48 83.64,88.48 83.72,88.56 83.72,89.54 83.8,89.62 83.98,89.62 84.06,89.54 84.06,88.56 84.14,88.48 84.31,88.48 84.39,88.56 84.39,89.54 84.47,89.62 84.65,89.62 84.73,89.54 84.73,88.56 84.81,88.48 84.98,88.48 85.06,88.56 85.06,89.54 85.14,89.62 85.32,89.62 85.4,89.54 85.4,88.56 85.48,88.48 85.65,88.48 85.73,88.56 85.73,89.54 85.81,89.62 85.99,89.62 86.07,89.54 86.07,88.56 86.15,88.48 86.32,88.48 86.4,88.56 86.4,89.54 86.49,89.62 86.78,89.62 88.07,88.33 90.98,88.33 94.61,84.7 97.7,84.7 97.78,84.78 97.78,85.52 97.87,85.61 98.04,85.61 98.12,85.52 98.12,84.78 98.2,84.7 98.37,84.7 98.45,84.78 98.45,85.52 98.54,85.61 98.71,85.61 98.79,85.52 98.79,84.78 98.87,84.7 99.04,84.7 99.13,84.78 99.13,85.52 99.21,85.61 99.38,85.61 99.46,85.52 99.46,84.78 99.54,84.7 99.71,84.7 99.8,84.78 99.8,85.52 99.88,85.61 100.05,85.61 100.13,85.52 100.13,84.78 100.21,84.7 100.39,84.7 100.47,84.78 100.47,85.52 100.55,85.61 100.72,85.61 100.8,85.52 100.8,84.78 100.88,84.7 103.15,84.7 103.94,83.9 108.93,83.9 108.97,83.86 109.85,83.32 109.99,83.17 arc(110.26,82.73) 110.35,82.22 110.35,78.6 arc(110.37,78.48) 110.44,78.38 110.5,78.32 arc(110.56,78.28) 110.62,78.27 110.91,78.27 arc(110.96,78.26) 110.99,78.23 111.08,78.14 arc(111.17,78.02) 111.2,77.86 arc(111.2,77.71) 111.14,77.56 111.14,77.56 arc(111.08,77.33) 111.14,77.1 arc(111.21,76.88) 111.16,76.66 111.13,76.62 arc(111.08,76.4) 111.14,76.18 arc(111.2,75.95) 111.14,75.72 111.14,75.72 v1(110.74,75.03)
DDR4_DDIMM2_DQ64: length 53.5
  L12_SIG4 w0.089: v1(121.9,80.55) 121.75,80.7 121.75,81.55 121.72,81.58 121.72,82.73 122.07,83.08 122.07,83.59 123.21,84.73 123.21,85.52 124.77,87.08 arc(124.81,87.1) 124.85,87.11 127.39,87.11 127.7,87.42 128.21,87.42 128.3,87.51 128.3,88.01 128.39,88.1 128.55,88.1 128.64,88.01 128.64,87.51 128.73,87.42 129.35,87.42 129.89,87.97 129.89,88.1 129.49,88.5 129.49,88.63 129.6,88.75 129.73,88.75 130.14,88.34 130.26,88.34 130.69,88.77 131.63,88.77 131.63,88.76 132.2,88.76 133.98,90.54 135.33,90.54 136.09,91.3 145.06,91.3 145.63,91.87 149.18,91.87 150.12,92.81 154.24,92.81 154.41,92.95 154.76,93.29 154.76,93.42 154.24,93.94 154.24,94.06 154.36,94.18 154.48,94.18 155,93.66 155.12,93.66 155.25,93.79 155.25,95.74 155.36,95.85 155.36,95.97 155.19,96.13 155.19,96.26 155.31,96.38 155.44,96.38 155.6,96.21 155.72,96.21 155.92,96.41 156.33,96.41 156.71,96.79 156.71,97.36 156.6,97.48 156.45,97.48 156.35,97.57 155.95,97.57 155.86,97.48 155.86,96.91 155.77,96.82 155.61,96.82 155.52,96.91 155.52,97.48 155.43,97.57 155.23,97.57 154.99,97.81 v1(154.99,97.95)
DDR4_DDIMM2_DQ65: length 54.9
  L12_SIG4 w0.089: v1(154.14,93.34) 154.1,93.3 154.07,93.28 153.63,93.28 153.54,93.37 153.54,94.29 153.45,94.38 153.3,94.38 153.2,94.28 153.2,93.37 153.11,93.28 152.95,93.28 152.86,93.37 152.86,93.65 152.77,93.74 152.6,93.74 152.52,93.65 152.52,93.37 152.43,93.28 152.26,93.28 152.17,93.37 152.17,93.65 152.08,93.74 151.92,93.74 151.83,93.65 151.83,93.37 151.74,93.28 151.58,93.28 151.49,93.37 151.49,93.65 151.4,93.74 151.23,93.74 151.14,93.65 151.14,93.37 151.05,93.28 150.71,93.28 150.63,93.37 150.63,94.01 150.53,94.11 150.37,94.11 150.28,94.02 150.28,93.37 150.19,93.28 149.93,93.28 149.69,93.04 149.56,93.04 149.49,93.11 149.36,93.11 149.24,92.99 149.24,92.87 149.32,92.79 149.32,92.67 148.99,92.34 148.77,92.34 148.69,92.43 148.69,92.82 148.6,92.91 148.43,92.91 148.34,92.82 148.34,92.43 148.25,92.34 145.43,92.34 144.86,91.77 141.59,91.77 141.5,91.86 141.5,92.02 141.41,92.11 141.24,92.11 141.16,92.02 141.16,91.86 141.07,91.77 140.9,91.77 140.81,91.86 140.81,92.35 140.72,92.44 140.56,92.44 140.47,92.35 140.47,91.86 140.38,91.77 140.22,91.77 140.13,91.86 140.13,92.38 140.07,92.44 139.86,92.44 139.78,92.37 139.78,91.86 139.7,91.77 135.89,91.77 135.14,91.01 133.79,91.01 133.63,90.85 133.5,90.85 133.15,91.21 133.02,91.21 132.91,91.09 132.91,90.97 133.26,90.61 133.26,90.49 133.15,90.37 133.02,90.37 132.63,90.75 132.51,90.75 132.39,90.64 132.39,90.51 132.78,90.13 132.78,90 132.66,89.88 132.53,89.88 132.15,90.27 132.02,90.27 131.91,90.15 131.91,90.03 132.29,89.64 132.29,89.52 132.03,89.25 129.77,89.25 129.69,89.33 128.94,89.33 127.19,87.58 124.61,87.58 122.74,85.71 122.74,84.92 121.6,83.79 121.6,83.33 121.22,82.95 121.22,81.42 121.48,81.17 121.48,80.05 v1(121.9,79.63)
DDR4_DDIMM2_DQ66: length 55.1
  L12_SIG4 w0.089: v1(121.1,79.17) 120.31,79.17 arc(120.09,79.11) 119.92,78.96 119.9,78.92 arc(119.73,78.77) 119.51,78.71 119.49,78.71 arc(119.27,78.64) 119.11,78.48 arc(118.95,78.32) 118.74,78.25 118.71,78.25 arc(118.49,78.3) 118.33,78.46 118.3,78.5 arc(118.14,78.65) 117.92,78.71 117.89,78.71 arc(117.68,78.78) 117.52,78.94 arc(117.48,78.99) 117.44,79.04 117.11,79.37 117.11,80.25 116.03,81.34 116.03,84.39 115.56,84.85 115.56,86.48 117.05,87.97 117.56,87.97 119.67,90.09 120.94,90.09 123.31,92.46 123.33,92.46 123.38,92.51 126.26,92.51 128.93,95.17 129.5,95.17 131.07,96.75 131.4,96.75 131.64,96.51 131.64,96.18 131.77,96.05 132.58,96.05 133.74,97.2 133.96,97.2 134.73,97.97 135.56,97.97 135.68,98.08 135.68,98.21 135.49,98.39 135.49,98.52 135.61,98.64 135.74,98.64 135.92,98.45 136.05,98.45 136.25,98.66 137.45,98.66 137.83,98.28 139.14,98.28 139.53,98.66 139.86,98.66 140.23,98.29 141.56,98.29 142.08,98.81 142.41,98.81 142.86,98.37 144.41,98.37 144.68,98.63 145.01,98.63 145.75,97.89 146.65,97.89 146.85,98.09 147.87,98.09 148.12,98.35 148.12,98.47 147.88,98.71 147.88,98.84 148,98.95 148.13,98.95 148.37,98.71 148.49,98.71 v1(148.99,99.22)
DDR4_DDIMM2_DQ67: length 53.5
  L12_SIG4 w0.089: v1(121.1,81.01) 120.75,81.36 120.75,81.55 120.19,82.11 120.19,83.42 120.45,83.68 121.06,83.68 121.13,83.75 121.13,83.98 121.23,84.08 121.23,84.21 120.91,84.54 120.91,84.66 121.01,84.77 121.16,84.77 121.48,84.45 121.6,84.45 121.72,84.57 121.72,84.69 121.51,84.9 121.51,84.99 121.64,85.13 121.77,85.13 121.96,84.94 122.09,84.94 122.27,85.12 122.27,85.47 122.17,85.57 121.63,85.57 121.51,85.69 121.51,85.99 121.6,86.08 122.44,86.08 124.42,88.05 127,88.05 128.74,89.8 129.98,89.8 130.07,89.89 130.07,90.07 130.16,90.16 130.32,90.16 130.41,90.07 130.41,89.89 130.58,89.72 131.32,89.72 131.41,89.81 131.41,90.01 130.79,90.63 130.79,90.78 130.9,90.88 131.03,90.88 131.42,90.49 131.58,90.49 131.7,90.61 131.7,90.73 131.3,91.12 131.3,91.25 131.42,91.36 131.55,91.36 131.92,90.99 132.05,90.99 132.17,91.1 132.17,91.23 131.93,91.46 131.93,91.59 132.03,91.68 132.2,91.68 132.41,91.47 132.53,91.47 132.74,91.68 133.34,91.68 133.52,91.5 133.95,91.5 134.12,91.67 134.29,91.67 134.46,91.5 134.96,91.5 135.12,91.66 135.12,91.79 134.84,92.07 134.84,92.2 134.96,92.31 135.09,92.31 135.3,92.1 135.56,92.1 135.7,92.24 135.78,92.24 135.92,92.38 135.92,93.12 136.03,93.23 136.31,93.23 136.42,93.12 136.42,92.29 136.47,92.24 136.7,92.24 136.77,92.3 136.77,92.87 136.88,92.98 137.02,92.98 137.11,92.89 137.11,92.29 137.16,92.24 137.39,92.24 137.45,92.3 137.45,92.82 137.54,92.91 138.31,92.91 138.4,93 138.4,93.17 138.49,93.26 138.65,93.26 138.74,93.17 138.74,92.94 138.84,92.84 138.99,92.84 139.08,92.93 139.08,93.17 139.17,93.26 139.34,93.26 139.43,93.17 139.43,93 139.51,92.91 140.9,92.91 140.99,93 140.99,93.16 141.08,93.25 141.24,93.25 141.33,93.16 141.33,92.69 141.43,92.58 141.6,92.58 141.95,92.24 142.04,92.24 142.13,92.33 142.13,92.64 142.22,92.73 142.38,92.73 142.47,92.64 142.47,92.33 142.56,92.24 142.73,92.24 142.82,92.33 142.82,92.64 142.91,92.73 143.07,92.73 143.16,92.64 143.16,92.33 143.25,92.24 143.41,92.24 143.5,92.33 143.5,92.64 143.59,92.73 143.76,92.73 143.84,92.64 143.84,92.33 143.93,92.24 144.1,92.24 144.19,92.33 144.19,92.84 144.31,92.95 144.44,92.95 144.53,92.87 144.53,92.41 144.62,92.32 144.75,92.32 145.24,92.81 147.74,92.81 147.87,92.94 147.87,93.21 148,93.34 v1(148.19,93.34)
DDR4_DDIMM2_DQ68: length 56.4
  L12_SIG4 w0.089: v1(156.64,97.95) 156.64,98.23 156.38,98.49 155.86,98.49 155.78,98.58 155.78,98.69 155.68,98.78 155.52,98.78 155.43,98.69 155.43,98.58 155.34,98.49 155.18,98.49 155.09,98.58 155.09,98.69 155,98.78 154.84,98.78 154.75,98.69 154.75,98.58 154.66,98.49 154.49,98.49 154.4,98.58 154.4,98.69 154.32,98.78 154.15,98.78 154.06,98.69 154.06,98.58 153.97,98.49 153.81,98.49 153.72,98.58 153.72,98.69 153.63,98.78 153.46,98.78 153.38,98.69 153.38,98.58 153.29,98.49 153.12,98.49 153.03,98.58 153.03,98.69 152.94,98.78 152.78,98.78 152.69,98.69 152.69,98.58 152.6,98.49 152.2,98.49 149.62,95.91 149.19,95.91 149.02,95.74 148.85,95.74 148.68,95.91 144.64,95.91 144.56,95.82 144.56,95.64 144.45,95.54 144.32,95.54 144.21,95.64 144.21,95.82 144.12,95.91 142.73,95.91 142.64,95.82 142.64,95.72 142.55,95.63 142.38,95.63 142.29,95.72 142.29,95.82 142.2,95.91 142.04,95.91 141.95,95.82 141.95,95.6 141.86,95.51 141.7,95.51 141.61,95.6 141.61,95.82 141.52,95.91 141.35,95.91 141.26,95.82 141.26,95.62 141.18,95.53 141.01,95.53 140.92,95.62 140.92,95.82 140.83,95.91 140.67,95.91 140.58,95.82 140.58,95.62 140.49,95.53 140.32,95.53 140.24,95.62 140.24,95.82 140.15,95.91 138.48,95.91 138.39,95.82 138.39,95.54 138.32,95.47 138.12,95.47 138.05,95.54 138.05,95.82 137.96,95.91 137.79,95.91 137.7,95.82 137.7,95.57 137.61,95.48 137.45,95.48 137.36,95.57 137.36,95.82 137.27,95.91 137.11,95.91 137.02,95.82 137.02,95.57 136.93,95.48 136.76,95.48 136.68,95.57 136.68,95.75 136.51,95.92 136.31,95.92 135.82,95.44 135.51,95.44 134.89,94.83 134.33,94.83 134.19,94.69 134.19,94.12 133.89,93.82 131.03,93.82 128.69,91.48 127.9,91.48 127.04,90.63 124.16,90.63 121.37,87.84 120.09,87.84 118.39,86.14 118.39,80.87 v1(118.71,80.55)
DDR4_DDIMM2_DQ69: length 57
  L12_SIG4 w0.089: v1(117.91,81.01) 117.92,81.02 117.92,82 117.92,82.75 117.45,83.22 117.45,86.28 117.74,86.57 118.14,86.57 120.26,88.68 121.54,88.68 123.88,91.02 123.88,91.02 123.97,91.1 126.85,91.1 127.7,91.95 128.49,91.95 130.41,93.87 130.41,93.87 130.83,94.29 133.07,94.29 133.27,94.5 133.27,94.75 134.32,95.79 134.54,95.79 135.27,96.52 135.58,96.52 135.72,96.39 149.44,96.39 152.01,98.96 152.02,98.96 152.08,99.02 arc(152.33,99.19) 152.64,99.25 154.67,99.25 154.79,99.25 155.82,99.25 arc(156.24,99.17) 156.6,98.93 157.04,98.49 arc(157.16,98.31) 157.2,98.1 157.2,96.7 arc(157.18,96.62) 157.14,96.55 156.63,96.04 arc(156.52,95.96) 156.39,95.94 156.28,95.94 arc(156.13,95.91) 156,95.83 155.82,95.65 arc(155.75,95.54) 155.72,95.4 155.72,93.47 v1(155.84,93.34)
DDR4_DDIMM2_DQ70: length 55.3
  L12_SIG4 w0.089: v1(118.71,79.63) 118.3,80.34 arc(118.14,80.49) 117.92,80.55 117.7,80.55 116.97,81.28 116.97,81.63 117.06,81.71 117.34,81.71 117.44,81.81 117.44,81.97 117.35,82.06 117.06,82.06 116.97,82.15 116.97,82.31 117.06,82.4 117.24,82.4 117.33,82.49 117.33,82.65 117.24,82.74 117.07,82.74 116.98,82.83 116.98,86.47 117.54,87.04 117.95,87.04 120.06,89.15 121.34,89.15 123.68,91.49 123.69,91.49 123.77,91.57 126.65,91.57 127.51,92.42 128.21,92.42 129.12,93.34 129.12,94 129.36,94.23 130.02,94.23 130.88,95.1 132.96,95.1 134.13,96.26 134.35,96.26 135.08,96.99 135.78,96.99 135.91,96.86 147.87,96.86 147.96,96.95 147.96,97.53 148.07,97.63 148.19,97.63 148.3,97.53 148.3,96.95 148.39,96.86 149.24,96.86 149.4,97.02 149.4,97.15 148.57,97.98 148.57,98.1 148.68,98.22 148.81,98.22 149.64,97.39 149.77,97.39 149.88,97.5 149.88,97.63 149.05,98.46 149.05,98.59 149.17,98.7 149.29,98.7 150.13,97.87 150.25,97.87 150.79,98.41 v1(150.79,99.22)
DDR4_DDIMM2_DQ71: length 55.9
  TOP w0.149: v1(147.28,97.28) 148.57,97.28 149.89,95.95 J1.199
  L12_SIG4 w0.089: v1(117.92,79.17) 117.46,79.63 117.46,80.32 116.5,81.28 116.5,84.59 116.03,85.05 116.03,86.29 117.25,87.5 117.75,87.5 119.87,89.62 121.13,89.62 123.5,91.99 123.53,91.99 123.58,92.04 126.46,92.04 127.58,93.16 127.71,93.16 127.91,92.95 128.04,92.95 128.16,93.07 128.16,93.19 127.95,93.4 127.95,93.53 128.06,93.65 128.19,93.65 128.4,93.44 128.53,93.44 128.64,93.55 128.64,93.68 128.43,93.89 128.43,94.01 129.12,94.7 129.82,94.7 130.69,95.57 132.77,95.57 133.93,96.73 134.15,96.73 134.92,97.5 136.21,97.5 136.49,97.78 136.98,97.78 137.07,97.69 137.07,97.46 137.16,97.37 137.33,97.37 137.41,97.46 137.41,97.69 137.5,97.78 138.95,97.78 139.04,97.69 139.04,97.44 139.13,97.35 139.29,97.35 139.38,97.44 139.38,97.69 139.47,97.78 139.63,97.78 139.72,97.69 139.72,97.44 139.81,97.35 139.98,97.35 140.07,97.44 140.07,97.69 140.16,97.78 140.32,97.78 140.41,97.69 140.41,97.44 140.5,97.35 140.66,97.35 140.75,97.44 140.75,97.69 140.84,97.78 141.01,97.78 141.09,97.69 141.09,97.44 141.18,97.35 141.35,97.35 141.44,97.44 141.44,97.69 141.53,97.78 141.69,97.78 141.78,97.69 141.78,97.44 141.87,97.35 142.03,97.35 142.12,97.44 142.12,97.69 142.21,97.78 142.38,97.78 142.47,97.69 142.47,97.44 142.56,97.35 142.72,97.35 142.81,97.44 142.81,97.69 143.01,97.89 143.76,97.89 143.96,97.69 143.96,97.44 144.05,97.35 144.22,97.35 144.31,97.44 144.31,97.69 144.4,97.78 144.94,97.78 145.31,97.41 147.15,97.41 v1(147.28,97.28)
DDR4_DDIMM2_DQS_N0: length 118.2
  L12_SIG4 w0.076: 108.72,81.21 108.72,81 108.72,80.98 arc(108.71,80.9) 108.68,80.84 108.67,80.82 arc(108.6,80.58) 108.65,80.32 arc(108.65,80.32) 108.65,80.31 108.68,80.27 arc(108.73,80.09) 108.68,79.9 arc(108.6,79.63) 108.67,79.36 108.68,79.35 108.73,79.26 arc(108.74,79.24) 108.74,79.22 108.74,79.17 arc(108.73,79.1) 108.71,79.04 108.66,78.96 arc(108.53,78.84) 108.36,78.8 108.32,78.8 arc(108.1,78.74) 107.93,78.59 arc(107.92,78.59) 107.92,78.58 107.83,78.55 v1(107.56,78.71)
  L12_SIG4 w0.089: 108.72,81.21 107.92,82.01 107.92,88.27 108.52,88.87 108.52,88.99 108.24,89.27 108.24,89.56 108.47,89.79 108.75,89.79 109.03,89.51 109.16,89.51 109.27,89.62 109.27,89.75 108.99,90.03 108.99,90.31 109.22,90.54 109.5,90.54 109.79,90.26 109.91,90.26 110.87,91.22 110.87,91.35 110.55,91.67 110.55,91.95 110.78,92.18 111.06,92.18 111.39,91.86 111.51,91.86 112.05,92.4 112.05,93.78 111.93,93.89 111.93,94.57 112.34,94.97 112.34,95.46 113.15,96.28 113.66,96.28 114.68,97.3 114.99,97.3 115.66,97.97 115.66,98.52 117.57,100.44 118.78,100.44 119.14,100.79 119.14,100.92 118.93,101.13 118.93,101.41 119.16,101.64 119.44,101.64 119.65,101.43 119.77,101.43 119.99,101.65 120.47,101.65 120.56,101.73 120.56,101.95 120.76,102.15 121.08,102.15 121.28,101.95 121.28,101.73 121.37,101.65 122.25,101.65 122.34,101.73 122.34,102.03 122.54,102.23 122.86,102.23 123.06,102.03 123.06,101.73 123.15,101.65 124.14,101.65 124.23,101.56 124.24,101.56 125.07,100.72 125.38,100.72 125.54,100.88 127.94,100.88 130.05,103 133.96,103 134.46,102.5 136.4,102.5 136.69,102.78 139.4,102.78 139.57,102.62 145.78,102.62 145.81,102.64 145.95,102.64 146.55,103.24 153.82,103.24 154.65,104.07 158.13,104.07 158.78,103.42 171.33,103.42 171.76,102.99 182.85,102.99 183.16,102.68 186.58,102.68 187.95,101.31 187.95,100.47 188.27,100.16 188.27,97.44 189.51,96.19 189.51,95.76 189.6,95.67 190.52,95.67 190.73,95.46 190.73,95.14 190.53,94.94 189.6,94.94 189.51,94.86 189.51,93.98 189.83,93.66 v1(189.84,93.66)
DDR4_DDIMM2_DQS_N1: length 95.3
  L12_SIG4 w0.076: v1(121.9,78.71) 122.17,78.55 122.19,78.47 arc(122.16,78.4) 122.13,78.32 arc(122.12,78.21) 122.15,78.1 122.27,77.89 arc(122.41,77.75) 122.6,77.7 122.86,77.7 arc(122.9,77.69) 122.92,77.67 123.01,77.53 123.02,77.51 arc(123.07,77.33) 123.02,77.14 123.01,77.12 arc(122.94,76.86) 123.02,76.6 123.02,76.59 arc(123.22,76.39) 123.49,76.32 123.51,76.32 arc(123.69,76.27) 123.81,76.13 arc(124.01,75.94) 124.28,75.86 124.29,75.86 arc(124.47,75.81) 124.6,75.69 124.62,75.66 arc(124.82,75.47) 125.09,75.4 arc(125.27,75.35) 125.41,75.22 125.41,75.21 arc(125.61,75.01) 125.88,74.94 125.89,74.94 arc(126.16,75.02) 126.36,75.21 arc(126.49,75.35) 126.68,75.4 126.69,75.4 arc(126.96,75.48) 127.16,75.67 arc(127.29,75.81) 127.47,75.86 127.48,75.86 arc(127.75,75.93) 127.95,76.13 127.96,76.14 arc(128.09,76.27) 128.27,76.32 arc(128.28,76.32) 128.28,76.32 128.28,76.32 arc(128.55,76.4) 128.75,76.59 arc(128.76,76.61) 128.77,76.64 arc(128.88,76.74) 129.03,76.78 129.18,76.78 arc(129.26,76.79) 129.34,76.82 arc(129.41,76.87) 129.47,76.93 129.54,77.05 arc(129.72,77.21) 129.94,77.27 arc(130.15,77.32) 130.3,77.47 arc(130.32,77.51) 130.33,77.55 130.35,77.59 arc(130.4,77.67) 130.49,77.7 130.66,77.7 arc(130.85,77.65) 130.99,77.52 131,77.5 arc(131.15,77.33) 131.36,77.25 arc(131.37,77.25) 131.38,77.25 131.38,77.25 arc(131.61,77.21) 131.78,77.06 131.79,77.05 arc(131.99,76.85) 132.26,76.78 132.27,76.78 arc(132.54,76.86) 132.73,77.05 arc(132.86,77.19) 133.03,77.25 arc(133.18,77.28) 133.33,77.34 arc(133.34,77.35) 133.35,77.35 133.6,77.6 arc(133.72,77.68) 133.86,77.7 arc(134,77.68) 134.11,77.6 134.34,77.38 arc(134.37,77.36) 134.39,77.34 arc(134.43,77.31) 134.47,77.29 arc(134.47,77.29) 134.47,77.29 arc(134.58,77.27) 134.68,77.26 138.08,77.26 138.53,77.71 arc(138.63,77.75) 138.72,77.81 139.01,78.1 arc(139.07,78.15) 139.15,78.16 139.54,78.16 arc(139.75,78.22) 139.89,78.39 arc(140.23,78.62) 140.57,78.39 arc(140.7,78.22) 140.91,78.16 141.11,78.16 arc(141.33,78.23) 141.48,78.4 arc(141.53,78.48) 141.59,78.54 arc(141.61,78.56) 141.63,78.58 arc(141.63,78.58) 141.64,78.58 arc(141.91,78.61) 142.14,78.44 142.18,78.37 arc(142.2,78.33) 142.23,78.3 142.29,78.24 arc(142.38,78.18) 142.48,78.16 142.65,78.16 arc(142.83,78.19) 142.98,78.3 143.01,78.33 arc(143.07,78.39) 143.11,78.46 arc(143.24,78.6) 143.42,78.65 147.01,78.65 arc(147.06,78.64) 147.1,78.61
  L12_SIG4 w0.089: v1(180.49,93.34) 180.2,93.05 arc(180.17,93.01) 180.16,92.97 180.16,92.95 arc(180.16,92.95) 180.15,92.95 arc(180.13,92.81) 180.05,92.69 179.86,92.51 arc(179.83,92.49) 179.78,92.48 174.91,92.48 arc(174.87,92.47) 174.83,92.45 173.91,91.52 arc(173.81,91.46) 173.69,91.44 171.9,91.44 arc(171.63,91.38) 171.4,91.23 171.09,90.91 arc(171.05,90.89) 171.01,90.88 170.77,90.88 169.92,91.73 169.8,91.73 169.68,91.61 169.68,91.49 170.53,90.64 170.53,90.36 170.3,90.13 170.02,90.13 169.17,90.98 169.04,90.98 168.93,90.86 168.93,90.73 169.78,89.88 169.78,89.6 169.55,89.37 169.26,89.37 168.42,90.22 168.29,90.22 168.17,90.1 168.17,89.98 169.02,89.13 169.02,88.85 167.69,87.51 arc(167.66,87.47) 167.65,87.43 167.65,87.23 arc(167.63,87.11) 167.56,87.02 167.31,86.77 arc(167.27,86.74) 167.22,86.73 166.95,86.73 arc(166.91,86.72) 166.87,86.69 165.98,85.8 arc(165.93,85.75) 165.9,85.68 arc(165.88,85.64) 165.88,85.6 165.88,81.94 arc(165.85,81.82) 165.79,81.72 164.86,80.79 164.58,80.79 163.33,82.04 163.17,82.04 163.07,81.94 163.07,81.82 164.33,80.55 164.33,80.27 164.11,80.04 163.82,80.04 162.76,81.1 162.64,81.1 162.52,80.98 162.52,80.86 163.58,79.8 163.58,79.51 163.35,79.29 163.07,79.29 162.01,80.35 161.88,80.35 161.76,80.23 161.76,80.1 162.82,79.04 162.82,78.76 162.6,78.53 162.31,78.53 161.25,79.59 161.13,79.59 161.01,79.47 161.01,79.35 162.07,78.29 162.07,78 161.47,77.41 arc(161.38,77.34) 161.26,77.32 148.44,77.32 arc(148.4,77.33) 148.36,77.35 148.31,77.41 147.1,78.61
DDR4_DDIMM2_DQS_N2: length 99.7
  L14_SIG5 w0.076: 144.26,71.72 144.27,71.71 144.27,71.42 arc(144.27,71.37) 144.26,71.31 arc(144.11,71.08) 143.86,70.99 143.47,70.99 arc(143.4,70.98) 143.34,70.95 arc(143.22,70.85) 143.13,70.73 arc(142.63,70.5) 142.17,70.78 arc(141.8,70.99) 141.43,70.78 141.42,70.76 141.42,70.76 arc(141.22,70.58) 140.96,70.51 140.93,70.51 arc(140.64,70.59) 140.43,70.79 140.42,70.81 arc(140.06,70.99) 139.72,70.79 arc(139.52,70.58) 139.24,70.51 139.2,70.51 139.17,70.51 arc(138.86,70.59) 138.64,70.81 arc(138.31,71) 137.98,70.81 137.97,70.8 arc(137.97,70.8) 137.97,70.79 arc(137.76,70.59) 137.48,70.51 137.47,70.51 arc(137.47,70.51) 137.46,70.51 arc(137.17,70.59) 136.96,70.8 136.95,70.82 arc(136.6,71.02) 136.25,70.82 136.24,70.8 arc(136.03,70.59) 135.74,70.51 135.73,70.51 arc(135.43,70.59) 135.22,70.8 135.21,70.81 arc(135.07,70.96) 134.87,71.01 arc(134.87,71.01) 134.87,71.01 arc(134.66,70.95) 134.51,70.8 arc(134.39,70.65) 134.22,70.55 arc(134.16,70.53) 134.1,70.52 arc(133.89,70.46) 133.71,70.32 133.6,70.22 arc(133.59,70.21) 133.58,70.19 arc(133.57,70.18) 133.56,70.17 arc(133.54,70.14) 133.51,70.12 133.38,69.99 arc(133.3,69.93) 133.19,69.91 132.91,69.91 arc(132.78,69.94) 132.68,70.03 132.52,70.24 arc(132.23,70.37) 131.96,70.2 131.88,70.07 arc(131.72,69.91) 131.5,69.85 131.42,69.85 arc(131.22,69.9) 131.07,70.04 130.94,70.26 arc(130.75,70.4) 130.52,70.35 130.52,70.34 arc(130.52,70.34) 130.51,70.34 arc(130.51,70.34) 130.5,70.33 arc(130.5,70.33) 130.49,70.33 130.48,70.32 arc(130.38,70.22) 130.31,70.1 arc(130.24,69.99) 130.15,69.9 130.09,69.86 arc(129.99,69.81) 129.87,69.8 129.77,69.82 arc(129.64,69.87) 129.53,69.94 129.5,69.98 arc(129.47,70.01) 129.45,70.05 129.41,70.13 arc(129.12,70.34) 128.77,70.23 arc(128.77,70.22) 128.76,70.21 arc(128.65,70.04) 128.49,69.92 arc(128.39,69.89) 128.28,69.88 128.19,69.88 arc(128.01,69.93) 127.87,70.05 127.77,70.21 arc(127.66,70.31) 127.51,70.36 arc(127.27,70.42) 127.07,70.56 126.91,70.72 arc(126.68,70.82) 126.45,70.72 126.25,70.53 arc(126.08,70.41) 125.88,70.37 124.51,70.37 arc(124.27,70.32) 124.06,70.19 123.83,69.95 arc(123.54,69.84) 123.25,69.97 123.05,70.17 arc(122.67,70.36) 122.26,70.24 arc(121.8,70.1) 121.36,70.28 arc(121.09,70.37) 120.85,70.24 arc(120.35,70.01) 119.84,70.22 119.79,70.27 arc(119.72,70.33) 119.64,70.37 arc(119.6,70.38) 119.55,70.38 arc(119.55,70.38) 119.55,70.38 arc(119.5,70.38) 119.44,70.39 arc(119.39,70.39) 119.35,70.37 arc(119.28,70.34) 119.22,70.3 arc(118.73,70.13) 118.24,70.31 arc(117.89,70.4) 117.6,70.19 117.6,70.19 arc(117.6,70.19) 117.6,70.19 arc(117.56,70.11) 117.52,70.05 arc(117.35,69.93) 117.14,69.88 arc(116.97,69.91) 116.82,70 116.56,70.27 arc(116.46,70.34) 116.34,70.36 116.21,70.36 arc(116.12,70.35) 116.05,70.3 115.71,69.96 arc(115.63,69.9) 115.53,69.88 115.48,69.88 arc(115.44,69.89) 115.4,69.89 arc(115.24,69.97) 115.12,70.1 115.07,70.18 arc(114.94,70.31) 114.76,70.36 114.68,70.36 arc(114.44,70.42) 114.25,70.58 arc(114.09,70.73) 113.88,70.8 arc(113.64,70.88) 113.47,71.06 arc(113.3,71.22) 113.08,71.3 arc(112.69,71.55) 112.67,72.01 112.69,72.07 arc(112.73,72.23) 112.69,72.38 112.61,72.56 arc(112.56,72.79) 112.63,73.02 112.69,73.13 arc(112.71,73.17) 112.72,73.22 arc(112.71,73.27) 112.69,73.32 112.66,73.37 arc(112.52,73.51) 112.34,73.56 112.34,73.56 arc(112.1,73.61) 111.91,73.77 arc(111.9,73.77) 111.9,73.78 111.81,73.8 v1(111.54,73.65)
  L14_SIG5 w0.081: 144.26,71.72 144.26,71.99 arc(144.28,72.12) 144.36,72.24 144.65,72.53 arc(144.71,72.61) 144.73,72.71 144.73,83.81 arc(144.73,83.84) 144.75,83.87 149.73,88.85 arc(149.76,88.87) 149.8,88.88 150.57,88.88 arc(150.78,88.97) 150.87,89.18 150.87,89.92 arc(150.91,90) 150.98,90.03 151.09,90.03 arc(151.12,90.02) 151.15,90 151.21,89.95 151.21,89.07 151.4,88.88 151.72,88.88 151.91,89.07 151.91,89.95 151.99,90.03 152.16,90.03 152.24,89.95 152.24,89.07 152.43,88.88 152.76,88.88 152.94,89.07 152.94,89.95 153.03,90.03 153.2,90.03 153.28,89.95 153.28,89.07 153.47,88.88 153.79,88.88 153.98,89.07 153.98,89.95 154.06,90.03 154.24,90.03 154.32,89.95 154.32,89.07 154.5,88.88 154.83,88.88 155.02,89.07 155.02,89.95 155.1,90.03 155.27,90.03 155.35,89.95 155.35,89.07 155.54,88.88 155.87,88.88 156.05,89.07 156.05,89.95 156.14,90.03 156.31,90.03 156.39,89.95 156.39,89.07 156.58,88.88 156.9,88.88 157.09,89.07 157.09,89.95 157.17,90.03 157.34,90.03 157.43,89.95 157.43,89.07 157.61,88.88 157.94,88.88 158.13,89.07 158.13,89.95 158.21,90.03 158.38,90.03 158.46,89.95 158.46,89.07 158.65,88.88 160.1,88.88 162.43,91.21 163.61,91.21 163.83,91.44 168.36,91.44 169.71,92.8 170.38,92.8 170.93,93.36 v1(171.11,93.36)
