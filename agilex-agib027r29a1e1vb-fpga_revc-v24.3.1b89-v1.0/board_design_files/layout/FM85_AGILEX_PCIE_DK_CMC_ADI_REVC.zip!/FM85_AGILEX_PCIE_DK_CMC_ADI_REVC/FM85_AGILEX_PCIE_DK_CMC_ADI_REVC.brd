# Allegro board FM85_AGILEX_PCIE_DK_CMC_ADI_REVC.brd (continued)
## Library data of the parts (continued)
R235-R237 = RES 0 OHM 5% 1/16W 0402 SMD: User Part Number: PART#; Tolerance: TOL; signal model: RESISTOR_0402_10K_10K
R356 R359 R361 R363 R364 R2741 = RESISTOR_0: Tolerance: TOL; User Part Number: PART#
R357 R943 R945 R5853 R5875-R5878 R5923 R5924 R5944-R5946 R6024 R6025 R6036 R6037 R6053 R6074 R6145 R6154 R6156 R6262 R6264 R6275 = Resistor, 0402: Tolerance: TOL; User Part Number: PART#
R378 = RESISTOR: User Part Number: PART#; Tolerance: TOL; signal model: RESISTOR_0402_22_22
R391 = RESISTOR: User Part Number: PART#; Tolerance: TOL; signal model: RESISTOR_0402_10_10
R436-R439 R441 R442 = RESISTOR: User Part Number: PART#; Tolerance: TOL; signal model: RESISTOR_0402_DNI_DNI
R440 R443 R446 R447 = RESISTOR: User Part Number: PART#; Tolerance: TOL; signal model: RESISTOR_0402_33.2_33.2
R477 R486 R497 R579 R964 = RES: User Part Number: PART#; Tolerance: TOL
R768 R2739 R6044 R6051 R6069 R6089 R6096 R6174-R6176 R6216 R6217 R6273 R6274 R6276 = Resistor, 0402: User Part Number: PART#; Tolerance: TOL
R853 R5884-R5888 R5890 R5891 R5893 R5894 R6067 R6068 R6075 R6255-R6258 R6277-R6279 R6291 R6292 R6297-R6299 = Resistor, 0402_0: Tolerance: TOL; User Part Number: PART#
R932 R933 = RES 0 OHM 5% 1/16W 0402 SMD: Tolerance: TOL; User Part Number: PART#; signal model: RES_0_OHM_5%_1/16W_0402_SMD_0402_0_0
R976 = RES: Tolerance: TOL; User Part Number: PART#
R1070 = RES 0 OHM 5% 1/16W 0402 SMD: User Part Number: PART#; Tolerance: TOL; signal model: RES_0_OHM_5%_1/16W_0402_SMD_0402_DNI_DNI
R1071 = RES 0 OHM 5% 1/16W 0402 SMD: User Part Number: PART#; Tolerance: TOL; signal model: RES_0_OHM
R1074 R1076 = RES 0 OHM 5% 1/16W 0402 SMD: Tolerance: TOL; User Part Number: PART#; signal model: RES_0_OHM
R2206 = RES_VERT_HORIZ: User Part Number: ER#04024K7FT; Tolerance: TOL; alternate symbols: (0402CIR_M)
R2635 R2653 R2654 R2742 R2743 R6193 = RES_VERT_HORIZ
R2637 R6192 = RES_VERT_HORIZ: room: DNI
R2691-R2698 = RES_VERT_HORIZ: signal model: RES1-2
R2736 = RESISTOR: User Part Number: PART#; Tolerance: TOL; signal model: RESISTOR_0402_22.0_22.0
R5954 = RES 0 OHM 5% 1/16W 0402 SMD
R6039 R6040 R6066 = Resistor, 0402_0: User Part Number: PART#; Tolerance: TOL
R6041 = Resistor, 0603_0: Tolerance: *; User Part Number: *
R6050 R6101 = RESISTOR
R6213 R6224 R6225 = RESISTOR: User Part Number: PART#; Tolerance: TOL; signal model: RES1-2_
R6317 R6318 = RESISTOR: Tolerance: TOL; User Part Number: PART#; signal model: RESISTOR_0402_0__DNI_0__DNI
S1-S5 = TS-A02SA-2-S100_0: User Part Number: *
ST1-ST3 ST6 ST9 ST10 ST13 ST17 ST18 ST20 ST23-ST32 ST34 = SHORT: User Part Number: *
SW1-SW5 SW8 = SPST4
SW6 = SW_SLIDE_DPDT: User Part Number: PART#; Tolerance: TOL
TP1 TP29 TP1000-TP1002 = TESTPOINT
TP8 TP9 TP14 TP15 TP18 TP24 TP25 TP27 TP28 TP950 TP951 TP954-TP977 TP979-TP992 TP994-TP999 TP1004-TP1008 = TP, 0.016", Thru Hole
TP19-TP22 = PAD_STYLE_C
U1-U5 U7-U11 = MT40A1G16HBA-083E_0
U6 = AgileX-I_2957A
U12 U28 U29 = MAX3378E_0: Tolerance: TOL; User Part Number: PN
U13 U15 U18 U30-U32 = MAX3378E_0: User Part Number: PN; Tolerance: TOL
U14 = FPC202
U16 = 24AA024
U17 = SN74LVC1G08_0
U19 = SN74AUP1G126DCK
U21 = REF1112
U22 = Si5341A-A-GM_0
U23 = Si52204
U24 U25 = Si53254A-D02AM
U26 U27 = FXMA2102UMX
U33 = MAX811
U34 = 10M50DA F256
U35 = TPD2EUSB30: User Part Number: *; Tolerance: *
U36 = MT25QU01GBBB: User Part Number: ICM000214; Tolerance: *
U38 = TS3A5018RSVR_0
U39 U41 = SN74LVC2G17DCKR
U40 U42 U105 U106 = MAX3002EUP+T
U43 = M24128
U44 U45 U49 U50 U87 = FDMC8878_VER2: User Part Number: *
U46 U51 = LTC4357: User Part Number: *
U47 U52 U88 = LTC4365_DFN: User Part Number: *
U48 = LTC4359
U53 = TPS3700: User Part Number: pn
U66 U67 = LTM4657-BGA_0
U68 U69 U71 U137 = LTC3543EDCB_0
U84 U85 U108 = TPS51200: User Part Number: *
U103 = W956D8MBYA6I
U104 = MT25QU01GBBB: Tolerance: *; User Part Number: ICM000214
U107 = TCA9539RTWR
U114 U139 = LTM4643EY#PBF
U116 = LTM4622EV#PBF
U117 = LTM4668IY#PBF
U118 U136 = LTM4686EV-1#PBF
U119 = LTC3888IUHG-1#PBF
U120 U121 U125 U126 = LTC7051AV#PBF
U122 = LTC4625EY
U123 U124 U128 U133 U134 U142 = LTM4623EY#PBF
U129 = MAX15053EWL+T
U130 U131 = ADP1752ACPZ-1.0-R7
U132 = LT3042IDD#PBF_0
U135 = LTM4678EY#PBF
U138 = LTM4643EY#PBF: tolerance: Hk
U141 = TCA9517A
U143 = CY7C68013A_56QFN: User Part Number: *
Y1 = CRYSTAL_SM_13
Y2 Y3 = CRYSTAL_SM_13: User Part Number: *
Y4 = KC2520Z100.000C15XXK

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
1X3_HDR_TH
  rect 1.524x1.524 hole 1.016: 1(0,0)
  round 1.524 hole 1.016: 2(2.54,0) 3(5.08,0)
8MM_CAN
  rect 2.032x4.013 smd: 1(0,3.257) 2(0,-3.257)
20-TSSOP
  rect 0.406x1.778 smd: 1(-2.925,-2.946) 2(-2.275,-2.946) 3(-1.625,-2.946) 4(-0.975,-2.946) 5(-0.325,-2.946) 6(0.325,-2.946) 7(0.975,-2.946) 8(1.625,-2.946) 9(2.275,-2.946) 10(2.925,-2.946) 11(2.925,2.946) 12(2.275,2.946) 13(1.625,2.946) 14(0.975,2.946) 15(0.325,2.946) 16(-0.325,2.946) 17(-0.975,2.946) 18(-1.625,2.946) 19(-2.275,2.946) 20(-2.925,2.946)
30MIL_TP
  round 0.762 smd: 1(0,0)
0201
  rect 0.45x0.4 smd: 1(-0.35,0) 2(0.35,0)
256FBGA
  round 1.016 smd: (-9.5,-9.5) (9.5,9.5)
  round 0.457 smd: A1(-7.5,7.5) A2(-6.5,7.5) A3(-5.5,7.5) A4(-4.5,7.5) A5(-3.5,7.5) A6(-2.5,7.5) A7(-1.5,7.5) A8(-0.5,7.5) A9(0.5,7.5) A10(1.5,7.5) A11(2.5,7.5) A12(3.5,7.5) A13(4.5,7.5) A14(5.5,7.5) A15(6.5,7.5) A16(7.5,7.5) B1(-7.5,6.5) B2(-6.5,6.5) B3(-5.5,6.5) B4(-4.5,6.5) B5(-3.5,6.5) B6(-2.5,6.5) B7(-1.5,6.5) B8(-0.5,6.5) B9(0.5,6.5) B10(1.5,6.5) B11(2.5,6.5) B12(3.5,6.5) B13(4.5,6.5) B14(5.5,6.5) B15(6.5,6.5) B16(7.5,6.5) C1(-7.5,5.5) C2(-6.5,5.5) C3(-5.5,5.5) C4(-4.5,5.5) C5(-3.5,5.5) C6(-2.5,5.5) C7(-1.5,5.5) C8(-0.5,5.5) C9(0.5,5.5) C10(1.5,5.5) C11(2.5,5.5) C12(3.5,5.5) C13(4.5,5.5) C14(5.5,5.5) C15(6.5,5.5) C16(7.5,5.5) D1(-7.5,4.5) D2(-6.5,4.5) D3(-5.5,4.5) D4(-4.5,4.5) D5(-3.5,4.5) D6(-2.5,4.5) D7(-1.5,4.5) D8(-0.5,4.5) D9(0.5,4.5) D10(1.5,4.5) D11(2.5,4.5) D12(3.5,4.5) D13(4.5,4.5) D14(5.5,4.5) D15(6.5,4.5) D16(7.5,4.5) E1(-7.5,3.5) E2(-6.5,3.5) E3(-5.5,3.5) E4(-4.5,3.5) E5(-3.5,3.5) E6(-2.5,3.5) E7(-1.5,3.5) E8(-0.5,3.5) E9(0.5,3.5) E10(1.5,3.5) E11(2.5,3.5) E12(3.5,3.5) E13(4.5,3.5) E14(5.5,3.5) E15(6.5,3.5) E16(7.5,3.5) F1(-7.5,2.5) F2(-6.5,2.5) F3(-5.5,2.5) F4(-4.5,2.5) F5(-3.5,2.5) F6(-2.5,2.5) F7(-1.5,2.5) F8(-0.5,2.5) F9(0.5,2.5) F10(1.5,2.5) F11(2.5,2.5) F12(3.5,2.5) F13(4.5,2.5) F14(5.5,2.5) F15(6.5,2.5) F16(7.5,2.5) G1(-7.5,1.5) G2(-6.5,1.5) G3(-5.5,1.5) G4(-4.5,1.5) G5(-3.5,1.5) G6(-2.5,1.5) G7(-1.5,1.5) G8(-0.5,1.5) G9(0.5,1.5) G10(1.5,1.5) G11(2.5,1.5) G12(3.5,1.5) G13(4.5,1.5) G14(5.5,1.5) G15(6.5,1.5) G16(7.5,1.5) H1(-7.5,0.5) H2(-6.5,0.5) H3(-5.5,0.5) H4(-4.5,0.5) H5(-3.5,0.5) H6(-2.5,0.5) H7(-1.5,0.5) H8(-0.5,0.5) H9(0.5,0.5) H10(1.5,0.5) H11(2.5,0.5) H12(3.5,0.5) H13(4.5,0.5) H14(5.5,0.5) H15(6.5,0.5) H16(7.5,0.5) J1(-7.5,-0.5) J2(-6.5,-0.5) J3(-5.5,-0.5) J4(-4.5,-0.5) J5(-3.5,-0.5) J6(-2.5,-0.5) J7(-1.5,-0.5) J8(-0.5,-0.5) J9(0.5,-0.5) J10(1.5,-0.5) J11(2.5,-0.5) J12(3.5,-0.5) J13(4.5,-0.5) J14(5.5,-0.5) J15(6.5,-0.5) J16(7.5,-0.5) K1(-7.5,-1.5) K2(-6.5,-1.5) K3(-5.5,-1.5) K4(-4.5,-1.5) K5(-3.5,-1.5) K6(-2.5,-1.5) K7(-1.5,-1.5) K8(-0.5,-1.5) K9(0.5,-1.5) K10(1.5,-1.5) K11(2.5,-1.5) K12(3.5,-1.5) K13(4.5,-1.5) K14(5.5,-1.5) K15(6.5,-1.5) K16(7.5,-1.5) L1(-7.5,-2.5) L2(-6.5,-2.5) L3(-5.5,-2.5) L4(-4.5,-2.5) L5(-3.5,-2.5) L6(-2.5,-2.5) L7(-1.5,-2.5) L8(-0.5,-2.5) L9(0.5,-2.5) L10(1.5,-2.5) L11(2.5,-2.5) L12(3.5,-2.5) L13(4.5,-2.5) L14(5.5,-2.5) L15(6.5,-2.5) L16(7.5,-2.5) M1(-7.5,-3.5) M2(-6.5,-3.5) M3(-5.5,-3.5) M4(-4.5,-3.5) M5(-3.5,-3.5) M6(-2.5,-3.5) M7(-1.5,-3.5) M8(-0.5,-3.5) M9(0.5,-3.5) M10(1.5,-3.5) M11(2.5,-3.5) M12(3.5,-3.5) M13(4.5,-3.5) M14(5.5,-3.5) M15(6.5,-3.5) M16(7.5,-3.5) N1(-7.5,-4.5) N2(-6.5,-4.5) N3(-5.5,-4.5) N4(-4.5,-4.5) N5(-3.5,-4.5) N6(-2.5,-4.5) N7(-1.5,-4.5) N8(-0.5,-4.5) N9(0.5,-4.5) N10(1.5,-4.5) N11(2.5,-4.5) N12(3.5,-4.5) N13(4.5,-4.5) N14(5.5,-4.5) N15(6.5,-4.5) N16(7.5,-4.5) P1(-7.5,-5.5) P2(-6.5,-5.5) P3(-5.5,-5.5) P4(-4.5,-5.5) P5(-3.5,-5.5) P6(-2.5,-5.5) P7(-1.5,-5.5) P8(-0.5,-5.5) P9(0.5,-5.5) P10(1.5,-5.5) P11(2.5,-5.5) P12(3.5,-5.5) P13(4.5,-5.5) P14(5.5,-5.5) P15(6.5,-5.5) P16(7.5,-5.5) R1(-7.5,-6.5) R2(-6.5,-6.5) R3(-5.5,-6.5) R4(-4.5,-6.5) R5(-3.5,-6.5) R6(-2.5,-6.5) R7(-1.5,-6.5) R8(-0.5,-6.5) R9(0.5,-6.5) R10(1.5,-6.5) R11(2.5,-6.5) R12(3.5,-6.5) R13(4.5,-6.5) R14(5.5,-6.5) R15(6.5,-6.5) R16(7.5,-6.5) T1(-7.5,-7.5) T2(-6.5,-7.5) T3(-5.5,-7.5) T4(-4.5,-7.5) T5(-3.5,-7.5) T6(-2.5,-7.5) T7(-1.5,-7.5) T8(-0.5,-7.5) T9(0.5,-7.5) T10(1.5,-7.5) T11(2.5,-7.5) T12(3.5,-7.5) T13(4.5,-7.5) T14(5.5,-7.5) T15(6.5,-7.5) T16(7.5,-7.5)
0402
  rect 0.508x0.508 smd: 1(0,0.445) 2(0,-0.445)
0603
  rect 1.016x1.016 smd: 1(-0.762,0) 2(0.762,0)
0805
  rect 1.6x1.321 smd: 1(0,0.95) 2(0,-0.95)
1206
  rect 1.27x1.778 smd: 1(-1.524,0) 2(1.524,0)
1210
  rect 1.27x2.794 smd: 1(-1.524,0) 2(1.524,0)
2917
  rect 2.54x2.743 smd: 1(-3.175,0) 2(3.175,0)
3528_2MM
  rect 2.032x2.286 smd: 1(-1.524,0) 2(1.524,0)
7343P
  rect 2.54x2.743 smd: 1(-3.175,0) 2(3.175,0)
7343P_H2MM
  rect 2.54x2.743 smd: 1(-3.175,0) 2(3.175,0)
2027180100
  oval 1.6x0.356 smd: 1(2.4,7) 2(2.4,6.2) 3(2.4,5.4) 4(2.4,4.6) 5(2.4,3.8) 6(2.4,3) 7(2.4,2.2) 8(2.4,1.4) 9(2.4,0.6) 10(2.4,-0.2) 11(2.4,-1) 12(2.4,-1.8) 13(2.4,-2.6) 14(2.4,-3.4) 15(2.4,-4.2) 16(2.4,-5) 17(2.4,-5.8) 18(2.4,-6.6) 19(2.4,-7.4) 20(11.19,-7) 21(11.19,-6.2) 22(11.19,-5.4) 23(11.19,-4.6) 24(11.19,-3.8) 25(11.19,-3) 26(11.19,-2.2) 27(11.19,-1.4) 28(11.19,-0.6) 29(11.19,0.2) 30(11.19,1) 31(11.19,1.8) 32(11.19,2.6) 33(11.19,3.4) 34(11.19,4.2) 35(11.19,5) 36(11.19,5.8) 37(11.19,6.6) 38(11.19,7.4) 39(5.33,7) 40(5.33,6.2) 41(5.33,5.4) 42(5.33,4.6) 43(5.33,3.8) 44(5.33,3) 45(5.33,2.2) 46(5.33,1.4) 47(5.33,0.6) 48(5.33,-0.2) 49(5.33,-1) 50(5.33,-1.8) 51(5.33,-2.6) 52(5.33,-3.4) 53(5.33,-4.2) 54(5.33,-5) 55(5.33,-5.8) 56(5.33,-6.6) 57(5.33,-7.4) 58(8.26,-7) 59(8.26,-6.2) 60(8.26,-5.4) 61(8.26,-4.6) 62(8.26,-3.8) 63(8.26,-3) 64(8.26,-2.2) 65(8.26,-1.4) 66(8.26,-0.6) 67(8.26,0.2) 68(8.26,1) 69(8.26,1.8) 70(8.26,2.6) 71(8.26,3.4) 72(8.26,4.2) 73(8.26,5) 74(8.26,5.8) 75(8.26,6.6) 76(8.26,7.4)
  round 3.023 hole 1.549: 77(-9.1,8.4) 78(-9.1,-8.4)
ANALOG_LQFN-42P
  rect 0.7x0.25 smd: 1(-2.4,3.5) 2(-2.4,3) 3(-2.4,2.5) 4(-2.4,2) 5(-2.4,1.5) 6(-2.4,1) 7(-2.4,0.5) 9(-2.4,-0.5) 10(-2.4,-1) 11(-2.4,-1.5) 12(-2.4,-2) 13(-2.4,-2.5) 14(-2.4,-3) 15(-2.4,-3.5) 22(2.4,-3.5) 23(2.4,-3) 24(2.4,-2.5) 25(2.4,-2) 26(2.4,-1.5) 27(2.4,-1) 28(2.4,-0.5) 29(2.4,0) 30(2.4,0.5) 31(2.4,1) 32(2.4,1.5) 33(2.4,2) 34(2.4,2.5) 35(2.4,3) 36(2.4,3.5)
  custom 0.312x0.312 smd: 8(-2.4,0)
  custom 0.238x0.238 smd: 16(-2,-3.9) 42(-2,3.9)
  rect 0.25x0.7 smd: 17(-1,-3.9) 19(0,-3.9) 20(1,-3.9) 38(1,3.9) 39(0,3.9) 41(-1,3.9)
  custom 0.35x0.35 smd: 18(-0.5,-3.9) 40(-0.5,3.9)
  custom 0.288x0.288 smd: 21(1.5,-3.9) 37(1.5,3.9)
  rect 0.7x1.5 smd: 43(0.85,0)
B2
  rect 1.778x2.54 smd: 1(-1.524,0) 2(1.524,0)
BGA9N50P3X3_149X149X69N
  round 0.35 smd: A1(-0.5,0.5) A2(0,0.5) A3(0.5,0.5) B1(-0.5,0) B2(0,0) B3(0.5,0) C1(-0.5,-0.5) C2(0,-0.5) C3(0.5,-0.5)
BGA25
  round 0.559 smd: A1(-2.54,2.54) A2(-1.27,2.54) A3(0,2.54) A4(1.27,2.54) A5(2.54,2.54) B1(-2.54,1.27) B2(-1.27,1.27) B3(0,1.27) B4(1.27,1.27) B5(2.54,1.27) C1(-2.54,0) C2(-1.27,0) C3(0,0) C4(1.27,0) C5(2.54,0) D1(-2.54,-1.27) D2(-1.27,-1.27) D3(0,-1.27) D4(1.27,-1.27) D5(2.54,-1.27) E1(-2.54,-2.54) E2(-1.27,-2.54) E3(0,-2.54) E4(1.27,-2.54) E5(2.54,-2.54)
BGA25C127P5X5_625X625X262
  round 0.63 smd: A1(-2.54,2.54) A2(-1.27,2.54) A3(0,2.54) A4(1.27,2.54) A5(2.54,2.54) B1(-2.54,1.27) B2(-1.27,1.27) B3(0,1.27) B4(1.27,1.27) B5(2.54,1.27) C1(-2.54,0) C2(-1.27,0) C3(0,0) C4(1.27,0) C5(2.54,0) D1(-2.54,-1.27) D2(-1.27,-1.27) D3(0,-1.27) D4(1.27,-1.27) D5(2.54,-1.27) E1(-2.54,-2.54) E2(-1.27,-2.54) E3(0,-2.54) E4(1.27,-2.54) E5(2.54,-2.54)
BGA49C80P7X7_625X625X230N
  round 0.45 smd: A1(-2.4,2.4) A2(-1.6,2.4) A3(-0.8,2.4) A4(0,2.4) A5(0.8,2.4) A6(1.6,2.4) A7(2.4,2.4) B1(-2.4,1.6) B2(-1.6,1.6) B3(-0.8,1.6) B4(0,1.6) B5(0.8,1.6) B6(1.6,1.6) B7(2.4,1.6) C1(-2.4,0.8) C2(-1.6,0.8) C3(-0.8,0.8) C4(0,0.8) C5(0.8,0.8) C6(1.6,0.8) C7(2.4,0.8) D1(-2.4,0) D2(-1.6,0) D3(-0.8,0) D4(0,0) D5(0.8,0) D6(1.6,0) D7(2.4,0) E1(-2.4,-0.8) E2(-1.6,-0.8) E3(-0.8,-0.8) E4(0,-0.8) E5(0.8,-0.8) E6(1.6,-0.8) E7(2.4,-0.8) F1(-2.4,-1.6) F2(-1.6,-1.6) F3(-0.8,-1.6) F4(0,-1.6) F5(0.8,-1.6) F6(1.6,-1.6) F7(2.4,-1.6) G1(-2.4,-2.4) G2(-1.6,-2.4) G3(-0.8,-2.4) G4(0,-2.4) G5(0.8,-2.4) G6(1.6,-2.4) G7(2.4,-2.4)
BGA77C127P7X11_900X1500X262N
  round 0.61 smd: A1(-3.81,6.35) A2(-2.54,6.35) A3(-1.27,6.35) A4(0,6.35) A5(1.27,6.35) A6(2.54,6.35) A7(3.81,6.35) B1(-3.81,5.08) B2(-2.54,5.08) B3(-1.27,5.08) B4(0,5.08) B5(1.27,5.08) B6(2.54,5.08) B7(3.81,5.08) C1(-3.81,3.81) C2(-2.54,3.81) C3(-1.27,3.81) C4(0,3.81) C5(1.27,3.81) C6(2.54,3.81) C7(3.81,3.81) D1(-3.81,2.54) D2(-2.54,2.54) D3(-1.27,2.54) D4(0,2.54) D5(1.27,2.54) D6(2.54,2.54) D7(3.81,2.54) E1(-3.81,1.27) E2(-2.54,1.27) E3(-1.27,1.27) E4(0,1.27) E5(1.27,1.27) E6(2.54,1.27) E7(3.81,1.27) F1(-3.81,0) F2(-2.54,0) F3(-1.27,0) F4(0,0) F5(1.27,0) F6(2.54,0) F7(3.81,0) G1(-3.81,-1.27) G2(-2.54,-1.27) G3(-1.27,-1.27) G4(0,-1.27) G5(1.27,-1.27) G6(2.54,-1.27) G7(3.81,-1.27) H1(-3.81,-2.54) H2(-2.54,-2.54) H3(-1.27,-2.54) H4(0,-2.54) H5(1.27,-2.54) H6(2.54,-2.54) H7(3.81,-2.54) J1(-3.81,-3.81) J2(-2.54,-3.81) J3(-1.27,-3.81) J4(0,-3.81) J5(1.27,-3.81) J6(2.54,-3.81) J7(3.81,-3.81) K1(-3.81,-5.08) K2(-2.54,-5.08) K3(-1.27,-5.08) K4(0,-5.08) K5(1.27,-5.08) K6(2.54,-5.08) K7(3.81,-5.08) L1(-3.81,-6.35) L2(-2.54,-6.35) L3(-1.27,-6.35) L4(0,-6.35) L5(1.27,-6.35) L6(2.54,-6.35) L7(3.81,-6.35)
BGA144C127P12X12_1600X1600X626
  round 0.61 smd: A1(-6.985,6.985) A2(-5.715,6.985) A3(-4.445,6.985) A4(-3.175,6.985) A5(-1.905,6.985) A6(-0.635,6.985) A7(0.635,6.985) A8(1.905,6.985) A9(3.175,6.985) A10(4.445,6.985) A11(5.715,6.985) A12(6.985,6.985) B1(-6.985,5.715) B2(-5.715,5.715) B3(-4.445,5.715) B4(-3.175,5.715) B5(-1.905,5.715) B6(-0.635,5.715) B7(0.635,5.715) B8(1.905,5.715) B9(3.175,5.715) B10(4.445,5.715) B11(5.715,5.715) B12(6.985,5.715) C1(-6.985,4.445) C2(-5.715,4.445) C3(-4.445,4.445) C4(-3.175,4.445) C5(-1.905,4.445) C6(-0.635,4.445) C7(0.635,4.445) C8(1.905,4.445) C9(3.175,4.445) C10(4.445,4.445) C11(5.715,4.445) C12(6.985,4.445) D1(-6.985,3.175) D2(-5.715,3.175) D3(-4.445,3.175) D4(-3.175,3.175) D5(-1.905,3.175) D6(-0.635,3.175) D7(0.635,3.175) D8(1.905,3.175) D9(3.175,3.175) D10(4.445,3.175) D11(5.715,3.175) D12(6.985,3.175) E1(-6.985,1.905) E2(-5.715,1.905) E3(-4.445,1.905) E4(-3.175,1.905) E5(-1.905,1.905) E6(-0.635,1.905) E7(0.635,1.905) E8(1.905,1.905) E9(3.175,1.905) E10(4.445,1.905) E11(5.715,1.905) E12(6.985,1.905) F1(-6.985,0.635) F2(-5.715,0.635) F3(-4.445,0.635) F4(-3.175,0.635) F5(-1.905,0.635) F6(-0.635,0.635) F7(0.635,0.635) F8(1.905,0.635) F9(3.175,0.635) F10(4.445,0.635) F11(5.715,0.635) F12(6.985,0.635) G1(-6.985,-0.635) G2(-5.715,-0.635) G3(-4.445,-0.635) G4(-3.175,-0.635) G5(-1.905,-0.635) G6(-0.635,-0.635) G7(0.635,-0.635) G8(1.905,-0.635) G9(3.175,-0.635) G10(4.445,-0.635) G11(5.715,-0.635) G12(6.985,-0.635) H1(-6.985,-1.905) H2(-5.715,-1.905) H3(-4.445,-1.905) H4(-3.175,-1.905) H5(-1.905,-1.905) H6(-0.635,-1.905) H7(0.635,-1.905) H8(1.905,-1.905) H9(3.175,-1.905) H10(4.445,-1.905) H11(5.715,-1.905) H12(6.985,-1.905) J1(-6.985,-3.175) J2(-5.715,-3.175) J3(-4.445,-3.175) J4(-3.175,-3.175) J5(-1.905,-3.175) J6(-0.635,-3.175) J7(0.635,-3.175) J8(1.905,-3.175) J9(3.175,-3.175) J10(4.445,-3.175) J11(5.715,-3.175) J12(6.985,-3.175) K1(-6.985,-4.445) K2(-5.715,-4.445) K3(-4.445,-4.445) K4(-3.175,-4.445) K5(-1.905,-4.445) K6(-0.635,-4.445) K7(0.635,-4.445) K8(1.905,-4.445) K9(3.175,-4.445) K10(4.445,-4.445) K11(5.715,-4.445) K12(6.985,-4.445) L1(-6.985,-5.715) L2(-5.715,-5.715) L3(-4.445,-5.715) L4(-3.175,-5.715) L5(-1.905,-5.715) L6(-0.635,-5.715) L7(0.635,-5.715) L8(1.905,-5.715) L9(3.175,-5.715) L10(4.445,-5.715) L11(5.715,-5.715) L12(6.985,-5.715) M1(-6.985,-6.985) M2(-5.715,-6.985) M3(-4.445,-6.985) M4(-3.175,-6.985) M5(-1.905,-6.985) M6(-0.635,-6.985) M7(0.635,-6.985) M8(1.905,-6.985) M9(3.175,-6.985) M10(4.445,-6.985) M11(5.715,-6.985) M12(6.985,-6.985)
C0402
  rect 0.508x0.508 smd: 1(0,0.445) 2(0,-0.445)
C0805
  rect 1.6x1.321 smd: 1(0,0.95) 2(0,-0.95)
C1206
  rect 1.27x1.778 smd: 1(-1.524,0) 2(1.524,0)
C2012
  rect 1.295x1.27 smd: 1(-1.098,0) 2(1.098,0)
CAP_PACK_4_1206
  rect 0.559x0.813 smd: 1(-1.2,-0.906) 2(-0.4,-0.906) 3(0.4,-0.906) 4(1.2,-0.906) 5(1.2,0.906) 6(0.4,0.906) 7(-0.4,0.906) 8(-1.2,0.906)
CAPC1005X60L20L
  rect 0.508x0.508 smd: 1(0,0.445) 2(0,-0.445)
CAPC2012X110L50L
  rect 1.6x1.321 smd: 1(0,0.95) 2(0,-0.95)
CAPC3216X135L50N
  rect 1.27x1.778 smd: 1(-1.524,0) 2(1.524,0)
CAPMP7343X300L130X240N_P079IN
  rect 2.54x2.743 smd: 1(-3.175,0) 2(3.175,0)
CT7343-43
  rect 2.232x2.8 smd: 1(-2.85,0) 2(2.85,0)
CT7361-20
  rect 2.74x4.88 smd: 1(-2.84,0)
  rect 3.94x4.88 smd: 2(2.24,0)
D2E
  rect 2.591x2.667 smd: 1(-3.2,0) 2(3.2,0)
DCK
  rect 0.406x1.27 smd: 1(-0.65,-0.985) 2(0,-0.985) 3(0.65,-0.985) 4(0.65,0.985) 5(-0.65,0.985)
DDC
  rect 0.6x1.1 smd: 1(-0.95,-1.25) 2(0,-1.25) 3(0.95,-1.25) 4(0.95,1.25) 5(0,1.25) 6(-0.95,1.25)
DDR4DIMM_SMT
  round 3.226 hole 2.464: (-68.975,0) (68.975,0)
  oval 1.727x2.972 hole 1.219x2.464: (5.575,0)
  rect 0.584x1.803 smd: 1(-63.325,-2.3) 2(-62.475,-2.3) 3(-61.625,-2.3) 4(-60.775,-2.3) 5(-59.925,-2.3) 6(-59.075,-2.3) 7(-58.225,-2.3) 8(-57.375,-2.3) 9(-56.525,-2.3) 10(-55.675,-2.3) 11(-54.825,-2.3) 12(-53.975,-2.3) 13(-53.125,-2.3) 14(-52.275,-2.3) 15(-51.425,-2.3) 16(-50.575,-2.3) 17(-49.725,-2.3) 18(-48.875,-2.3) 19(-48.025,-2.3) 20(-47.175,-2.3) 21(-46.325,-2.3) 22(-45.475,-2.3) 23(-44.625,-2.3) 24(-43.775,-2.3) 25(-42.925,-2.3) 26(-42.075,-2.3) 27(-41.225,-2.3) 28(-40.375,-2.3) 29(-39.525,-2.3) 30(-38.675,-2.3) 31(-37.825,-2.3) 32(-36.975,-2.3) 33(-36.125,-2.3) 34(-35.275,-2.3) 35(-34.425,-2.3) 36(-33.575,-2.3) 37(-32.725,-2.3) 38(-31.875,-2.3) 39(-31.025,-2.3) 40(-30.175,-2.3) 41(-29.325,-2.3) 42(-28.475,-2.3) 43(-27.625,-2.3) 44(-26.775,-2.3) 45(-25.925,-2.3) 46(-25.075,-2.3) 47(-24.225,-2.3) 48(-23.375,-2.3) 49(-22.525,-2.3) 50(-21.675,-2.3) 51(-20.825,-2.3) 52(-19.975,-2.3) 53(-19.125,-2.3) 54(-18.275,-2.3) 55(-17.425,-2.3) 56(-16.575,-2.3) 57(-15.725,-2.3) 58(-14.875,-2.3) 59(-14.025,-2.3) 60(-13.175,-2.3) 61(-12.325,-2.3) 62(-11.475,-2.3) 63(-10.625,-2.3) 64(-9.775,-2.3) 65(-8.925,-2.3) 66(-8.075,-2.3) 67(-7.225,-2.3) 68(-6.375,-2.3) 69(-5.525,-2.3) 70(-4.675,-2.3) 71(-3.825,-2.3) 72(-2.975,-2.3) 73(-2.125,-2.3) 74(-1.275,-2.3) 75(-0.425,-2.3) 76(0.425,-2.3) 77(1.275,-2.3) 78(7.225,-2.3) 79(8.075,-2.3) 80(8.925,-2.3) 81(9.775,-2.3) 82(10.625,-2.3) 83(11.475,-2.3) 84(12.325,-2.3) 85(13.175,-2.3) 86(14.025,-2.3) 87(14.875,-2.3) 88(15.725,-2.3) 89(16.575,-2.3) 90(17.425,-2.3) 91(18.275,-2.3) 92(19.125,-2.3) 93(19.975,-2.3) 94(20.825,-2.3) 95(21.675,-2.3) 96(22.525,-2.3) 97(23.375,-2.3) 98(24.225,-2.3) 99(25.075,-2.3) 100(25.925,-2.3) 101(26.775,-2.3) 102(27.625,-2.3) 103(28.475,-2.3) 104(29.325,-2.3) 105(30.175,-2.3) 106(31.025,-2.3) 107(31.875,-2.3) 108(32.725,-2.3) 109(33.575,-2.3) 110(34.425,-2.3) 111(35.275,-2.3) 112(36.125,-2.3) 113(36.975,-2.3) 114(37.825,-2.3) 115(38.675,-2.3) 116(39.525,-2.3) 117(40.375,-2.3) 118(41.225,-2.3) 119(42.075,-2.3) 120(42.925,-2.3) 121(43.775,-2.3) 122(44.625,-2.3) 123(45.475,-2.3) 124(46.325,-2.3) 125(47.175,-2.3) 126(48.025,-2.3) 127(48.875,-2.3) 128(49.725,-2.3) 129(50.575,-2.3) 130(51.425,-2.3) 131(52.275,-2.3) 132(53.125,-2.3) 133(53.975,-2.3) 134(54.825,-2.3) 135(55.675,-2.3) 136(56.525,-2.3) 137(57.375,-2.3) 138(58.225,-2.3) 139(59.075,-2.3) 140(59.925,-2.3) 141(60.775,-2.3) 142(61.625,-2.3) 143(62.475,-2.3) 144(63.325,-2.3) 145(-63.325,2.3) 146(-62.475,2.3) 147(-61.625,2.3) 148(-60.775,2.3) 149(-59.925,2.3) 150(-59.075,2.3) 151(-58.225,2.3) 152(-57.375,2.3) 153(-56.525,2.3) 154(-55.675,2.3) 155(-54.825,2.3) 156(-53.975,2.3) 157(-53.125,2.3) 158(-52.275,2.3) 159(-51.425,2.3) 160(-50.575,2.3) 161(-49.725,2.3) 162(-48.875,2.3) 163(-48.025,2.3) 164(-47.175,2.3) 165(-46.325,2.3) 166(-45.475,2.3) 167(-44.625,2.3) 168(-43.775,2.3) 169(-42.925,2.3) 170(-42.075,2.3) 171(-41.225,2.3) 172(-40.375,2.3) 173(-39.525,2.3) 174(-38.675,2.3) 175(-37.825,2.3) 176(-36.975,2.3) 177(-36.125,2.3) 178(-35.275,2.3) 179(-34.425,2.3) 180(-33.575,2.3) 181(-32.725,2.3) 182(-31.875,2.3) 183(-31.025,2.3) 184(-30.175,2.3) 185(-29.325,2.3) 186(-28.475,2.3) 187(-27.625,2.3) 188(-26.775,2.3) 189(-25.925,2.3) 190(-25.075,2.3) 191(-24.225,2.3) 192(-23.375,2.3) 193(-22.525,2.3) 194(-21.675,2.3) 195(-20.825,2.3) 196(-19.975,2.3) 197(-19.125,2.3) 198(-18.275,2.3) 199(-17.425,2.3) 200(-16.575,2.3) 201(-15.725,2.3) 202(-14.875,2.3) 203(-14.025,2.3) 204(-13.175,2.3) 205(-12.325,2.3) 206(-11.475,2.3) 207(-10.625,2.3) 208(-9.775,2.3) 209(-8.925,2.3) 210(-8.075,2.3) 211(-7.225,2.3) 212(-6.375,2.3) 213(-5.525,2.3) 214(-4.675,2.3) 215(-3.825,2.3) 216(-2.975,2.3) 217(-2.125,2.3) 218(-1.275,2.3) 219(-0.425,2.3) 220(0.425,2.3) 221(1.275,2.3) 222(7.225,2.3) 223(8.075,2.3) 224(8.925,2.3) 225(9.775,2.3) 226(10.625,2.3) 227(11.475,2.3) 228(12.325,2.3) 229(13.175,2.3) 230(14.025,2.3) 231(14.875,2.3) 232(15.725,2.3) 233(16.575,2.3) 234(17.425,2.3) 235(18.275,2.3) 236(19.125,2.3) 237(19.975,2.3) 238(20.825,2.3) 239(21.675,2.3) 240(22.525,2.3) 241(23.375,2.3) 242(24.225,2.3) 243(25.075,2.3) 244(25.925,2.3) 245(26.775,2.3) 246(27.625,2.3) 247(28.475,2.3) 248(29.325,2.3) 249(30.175,2.3) 250(31.025,2.3) 251(31.875,2.3) 252(32.725,2.3) 253(33.575,2.3) 254(34.425,2.3) 255(35.275,2.3) 256(36.125,2.3) 257(36.975,2.3) 258(37.825,2.3) 259(38.675,2.3) 260(39.525,2.3) 261(40.375,2.3) 262(41.225,2.3) 263(42.075,2.3) 264(42.925,2.3) 265(43.775,2.3) 266(44.625,2.3) 267(45.475,2.3) 268(46.325,2.3) 269(47.175,2.3) 270(48.025,2.3) 271(48.875,2.3) 272(49.725,2.3) 273(50.575,2.3) 274(51.425,2.3) 275(52.275,2.3) 276(53.125,2.3) 277(53.975,2.3) 278(54.825,2.3) 279(55.675,2.3) 280(56.525,2.3) 281(57.375,2.3) 282(58.225,2.3) 283(59.075,2.3) 284(59.925,2.3) 285(60.775,2.3) 286(61.625,2.3) 287(62.475,2.3) 288(63.325,2.3)
DFN6_EPAD
  rect 0.25x0.7 smd: 1(-0.5,-1.425) 2(0,-1.425) 3(0.5,-1.425) 4(0.5,1.425) 5(0,1.425) 6(-0.5,1.425)
  rect 1.321x1.6 smd: 7(0,0)
DFN8-EPAD_3X2
  rect 0.279x0.787 smd: 1(-0.75,-0.994) 2(-0.25,-0.994) 3(0.25,-0.994) 4(0.75,-0.994) 5(0.75,0.994) 6(0.25,0.994) 7(-0.25,0.994) 8(-0.75,0.994)
  rect 2.21x0.61 smd: 9(0,0)
DIO_SOD882
  rect 0.4x0.7 smd: 1(-0.35,0) 2(0.35,0)
DIPSWITCH_SMT_QUAD
  rect 0.76x1.27 smd: 1(-1.905,-3.81) 2(-0.635,-3.81) 3(0.635,-3.81) 4(1.905,-3.81) 5(1.905,3.81) 6(0.635,3.81) 7(-0.635,3.81) 8(-1.905,3.81)
DRT
  rect 0.305x0.305 smd: 1(-0.35,-0.425) 2(0.35,-0.425) 3(0,0.425)
EG2207
  round 1.778 hole 1.194: (-2.794,-1.003) (6.807,-1.003)
  rect 1.346x1.346 hole 0.787: 1(0,0)
  round 1.346 hole 0.787: 2(2.007,0) 3(4.013,0) 4(0,-2.007) 5(2.007,-2.007) 6(4.013,-2.007)
FBGA96
  round 0.42 smd: A1(-3.2,6) A2(-2.4,6) A3(-1.6,6) A7(1.6,6) A8(2.4,6) A9(3.2,6) B1(-3.2,5.2) B2(-2.4,5.2) B3(-1.6,5.2) B7(1.6,5.2) B8(2.4,5.2) B9(3.2,5.2) C1(-3.2,4.4) C2(-2.4,4.4) C3(-1.6,4.4) C7(1.6,4.4) C8(2.4,4.4) C9(3.2,4.4) D1(-3.2,3.6) D2(-2.4,3.6) D3(-1.6,3.6) D7(1.6,3.6) D8(2.4,3.6) D9(3.2,3.6) E1(-3.2,2.8) E2(-2.4,2.8) E3(-1.6,2.8) E7(1.6,2.8) E8(2.4,2.8) E9(3.2,2.8) F1(-3.2,2) F2(-2.4,2) F3(-1.6,2) F7(1.6,2) F8(2.4,2) F9(3.2,2) G1(-3.2,1.2) G2(-2.4,1.2) G3(-1.6,1.2) G7(1.6,1.2) G8(2.4,1.2) G9(3.2,1.2) H1(-3.2,0.4) H2(-2.4,0.4) H3(-1.6,0.4) H7(1.6,0.4) H8(2.4,0.4) H9(3.2,0.4) J1(-3.2,-0.4) J2(-2.4,-0.4) J3(-1.6,-0.4) J7(1.6,-0.4) J8(2.4,-0.4) J9(3.2,-0.4) K1(-3.2,-1.2) K2(-2.4,-1.2) K3(-1.6,-1.2) K7(1.6,-1.2) K8(2.4,-1.2) K9(3.2,-1.2) L1(-3.2,-2) L2(-2.4,-2) L3(-1.6,-2) L7(1.6,-2) L8(2.4,-2) L9(3.2,-2) M1(-3.2,-2.8) M2(-2.4,-2.8) M3(-1.6,-2.8) M7(1.6,-2.8) M8(2.4,-2.8) M9(3.2,-2.8) N1(-3.2,-3.6) N2(-2.4,-3.6) N3(-1.6,-3.6) N7(1.6,-3.6) N8(2.4,-3.6) N9(3.2,-3.6) P1(-3.2,-4.4) P2(-2.4,-4.4) P3(-1.6,-4.4) P7(1.6,-4.4) P8(2.4,-4.4) P9(3.2,-4.4) R1(-3.2,-5.2) R2(-2.4,-5.2) R3(-1.6,-5.2) R7(1.6,-5.2) R8(2.4,-5.2) R9(3.2,-5.2) T1(-3.2,-6) T2(-2.4,-6) T3(-1.6,-6) T7(1.6,-6) T8(2.4,-6) T9(3.2,-6)
FBGA2957A_HEX_P56X45
  round 1.016 smd: (-29,-23.5) (29,23.5)
  round 0.45 smd: A69(16.058,21.752) A72(17.79,21.752) A74(19.522,21.752) A76(21.255,21.752) A78(22.987,21.752) AA27(-16.046,17.021) AA29(-14.452,17.021) AA31(-12.859,17.021) AA33(-11.265,17.021) AA35(-9.671,17.021) AA37(-8.078,17.021) AA39(-6.484,17.021) AA41(-4.89,17.021) AA43(-3.296,17.021) AA45(-1.703,17.021) AA47(-0.109,17.021) AA49(1.485,17.021) AA51(3.078,17.021) AA53(4.672,17.021) AA55(6.266,17.021) AA57(7.859,17.021) AA59(9.453,17.021) AA61(11.047,17.021) AA63(12.641,17.021) AA65(14.234,17.021) AB1(-27.317,16.791) AB6(-25.585,16.791) AB10(-23.853,16.791) AB14(-22.121,16.791) AB18(-20.389,16.791) AB22(-18.656,16.791) AC72(17.79,16.751) AC74(19.522,16.751) AC76(21.255,16.751) AC78(22.987,16.751) AC80(24.719,16.751) AC82(26.451,16.751) AD26(-16.843,16.561) AD28(-15.249,16.561) AD30(-13.655,16.561) AD32(-12.062,16.561) AD34(-10.468,16.561) AD36(-8.874,16.561) AD38(-7.281,16.561) AD40(-5.687,16.561) AD42(-4.093,16.561) AD44(-2.5,16.561) AD46(-0.906,16.561) AD48(0.688,16.561) AD50(2.282,16.561) AD52(3.875,16.561) AD54(5.469,16.561) AD56(7.063,16.561) AD58(8.656,16.561) AD60(10.25,16.561) AD62(11.844,16.561) AD64(13.437,16.561) AE3(-26.451,16.291) AE8(-24.719,16.291) AE12(-22.987,16.291) AE16(-21.255,16.291) AE20(-19.522,16.291) AE24(-17.79,16.291) AF73(18.656,16.251) AF75(20.388,16.251) AF77(22.121,16.251) AF79(23.853,16.251) AF81(25.585,16.251) AF83(27.317,16.251) AG27(-16.046,16.101) AG29(-14.452,16.101) AG31(-12.859,16.101) AG33(-11.265,16.101) AG35(-9.671,16.101) AG37(-8.078,16.101) AG39(-6.484,16.101) AG41(-4.89,16.101) AG43(-3.296,16.101) AG45(-1.703,16.101) AG47(-0.109,16.101) AG49(1.485,16.101) AG51(3.078,16.101) AG53(4.672,16.101) AG55(6.266,16.101) AG57(7.859,16.101) AG59(9.453,16.101) AG61(11.047,16.101) AG63(12.641,16.101) AG65(14.234,16.101) AG68(15.828,16.101) AH1(-27.317,15.791) AH6(-25.585,15.791) AH10(-23.853,15.791) AH14(-22.121,15.791) AH18(-20.389,15.791) AH22(-18.656,15.791) AJ72(17.79,15.751) AJ74(19.522,15.751) AJ76(21.255,15.751) AJ78(22.987,15.751) AJ80(24.719,15.751) AJ82(26.451,15.751) AK26(-16.843,15.641) AK28(-15.249,15.641) AK30(-13.655,15.641) AK32(-12.062,15.641) AK34(-10.468,15.641) AK36(-8.874,15.641) AK38(-7.281,15.641) AK40(-5.687,15.641) AK42(-4.093,15.641) AK44(-2.5,15.641) AK46(-0.906,15.641) AK48(0.688,15.641) AK50(2.282,15.641) AK52(3.875,15.641) AK54(5.469,15.641) AK56(7.063,15.641) AK58(8.656,15.641) AK60(10.25,15.641) AK62(11.844,15.641) AK64(13.437,15.641) AK66(15.031,15.641) AK70(16.625,15.641) AL3(-26.451,15.291) AL8(-24.719,15.291) AL12(-22.987,15.291) AL16(-21.255,15.291) AL20(-19.522,15.291) AL24(-17.79,15.291) AM73(18.656,15.251) AM75(20.388,15.251) AM77(22.121,15.251) AM79(23.853,15.251) AM81(25.585,15.251) AM83(27.317,15.251) AN27(-16.046,15.181) AN29(-14.452,15.181) AN31(-12.859,15.181) AN33(-11.265,15.181) AN35(-9.671,15.181) AN37(-8.078,15.181) AN39(-6.484,15.181) AN41(-4.89,15.181) AN43(-3.296,15.181) AN45(-1.703,15.181) AN47(-0.109,15.181) AN49(1.485,15.181) AN51(3.078,15.181) AN53(4.672,15.181) AN55(6.266,15.181) AN57(7.859,15.181) AN59(9.453,15.181) AN61(11.047,15.181) AN63(12.641,15.181) AN65(14.234,15.181) AN68(15.828,15.181) AP1(-27.317,14.791) AP6(-25.585,14.791) AP10(-23.853,14.791) AP14(-22.121,14.791) AP18(-20.389,14.791) AP22(-18.656,14.791) AR72(17.79,14.751) AR74(19.522,14.751) AR76(21.255,14.751) AR78(22.987,14.751) AR80(24.719,14.751) AR82(26.451,14.751) AT26(-16.843,14.721) AT28(-15.249,14.721) AT30(-13.655,14.721) AT32(-12.062,14.721) AT34(-10.468,14.721) AT36(-8.874,14.721) AT38(-7.281,14.721) AT40(-5.687,14.721) AT42(-4.093,14.721) AT44(-2.5,14.721) AT46(-0.906,14.721) AT48(0.688,14.721) AT50(2.282,14.721) AT52(3.875,14.721) AT54(5.469,14.721) AT56(7.063,14.721) AT58(8.656,14.721) AT60(10.25,14.721) AT62(11.844,14.721) AT64(13.437,14.721) AT66(15.031,14.721) AT70(16.625,14.721) AU3(-26.451,14.291) AU8(-24.719,14.291) AU12(-22.987,14.291) AU16(-21.254,14.291) AU20(-19.522,14.291) AU24(-17.79,14.291) AV27(-16.046,14.261) AV29(-14.452,14.261) AV31(-12.859,14.261) AV33(-11.265,14.261) AV35(-9.671,14.261) AV37(-8.078,14.261) AV39(-6.484,14.261) AV41(-4.89,14.261) AV43(-3.296,14.261) AV45(-1.703,14.261) AV47(-0.109,14.261) AV49(1.485,14.261) AV51(3.078,14.261) AV53(4.672,14.261) AV55(6.266,14.261) AV57(7.859,14.261) AV59(9.453,14.261) AV61(11.047,14.261) AV63(12.641,14.261) AV65(14.234,14.261) AV68(15.828,14.261) AW73(18.656,14.251) AW75(20.388,14.251) AW77(22.121,14.251) AW79(23.853,14.251) AW81(25.585,14.251) AW83(27.317,14.251) AY26(-16.843,13.801) AY28(-15.249,13.801) AY30(-13.655,13.801) AY32(-12.062,13.801) AY34(-10.468,13.801) AY36(-8.874,13.801) AY38(-7.281,13.801) AY40(-5.687,13.801) AY42(-4.093,13.801) AY44(-2.5,13.801) AY46(-0.906,13.801) AY48(0.688,13.801) AY50(2.282,13.801) AY52(3.875,13.801) AY54(5.469,13.801) AY56(7.063,13.801) AY58(8.656,13.801) AY60(10.25,13.801) AY62(11.844,13.801) AY64(13.437,13.801) AY66(15.031,13.801) AY70(16.625,13.801) B13(-22.42,21.622) B17(-20.827,21.622) B21(-19.233,21.622) B25(-17.639,21.622) B27(-16.046,21.622) B29(-14.452,21.622) B31(-12.858,21.622) B33(-11.264,21.622) B35(-9.671,21.622) B37(-8.077,21.622) B39(-6.483,21.622) B41(-4.89,21.622) B43(-3.296,21.622) B45(-1.702,21.622) B47(-0.109,21.622) B49(1.485,21.622) B51(3.079,21.622) B53(4.673,21.622) B55(6.266,21.622) B57(7.86,21.622) B59(9.454,21.622) B61(11.047,21.622) B63(12.641,21.622) B65(14.235,21.622) BA1(-27.317,13.791) BA6(-25.585,13.791) BA10(-23.853,13.791) BA14(-22.121,13.791) BA18(-20.388,13.791) BA22(-18.656,13.791) BB72(17.79,13.751) BB74(19.522,13.751) BB76(21.255,13.751) BB78(22.987,13.751) BB80(24.719,13.751) BB82(26.451,13.751) BC27(-16.046,13.341) BC29(-14.452,13.341) BC31(-12.859,13.341) BC33(-11.265,13.341) BC35(-9.671,13.341) BC37(-8.078,13.341) BC39(-6.484,13.341) BC41(-4.89,13.341) BC43(-3.296,13.341) BC45(-1.703,13.341) BC47(-0.109,13.341) BC49(1.485,13.341) BC51(3.078,13.341) BC53(4.672,13.341) BC55(6.266,13.341) BC57(7.859,13.341) BC59(9.453,13.341) BC61(11.047,13.341) BC63(12.641,13.341) BC65(14.234,13.341) BC68(15.828,13.341) BD3(-26.451,13.291) BD8(-24.719,13.291) BD12(-22.987,13.291) BD16(-21.254,13.291) BD20(-19.522,13.291) BD24(-17.79,13.291) BE73(18.656,13.251) BE75(20.388,13.251) BE77(22.121,13.251) BE79(23.853,13.251) BE81(25.585,13.251) BE83(27.317,13.251) BF26(-16.843,12.881) BF28(-15.249,12.881) BF30(-13.655,12.881) BF32(-12.062,12.881) BF34(-10.468,12.881) BF36(-8.874,12.881) BF38(-7.281,12.881) BF40(-5.687,12.881) BF42(-4.093,12.881) BF44(-2.5,12.881) BF46(-0.906,12.881) BF48(0.688,12.881) BF50(2.282,12.881) BF52(3.875,12.881) BF54(5.469,12.881) BF56(7.063,12.881) BF58(8.656,12.881) BF60(10.25,12.881) BF62(11.844,12.881) BF64(13.437,12.881) BF66(15.031,12.881) BF70(16.625,12.881) BG1(-27.317,12.791) BG6(-25.585,12.791) BG10(-23.853,12.791) BG14(-22.121,12.791) BG18(-20.388,12.791) BG22(-18.656,12.791) BH72(17.79,12.751) BH74(19.522,12.751) BH76(21.255,12.751) BH78(22.987,12.751) BH80(24.719,12.751) BH82(26.451,12.751) BJ27(-16.046,12.421) BJ29(-14.452,12.421) BJ31(-12.859,12.421) BJ33(-11.265,12.421) BJ35(-9.671,12.421) BJ37(-8.078,12.421) BJ39(-6.484,12.421) BJ41(-4.89,12.421) BJ43(-3.296,12.421) BJ45(-1.703,12.421) BJ47(-0.109,12.421) BJ49(1.485,12.421) BJ51(3.078,12.421) BJ53(4.672,12.421) BJ55(6.266,12.421) BJ57(7.859,12.421) BJ59(9.453,12.421) BJ61(11.047,12.421) BJ63(12.641,12.421) BJ65(14.234,12.421) BJ68(15.828,12.421) BK3(-26.451,12.291) BK8(-24.719,12.291) BK12(-22.987,12.291) BK16(-21.254,12.291) BK20(-19.522,12.291) BK24(-17.79,12.291) BL73(18.656,12.251) BL75(20.388,12.251) BL77(22.121,12.251) BL79(23.853,12.251) BL81(25.585,12.251) BL83(27.317,12.251) BM26(-16.843,11.961) BM28(-15.249,11.961) BM30(-13.655,11.961) BM32(-12.062,11.961) BM34(-10.468,11.961) BM36(-8.874,11.961) BM38(-7.281,11.961) BM40(-5.687,11.961) BM42(-4.093,11.961) BM44(-2.5,11.961) BM46(-0.906,11.961) BM48(0.688,11.961) BM50(2.282,11.961) BM52(3.875,11.961) BM54(5.469,11.961) BM56(7.063,11.961) BM58(8.656,11.961) BM60(10.25,11.961) BM62(11.844,11.961) BM64(13.437,11.961) BM66(15.031,11.961) BM70(16.625,11.961) BN1(-27.317,11.791) BN6(-25.585,11.791) BN10(-23.853,11.791) BN14(-22.121,11.791) BN18(-20.388,11.791) BN22(-18.656,11.791) BP72(17.79,11.751) BP74(19.522,11.751) BP76(21.255,11.751) BP78(22.987,11.751) BP80(24.719,11.751) BP82(26.451,11.751) BR27(-16.046,11.501) BR29(-14.452,11.501) BR31(-12.859,11.501) BR33(-11.265,11.501) BR35(-9.671,11.501) BR37(-8.078,11.501) BR39(-6.484,11.501) BR41(-4.89,11.501) BR43(-3.296,11.501) BR45(-1.703,11.501) BR47(-0.109,11.501) BR49(1.485,11.501) BR51(3.078,11.501) BR53(4.672,11.501) BR55(6.266,11.501) BR57(7.859,11.501) BR59(9.453,11.501) BR61(11.047,11.501) BR63(12.641,11.501) BR65(14.234,11.501) BR68(15.828,11.501) BT3(-26.451,11.291) BT8(-24.719,11.291) BT12(-22.987,11.291) BT16(-21.254,11.291) BT20(-19.522,11.291) BT24(-17.79,11.291) BU73(18.656,11.251) BU75(20.388,11.251) BU77(22.121,11.251) BU79(23.853,11.251) BU81(25.585,11.251) BU83(27.317,11.251) BV26(-16.843,11.041) BV28(-15.249,11.041) BV30(-13.655,11.041) BV32(-12.062,11.041) BV34(-10.468,11.041) BV36(-8.874,11.041) BV38(-7.281,11.041) BV40(-5.687,11.041) BV42(-4.093,11.041) BV44(-2.5,11.041) BV46(-0.906,11.041) BV48(0.688,11.041) BV50(2.282,11.041) BV52(3.875,11.041) BV54(5.469,11.041) BV56(7.063,11.041) BV58(8.656,11.041) BV60(10.25,11.041) BV62(11.844,11.041) BV64(13.437,11.041) BV66(15.031,11.041) BV70(16.625,11.041) BW1(-27.317,10.791) BW6(-25.585,10.791) BW10(-23.853,10.791) BW14(-22.121,10.791) BW18(-20.388,10.791) BW22(-18.656,10.791) BY72(17.79,10.751) BY74(19.522,10.751) BY76(21.255,10.751) BY78(22.987,10.751) BY80(24.719,10.751) BY82(26.451,10.751) C67(15.192,21.252) C71(16.924,21.252) C73(18.656,21.252) C75(20.389,21.252) C77(22.121,21.252) C79(23.853,21.252) CA27(-16.046,10.581) CA29(-14.452,10.581) CA31(-12.859,10.581) CA33(-11.265,10.581) CA35(-9.671,10.581) CA37(-8.078,10.581) CA39(-6.484,10.581) CA41(-4.89,10.581) CA43(-3.296,10.581) CA45(-1.703,10.581) CA47(-0.109,10.581) CA49(1.485,10.581) CA51(3.078,10.581) CA53(4.672,10.581) CA55(6.266,10.581) CA57(7.859,10.581) CA59(9.453,10.581) CA61(11.047,10.581) CA63(12.641,10.581) CA65(14.234,10.581) CA68(15.828,10.581) CB3(-26.451,10.291) CB8(-24.719,10.291) CB12(-22.987,10.291) CB16(-21.254,10.291) CB20(-19.522,10.291) CB24(-17.79,10.291) CC73(18.656,10.251) CC75(20.388,10.251) CC77(22.121,10.251) CC79(23.853,10.251) CC81(25.585,10.251) CC83(27.317,10.251) CD26(-16.843,10.121) CD28(-15.249,10.121) CD30(-13.655,10.121) CD32(-12.062,10.121) CD34(-10.468,10.121) CD36(-8.874,10.121) CD38(-7.281,10.121) CD40(-5.687,10.121) CD42(-4.093,10.121) CD44(-2.5,10.121) CD46(-0.906,10.121) CD48(0.688,10.121) CD50(2.282,10.121) CD52(3.875,10.121) CD54(5.469,10.121) CD56(7.063,10.121) CD58(8.656,10.121) CD60(10.25,10.121) CD62(11.844,10.121) CD64(13.437,10.121) CD66(15.031,10.121) CD70(16.625,10.121) CE1(-27.317,9.791) CE6(-25.585,9.791) CE10(-23.853,9.791) CE14(-22.121,9.791) CE18(-20.388,9.791) CE22(-18.656,9.791) CF72(17.79,9.751) CF74(19.522,9.751) CF76(21.255,9.751) CF78(22.987,9.751) CF80(24.719,9.751) CF82(26.451,9.751) CG27(-16.046,9.661) CG29(-14.452,9.661) CG31(-12.859,9.661) CG33(-11.265,9.661) CG35(-9.671,9.661) CG37(-8.078,9.661) CG39(-6.484,9.661) CG41(-4.89,9.661) CG43(-3.296,9.661) CG45(-1.703,9.661) CG47(-0.109,9.661) CG49(1.485,9.661) CG51(3.078,9.661) CG53(4.672,9.661) CG55(6.266,9.661) CG57(7.859,9.661) CG59(9.453,9.661) CG61(11.047,9.661) CG63(12.641,9.661) CG65(14.234,9.661) CG68(15.828,9.661) CH3(-26.451,9.291) CH8(-24.719,9.291) CH12(-22.987,9.291) CH16(-21.254,9.291) CH20(-19.522,9.291) CH24(-17.79,9.291) CJ73(18.656,9.251) CJ75(20.388,9.251) CJ77(22.121,9.251) CJ79(23.853,9.251) CJ81(25.585,9.251) CJ83(27.317,9.251) CK26(-16.843,9.201) CK28(-15.249,9.201) CK30(-13.655,9.201) CK32(-12.062,9.201) CK34(-10.468,9.201) CK36(-8.874,9.201) CK38(-7.281,9.201) CK40(-5.687,9.201) CK42(-4.093,9.201) CK44(-2.5,9.201) CK46(-0.906,9.201) CK48(0.688,9.201) CK50(2.282,9.201) CK52(3.875,9.201) CK54(5.469,9.201) CK56(7.063,9.201) CK58(8.656,9.201) CK60(10.25,9.201) CK62(11.844,9.201) CK64(13.437,9.201) CK66(15.031,9.201) CK70(16.625,9.201) CL1(-27.317,8.791) CL6(-25.585,8.791) CL10(-23.853,8.791) CL14(-22.121,8.791) CL18(-20.388,8.791) CL22(-18.656,8.791) CM72(17.79,8.751) CM74(19.522,8.751) CM76(21.255,8.751) CM78(22.987,8.751) CM80(24.719,8.751) CM82(26.451,8.751) CN27(-16.046,8.741) CN29(-14.452,8.741) CN31(-12.859,8.741) CN33(-11.265,8.741) CN35(-9.671,8.741) CN37(-8.078,8.741) CN39(-6.484,8.741) CN41(-4.89,8.741) CN43(-3.296,8.741) CN45(-1.703,8.741) CN47(-0.109,8.741) CN49(1.485,8.741) CN51(3.078,8.741) CN53(4.672,8.741) CN55(6.266,8.741) CN57(7.859,8.741) CN59(9.453,8.741) CN61(11.047,8.741) CN63(12.641,8.741) CN65(14.234,8.741) CN68(15.828,8.741) CP3(-26.451,8.291) CP8(-24.719,8.291) CP12(-22.987,8.291) CP16(-21.254,8.291) CP20(-19.522,8.291) CP24(-17.79,8.291) CR26(-16.843,8.281) CR28(-15.249,8.281) CR30(-13.655,8.281) CR32(-12.062,8.281) CR34(-10.468,8.281) CR36(-8.874,8.281) CR38(-7.281,8.281) CR40(-5.687,8.281) CR42(-4.093,8.281) CR44(-2.5,8.281) CR46(-0.906,8.281) CR48(0.688,8.281) CR50(2.282,8.281) CR52(3.875,8.281) CR54(5.469,8.281) CR56(7.063,8.281) CR58(8.656,8.281) CR60(10.25,8.281) CR62(11.844,8.281) CR64(13.437,8.281) CR66(15.031,8.281) CR70(16.625,8.281) CT73(18.656,8.251) CT75(20.388,8.251) CT77(22.121,8.251) CT79(23.853,8.251) CT81(25.585,8.251) CT83(27.317,8.251) CU27(-16.046,7.821) CU29(-14.452,7.821) CU31(-12.859,7.821) CU33(-11.265,7.821) CU35(-9.671,7.821) CU37(-8.078,7.821) CU39(-6.484,7.821) CU41(-4.89,7.821) CU43(-3.296,7.821) CU45(-1.703,7.821) CU47(-0.109,7.821) CU49(1.485,7.821) CU51(3.078,7.821) CU53(4.672,7.821) CU55(6.266,7.821) CU57(7.859,7.821) CU59(9.453,7.821) CU61(11.047,7.821) CU63(12.641,7.821) CU65(14.234,7.821) CU68(15.828,7.821) CV1(-27.317,7.791) CV6(-25.585,7.791) CV10(-23.853,7.791) CV14(-22.121,7.791) CV18(-20.388,7.791) CV22(-18.656,7.791) CW72(17.79,7.751) CW74(19.522,7.751) CW76(21.255,7.751) CW78(22.987,7.751) CW80(24.719,7.751) CW82(26.451,7.751) CY26(-16.843,7.361) CY28(-15.249,7.361) CY30(-13.655,7.361) CY32(-12.062,7.361) CY34(-10.468,7.361) CY36(-8.874,7.361) CY38(-7.281,7.361) CY40(-5.687,7.361) CY42(-4.093,7.361) CY44(-2.5,7.361) CY46(-0.906,7.361) CY48(0.688,7.361) CY50(2.282,7.361) CY52(3.875,7.361) CY54(5.469,7.361) CY56(7.063,7.361) CY58(8.656,7.361) CY60(10.25,7.361) CY62(11.844,7.361) CY64(13.437,7.361) CY66(15.031,7.361) CY70(16.625,7.361) D11(-23.217,21.162) D15(-21.623,21.162) D19(-20.03,21.162) D23(-18.436,21.162) D26(-16.842,21.162) D28(-15.249,21.162) D30(-13.655,21.162) D32(-12.061,21.162) D34(-10.467,21.162) D36(-8.874,21.162) D38(-7.28,21.162) D40(-5.686,21.162) D42(-4.093,21.162) D44(-2.499,21.162) D46(-0.905,21.162) D48(0.688,21.162) D50(2.282,21.162) D52(3.876,21.162) D54(5.47,21.162) D56(7.063,21.162) D58(8.657,21.162) D60(10.251,21.162) D62(11.844,21.162) D64(13.438,21.162) DA3(-26.451,7.291) DA8(-24.719,7.291) DA12(-22.987,7.291) DA16(-21.254,7.291) DA20(-19.522,7.291) DA24(-17.79,7.291) DB73(18.656,7.251) DB75(20.388,7.251) DB77(22.121,7.251) DB79(23.853,7.251) DB81(25.585,7.251) DB83(27.317,7.251) DC27(-16.046,6.9) DC29(-14.452,6.9) DC31(-12.859,6.9) DC33(-11.265,6.9) DC35(-9.671,6.9) DC37(-8.078,6.9) DC39(-6.484,6.9) DC41(-4.89,6.9) DC43(-3.296,6.9) DC45(-1.703,6.9) DC47(-0.109,6.9) DC49(1.485,6.9) DC51(3.078,6.9) DC53(4.672,6.9) DC55(6.266,6.9) DC57(7.859,6.9) DC59(9.453,6.9) DC61(11.047,6.9) DC63(12.641,6.9) DC65(14.234,6.9) DC68(15.828,6.9) DD1(-27.317,6.791) DD6(-25.585,6.791) DD10(-23.853,6.791) DD14(-22.121,6.791) DD18(-20.388,6.791) DD22(-18.656,6.791) DE72(17.79,6.751) DE74(19.522,6.751) DE76(21.255,6.751) DE78(22.987,6.751) DE80(24.719,6.751) DE82(26.451,6.751) DF26(-16.843,6.441) DF28(-15.249,6.441) DF30(-13.655,6.441) DF32(-12.062,6.441) DF34(-10.468,6.441) DF36(-8.874,6.441) DF38(-7.281,6.441) DF40(-5.687,6.441) DF42(-4.093,6.441) DF44(-2.5,6.441) DF46(-0.906,6.441) DF48(0.688,6.441) DF50(2.282,6.441) DF52(3.875,6.441) DF54(5.469,6.441) DF56(7.063,6.441) DF58(8.656,6.441) DF60(10.25,6.441) DF62(11.844,6.441) DF64(13.437,6.441) DF66(15.031,6.441) DF70(16.625,6.441) DG3(-26.451,6.29) DG8(-24.719,6.29) DG12(-22.987,6.29) DG16(-21.254,6.29) DG20(-19.522,6.29) DG24(-17.79,6.29) DH73(18.656,6.25) DH75(20.389,6.25) DH77(22.121,6.25) DH79(23.853,6.25) DH81(25.585,6.25) DH83(27.318,6.25) DJ27(-16.046,5.98) DJ29(-14.452,5.98) DJ31(-12.859,5.98) DJ33(-11.265,5.98) DJ35(-9.672,5.98) DJ37(-8.078,5.98) DJ39(-6.484,5.98) DJ41(-4.891,5.98) DJ43(-3.297,5.98) DJ45(-1.704,5.98) DJ47(-0.11,5.98) DJ49(1.484,5.98) DJ51(3.077,5.98) DJ53(4.671,5.98) DJ55(6.264,5.98) DJ57(7.858,5.98) DJ59(9.452,5.98) DJ61(11.045,5.98) DJ63(12.639,5.98) DJ65(14.232,5.98) DJ68(15.826,5.98) DK1(-27.317,5.79) DK6(-25.585,5.79) DK10(-23.853,5.79) DK14(-22.121,5.79) DK18(-20.388,5.79) DK22(-18.656,5.79) DL72(17.79,5.75) DL74(19.522,5.75) DL76(21.255,5.75) DL78(22.987,5.75) DL80(24.719,5.75) DL82(26.451,5.75) DM26(-16.843,5.52) DM28(-15.249,5.52) DM30(-13.655,5.52) DM32(-12.062,5.52) DM34(-10.468,5.52) DM36(-8.874,5.52) DM38(-7.281,5.52) DM40(-5.687,5.52) DM42(-4.093,5.52) DM44(-2.5,5.52) DM46(-0.906,5.52) DM48(0.688,5.52) DM50(2.282,5.52) DM52(3.875,5.52) DM54(5.469,5.52) DM56(7.063,5.52) DM58(8.656,5.52) DM60(10.25,5.52) DM62(11.844,5.52) DM64(13.437,5.52) DM66(15.031,5.52) DM70(16.625,5.52) DN3(-26.451,5.29) DN8(-24.719,5.29) DN12(-22.987,5.29) DN16(-21.254,5.29) DN20(-19.522,5.29) DN24(-17.79,5.29) DP73(18.656,5.25) DP75(20.389,5.25) DP77(22.121,5.25) DP79(23.853,5.25) DP81(25.585,5.25) DP83(27.318,5.25) DR27(-16.046,5.06) DR29(-14.452,5.06) DR31(-12.859,5.06) DR33(-11.265,5.06) DR35(-9.672,5.06) DR37(-8.078,5.06) DR39(-6.484,5.06) DR53(4.671,5.06) DR55(6.265,5.06) DR57(7.858,5.06) DR59(9.452,5.06) DR61(11.045,5.06) DR63(12.639,5.06) DR65(14.233,5.06) DR68(15.826,5.06) DT1(-27.317,4.79) DT6(-25.585,4.79) DT10(-23.853,4.79) DT14(-22.121,4.79) DT18(-20.388,4.79) DT22(-18.656,4.79) DU72(17.79,4.75) DU74(19.522,4.75) DU76(21.255,4.75) DU78(22.987,4.75) DU80(24.719,4.75) DU82(26.451,4.75) DV26(-16.843,4.6) DV28(-15.249,4.6) DV30(-13.655,4.6) DV32(-12.062,4.6) DV34(-10.468,4.6) DV36(-8.874,4.6) DV38(-7.281,4.6) DV40(-5.687,4.6) DV54(5.468,4.6) DV56(7.061,4.6) DV58(8.655,4.6) DV60(10.249,4.6) DV62(11.842,4.6) DV64(13.436,4.6) DV66(15.03,4.6) DV70(16.624,4.6) DW3(-26.451,4.29) DW8(-24.719,4.29) DW12(-22.987,4.29) DW16(-21.254,4.29) DW20(-19.522,4.29) DW24(-17.79,4.29) DY73(18.656,4.25) DY75(20.389,4.25) DY77(22.121,4.25) DY79(23.853,4.25) DY81(25.585,4.25) DY83(27.318,4.25) E69(16.058,20.752) E72(17.79,20.752) E74(19.522,20.752) E76(21.255,20.752) E78(22.987,20.752) E80(24.719,20.752) EA27(-16.046,4.14) EA29(-14.452,4.14) EA31(-12.859,4.14) EA33(-11.265,4.14) EA35(-9.672,4.14) EA37(-8.078,4.14) EA39(-6.484,4.14) EA53(4.671,4.14) EA55(6.265,4.14) EA57(7.858,4.14) EA59(9.452,4.14) EA61(11.045,4.14) EA63(12.639,4.14) EA65(14.233,4.14) EA68(15.826,4.14) EB1(-27.317,3.79) EB6(-25.585,3.79) EB10(-23.853,3.79) EB14(-22.121,3.79) EB18(-20.388,3.79) EB22(-18.656,3.79) EC72(17.79,3.75) EC74(19.522,3.75) EC76(21.255,3.75) EC78(22.987,3.75) EC80(24.719,3.75) EC82(26.451,3.75) ED26(-16.843,3.68) ED28(-15.249,3.68) ED30(-13.655,3.68) ED32(-12.062,3.68) ED34(-10.468,3.68) ED36(-8.874,3.68) ED38(-7.281,3.68) ED40(-5.687,3.68) ED54(5.468,3.68) ED56(7.061,3.68) ED58(8.655,3.68) ED60(10.249,3.68) ED62(11.842,3.68) ED64(13.436,3.68) ED66(15.03,3.68) ED70(16.624,3.68) EE3(-26.451,3.29) EE8(-24.719,3.29) EE12(-22.987,3.29) EE16(-21.254,3.29) EE20(-19.522,3.29) EE24(-17.79,3.29) EF73(18.656,3.25) EF75(20.389,3.25) EF77(22.121,3.25) EF79(23.853,3.25) EF81(25.585,3.25) EF83(27.318,3.25) EG27(-16.046,3.22) EG29(-14.452,3.22) EG31(-12.859,3.22) EG33(-11.265,3.22) EG35(-9.672,3.22) EG37(-8.078,3.22) EG39(-6.484,3.22) EG53(4.671,3.22) EG55(6.265,3.22) EG57(7.858,3.22) EG59(9.452,3.22) EG61(11.045,3.22) EG63(12.639,3.22) EG65(14.233,3.22) EG68(15.826,3.22) EH1(-27.317,2.79) EH6(-25.585,2.79) EH10(-23.853,2.79) EH14(-22.121,2.79) EH18(-20.388,2.79) EH22(-18.656,2.79) EJ26(-16.843,2.76) EJ28(-15.249,2.76) EJ30(-13.655,2.76) EJ32(-12.062,2.76) EJ34(-10.468,2.76) EJ36(-8.874,2.76) EJ38(-7.281,2.76) EJ40(-5.687,2.76) EJ54(5.468,2.76) EJ56(7.061,2.76) EJ58(8.655,2.76) EJ60(10.249,2.76) EJ62(11.842,2.76) EJ64(13.436,2.76) EJ66(15.03,2.76) EJ70(16.624,2.76) EK72(17.79,2.75) EK74(19.522,2.75) EK76(21.255,2.75) EK78(22.987,2.75) EK80(24.719,2.75) EK82(26.451,2.75) EL27(-16.046,2.3) EL29(-14.452,2.3) EL31(-12.859,2.3) EL33(-11.265,2.3) EL35(-9.672,2.3) EL37(-8.078,2.3) EL39(-6.484,2.3) EL53(4.671,2.3) EL55(6.265,2.3) EL57(7.858,2.3) EL59(9.452,2.3) EL61(11.045,2.3) EL63(12.639,2.3) EL65(14.233,2.3) EL68(15.826,2.3) EM3(-26.451,2.29) EM8(-24.719,2.29) EM12(-22.987,2.29) EM16(-21.254,2.29) EM20(-19.522,2.29) EM24(-17.79,2.29) EN73(18.656,2.25) EN75(20.389,2.25) EN77(22.121,2.25) EN79(23.853,2.25) EN81(25.585,2.25) EN83(27.318,2.25) EP26(-16.843,1.84) EP28(-15.249,1.84) EP30(-13.655,1.84) EP32(-12.062,1.84) EP34(-10.468,1.84) EP36(-8.874,1.84) EP38(-7.281,1.84) EP40(-5.687,1.84) EP54(5.468,1.84) EP56(7.061,1.84) EP58(8.655,1.84) EP60(10.249,1.84) EP62(11.842,1.84) EP64(13.436,1.84) EP66(15.03,1.84) EP70(16.624,1.84) ER1(-27.317,1.79) ER6(-25.585,1.79) ER10(-23.853,1.79) ER14(-22.121,1.79) ER18(-20.388,1.79) ER22(-18.656,1.79) ET72(17.79,1.75) ET74(19.522,1.75) ET76(21.255,1.75) ET78(22.987,1.75) ET80(24.719,1.75) ET82(26.451,1.75) EU27(-16.046,1.38) EU29(-14.452,1.38) EU31(-12.859,1.38) EU33(-11.265,1.38) EU35(-9.672,1.38) EU37(-8.078,1.38) EU39(-6.484,1.38) EU53(4.671,1.38) EU55(6.265,1.38) EU57(7.858,1.38) EU59(9.452,1.38) EU61(11.045,1.38) EU63(12.639,1.38) EU65(14.233,1.38) EU68(15.826,1.38) EV3(-26.451,1.29) EV8(-24.719,1.29) EV12(-22.987,1.29) EV16(-21.254,1.29) EV20(-19.522,1.29) EV24(-17.79,1.29) EW73(18.656,1.25) EW75(20.389,1.25) EW77(22.121,1.25) EW79(23.853,1.25) EW81(25.585,1.25) EW83(27.318,1.25) EY26(-16.843,0.92) EY28(-15.249,0.92) EY30(-13.655,0.92) EY32(-12.062,0.92) EY34(-10.468,0.92) EY36(-8.874,0.92) EY38(-7.281,0.92) EY40(-5.687,0.92) EY54(5.468,0.92) EY56(7.061,0.92) EY58(8.655,0.92) EY60(10.249,0.92) EY62(11.842,0.92) EY64(13.436,0.92) EY66(15.03,0.92) EY70(16.624,0.92) F9(-24.014,20.702) F13(-22.42,20.702) F17(-20.827,20.702) F21(-19.233,20.702) F25(-17.639,20.702) F27(-16.045,20.702) F29(-14.452,20.702) F31(-12.858,20.702) F33(-11.264,20.702) F35(-9.671,20.702) F37(-8.077,20.702) F39(-6.483,20.702) F41(-4.889,20.702) F43(-3.296,20.702) F45(-1.702,20.702) F47(-0.108,20.702) F49(1.485,20.702) F51(3.079,20.702) F53(4.673,20.702) F55(6.266,20.702) F57(7.86,20.702) F59(9.454,20.702) F61(11.048,20.702) F63(12.641,20.702) F65(14.235,20.702) FA1(-27.317,0.79) FA6(-25.585,0.79) FA10(-23.853,0.79) FA14(-22.121,0.79) FA18(-20.388,0.79) FA22(-18.656,0.79) FB72(17.79,0.75) FB74(19.522,0.75) FB76(21.255,0.75) FB78(22.987,0.75) FB80(24.719,0.75) FB82(26.451,0.75) FC27(-16.046,0.46) FC29(-14.452,0.46) FC31(-12.859,0.46) FC33(-11.265,0.46) FC35(-9.672,0.46) FC37(-8.078,0.46) FC39(-6.484,0.46) FC53(4.671,0.46) FC55(6.265,0.46) FC57(7.858,0.46) FC59(9.452,0.46) FC61(11.045,0.46) FC63(12.639,0.46) FC65(14.233,0.46) FC68(15.826,0.46) FD3(-26.451,0.29) FD8(-24.719,0.29) FD12(-22.987,0.29) FD16(-21.254,0.29) FD20(-19.522,0.29) FD24(-17.79,0.29) FE73(18.656,0.25) FE75(20.389,0.25) FE77(22.121,0.25) FE79(23.853,0.25) FE81(25.585,0.25) FE83(27.318,0.25) FF26(-16.843,0) FF28(-15.249,0) FF30(-13.655,0) FF32(-12.062,0) FF34(-10.468,0) FF36(-8.874,0) FF38(-7.281,0) FF40(-5.687,0) FF54(5.468,0) FF56(7.061,0) FF58(8.655,0) FF60(10.249,0) FF62(11.842,0) FF64(13.436,0) FF66(15.03,0) FF70(16.624,0) FG1(-27.317,-0.21) FG6(-25.585,-0.21) FG10(-23.853,-0.21) FG14(-22.121,-0.21) FG18(-20.388,-0.21) FG22(-18.656,-0.21) FH72(17.79,-0.25) FH74(19.522,-0.25) FH76(21.255,-0.25) FH78(22.987,-0.25) FH80(24.719,-0.25) FH82(26.451,-0.25) FJ27(-16.046,-0.46) FJ29(-14.452,-0.46) FJ31(-12.859,-0.46) FJ33(-11.265,-0.46) FJ35(-9.672,-0.46) FJ37(-8.078,-0.46) FJ39(-6.484,-0.46) FJ53(4.671,-0.46) FJ55(6.265,-0.46) FJ57(7.858,-0.46) FJ59(9.452,-0.46) FJ61(11.045,-0.46) FJ63(12.639,-0.46) FJ65(14.233,-0.46) FJ68(15.826,-0.46) FK3(-26.451,-0.71) FK8(-24.719,-0.71) FK12(-22.987,-0.71) FK16(-21.254,-0.71) FK20(-19.522,-0.71) FK24(-17.79,-0.71) FL73(18.656,-0.75) FL75(20.389,-0.75) FL77(22.121,-0.75) FL79(23.853,-0.75) FL81(25.585,-0.75) FL83(27.318,-0.75) FM26(-16.843,-0.92) FM28(-15.249,-0.92) FM30(-13.655,-0.92) FM32(-12.062,-0.92) FM34(-10.468,-0.92) FM36(-8.874,-0.92) FM38(-7.281,-0.92) FM40(-5.687,-0.92) FM54(5.468,-0.92) FM56(7.061,-0.92) FM58(8.655,-0.92) FM60(10.249,-0.92) FM62(11.842,-0.92) FM64(13.436,-0.92) FM66(15.03,-0.92) FM70(16.624,-0.92) FN1(-27.317,-1.21) FN6(-25.585,-1.21) FN10(-23.853,-1.21) FN14(-22.121,-1.21) FN18(-20.388,-1.21) FN22(-18.656,-1.21) FP72(17.79,-1.25) FP74(19.522,-1.25) FP76(21.255,-1.25) FP78(22.987,-1.25) FP80(24.719,-1.25) FP82(26.451,-1.25) FR27(-16.046,-1.38) FR29(-14.452,-1.38) FR31(-12.859,-1.38) FR33(-11.265,-1.38) FR35(-9.672,-1.38) FR37(-8.078,-1.38) FR39(-6.484,-1.38) FR53(4.671,-1.38) FR55(6.265,-1.38) FR57(7.858,-1.38) FR59(9.452,-1.38) FR61(11.045,-1.38) FR63(12.639,-1.38) FR65(14.233,-1.38) FR68(15.826,-1.38) FT3(-26.451,-1.71) FT8(-24.719,-1.71) FT12(-22.987,-1.71) FT16(-21.254,-1.71) FT20(-19.522,-1.71) FT24(-17.79,-1.71) FU73(18.656,-1.75) FU75(20.389,-1.75) FU77(22.121,-1.75) FU79(23.853,-1.75) FU81(25.585,-1.75) FU83(27.318,-1.75) FV26(-16.843,-1.84) FV28(-15.249,-1.84) FV30(-13.655,-1.84) FV32(-12.062,-1.84) FV34(-10.468,-1.84) FV36(-8.874,-1.84) FV38(-7.281,-1.84) FV40(-5.687,-1.84) FV54(5.468,-1.84) FV56(7.061,-1.84) FV58(8.655,-1.84) FV60(10.249,-1.84) FV62(11.842,-1.84) FV64(13.436,-1.84) FV66(15.03,-1.84) FV70(16.624,-1.84) FW1(-27.317,-2.21) FW6(-25.585,-2.21) FW10(-23.853,-2.21) FW14(-22.121,-2.21) FW18(-20.388,-2.21) FW22(-18.656,-2.21) FY72(17.79,-2.25) FY74(19.522,-2.25) FY76(21.255,-2.25) FY78(22.987,-2.25) FY80(24.719,-2.25) FY82(26.451,-2.25) G67(15.192,20.252) G71(16.924,20.252) G73(18.656,20.252) G75(20.388,20.252) G77(22.121,20.252) G79(23.853,20.252) G81(25.585,20.252) GA27(-16.046,-2.3) GA29(-14.452,-2.3) GA31(-12.859,-2.3) GA33(-11.265,-2.3) GA35(-9.672,-2.3) GA37(-8.078,-2.3) GA39(-6.484,-2.3) GA53(4.671,-2.3) GA55(6.265,-2.3) GA57(7.858,-2.3) GA59(9.452,-2.3) GA61(11.045,-2.3) GA63(12.639,-2.3) GA65(14.233,-2.3) GA68(15.826,-2.3) GB3(-26.451,-2.71) GB8(-24.719,-2.71) GB12(-22.987,-2.71) GB16(-21.254,-2.71) GB20(-19.522,-2.71) GB24(-17.79,-2.71) GC73(18.656,-2.75) GC75(20.389,-2.75) GC77(22.121,-2.75) GC79(23.853,-2.75) GC81(25.585,-2.75) GC83(27.318,-2.75) GD26(-16.843,-2.76) GD28(-15.249,-2.76) GD30(-13.655,-2.76) GD32(-12.062,-2.76) GD34(-10.468,-2.76) GD36(-8.874,-2.76) GD38(-7.281,-2.76) GD40(-5.687,-2.76) GD54(5.468,-2.76) GD56(7.061,-2.76) GD58(8.655,-2.76) GD60(10.249,-2.76) GD62(11.842,-2.76) GD64(13.436,-2.76) GD66(15.03,-2.76) GD70(16.624,-2.76) GE1(-27.317,-3.21) GE6(-25.585,-3.21) GE10(-23.853,-3.21) GE14(-22.121,-3.21) GE18(-20.388,-3.21) GE22(-18.656,-3.21) GF27(-16.046,-3.22) GF29(-14.452,-3.22) GF31(-12.859,-3.22) GF33(-11.265,-3.22) GF35(-9.672,-3.22) GF37(-8.078,-3.22) GF39(-6.484,-3.22) GF53(4.671,-3.22) GF55(6.265,-3.22) GF57(7.858,-3.22) GF59(9.452,-3.22) GF61(11.045,-3.22) GF63(12.639,-3.22) GF65(14.233,-3.22) GF68(15.826,-3.22) GG72(17.79,-3.25) GG74(19.522,-3.25) GG76(21.255,-3.25) GG78(22.987,-3.25) GG80(24.719,-3.25) GG82(26.451,-3.25) GH26(-16.843,-3.68) GH28(-15.249,-3.68) GH30(-13.655,-3.68) GH32(-12.062,-3.68) GH34(-10.468,-3.68) GH36(-8.874,-3.68) GH38(-7.281,-3.68) GH40(-5.687,-3.68) GH54(5.468,-3.68) GH56(7.061,-3.68) GH58(8.655,-3.68) GH60(10.249,-3.68) GH62(11.842,-3.68) GH64(13.436,-3.68) GH66(15.03,-3.68) GH70(16.624,-3.68) GJ3(-26.451,-3.71) GJ8(-24.719,-3.71) GJ12(-22.987,-3.71) GJ16(-21.254,-3.71) GJ20(-19.522,-3.71) GJ24(-17.79,-3.71) GK73(18.656,-3.75) GK75(20.389,-3.75) GK77(22.121,-3.75) GK79(23.853,-3.75) GK81(25.585,-3.75) GK83(27.318,-3.75) GL27(-16.046,-4.14) GL29(-14.452,-4.14) GL31(-12.859,-4.14) GL33(-11.265,-4.14) GL35(-9.672,-4.14) GL37(-8.078,-4.14) GL39(-6.484,-4.14) GL53(4.671,-4.14) GL55(6.265,-4.14) GL57(7.858,-4.14) GL59(9.452,-4.14) GL61(11.045,-4.14) GL63(12.639,-4.14) GL65(14.233,-4.14) GL68(15.826,-4.14) GM1(-27.317,-4.21) GM6(-25.585,-4.21) GM10(-23.853,-4.21) GM14(-22.121,-4.21) GM18(-20.388,-4.21) GM22(-18.656,-4.21) GN72(17.79,-4.25) GN74(19.522,-4.25) GN76(21.255,-4.25) GN78(22.987,-4.25) GN80(24.719,-4.25) GN82(26.451,-4.25) GP26(-16.843,-4.6) GP28(-15.249,-4.6) GP30(-13.655,-4.6) GP32(-12.062,-4.6) GP34(-10.468,-4.6) GP36(-8.874,-4.6) GP38(-7.281,-4.6) GP40(-5.687,-4.6) GP54(5.468,-4.6) GP56(7.061,-4.6) GP58(8.655,-4.6) GP60(10.249,-4.6) GP62(11.842,-4.6) GP64(13.436,-4.6) GP66(15.03,-4.6) GP70(16.624,-4.6) GR3(-26.451,-4.71) GR8(-24.719,-4.71) GR12(-22.987,-4.71) GR16(-21.254,-4.71) GR20(-19.522,-4.71) GR24(-17.79,-4.71) GT73(18.656,-4.75) GT75(20.389,-4.75) GT77(22.121,-4.75) GT79(23.853,-4.75) GT81(25.585,-4.75) GT83(27.318,-4.75) GU27(-16.046,-5.06) GU29(-14.452,-5.06) GU31(-12.859,-5.06) GU33(-11.265,-5.06) GU35(-9.672,-5.06) GU37(-8.078,-5.06) GU39(-6.484,-5.06) GU53(4.671,-5.06) GU55(6.265,-5.06) GU57(7.858,-5.06) GU59(9.452,-5.06) GU61(11.045,-5.06) GU63(12.639,-5.06) GU65(14.233,-5.06) GU68(15.826,-5.06) GV1(-27.317,-5.21) GV6(-25.585,-5.21) GV10(-23.853,-5.21) GV14(-22.121,-5.21) GV18(-20.388,-5.21) GV22(-18.656,-5.21) GW72(17.79,-5.251) GW74(19.522,-5.251) GW76(21.255,-5.251) GW78(22.987,-5.251) GW80(24.719,-5.251) GW82(26.451,-5.251) GY26(-16.843,-5.52) GY28(-15.249,-5.52) GY30(-13.655,-5.52) GY32(-12.062,-5.52) GY34(-10.468,-5.52) GY36(-8.874,-5.52) GY38(-7.281,-5.52) GY40(-5.687,-5.52) GY42(-4.094,-5.52) GY44(-2.5,-5.52) GY46(-0.907,-5.52) GY48(0.687,-5.52) GY50(2.281,-5.52) GY52(3.874,-5.52) GY54(5.468,-5.52) GY56(7.062,-5.52) GY58(8.656,-5.52) GY60(10.249,-5.52) GY62(11.843,-5.52) GY64(13.437,-5.52) GY66(15.03,-5.52) GY70(16.624,-5.52) H7(-24.811,20.242) H11(-23.217,20.242) H15(-21.623,20.242) H19(-20.03,20.242) H23(-18.436,20.242) H26(-16.842,20.242) H28(-15.249,20.242) H30(-13.655,20.242) H32(-12.061,20.242) H34(-10.467,20.242) H36(-8.874,20.242) H38(-7.28,20.242) H40(-5.686,20.242) H42(-4.093,20.242) H44(-2.499,20.242) H46(-0.905,20.242) H48(0.688,20.242) H50(2.282,20.242) H52(3.876,20.242) H54(5.47,20.242) H56(7.063,20.242) H58(8.657,20.242) H60(10.251,20.242) H62(11.844,20.242) H64(13.438,20.242) HA3(-26.451,-5.711) HA8(-24.719,-5.711) HA12(-22.987,-5.711) HA16(-21.254,-5.711) HA20(-19.522,-5.711) HA24(-17.79,-5.711) HB73(18.656,-5.751) HB75(20.389,-5.751) HB77(22.121,-5.751) HB79(23.853,-5.751) HB81(25.585,-5.751) HB83(27.318,-5.751) HC27(-16.046,-5.981) HC29(-14.452,-5.981) HC31(-12.859,-5.981) HC33(-11.265,-5.981) HC35(-9.672,-5.981) HC37(-8.078,-5.981) HC39(-6.484,-5.981) HC41(-4.891,-5.981) HC43(-3.297,-5.981) HC45(-1.704,-5.981) HC47(-0.11,-5.981) HC49(1.484,-5.981) HC51(3.077,-5.981) HC53(4.671,-5.981) HC55(6.265,-5.981) HC57(7.858,-5.981) HC59(9.452,-5.981) HC61(11.045,-5.981) HC63(12.639,-5.981) HC65(14.233,-5.981) HC68(15.826,-5.981) HD1(-27.317,-6.211) HD6(-25.585,-6.211) HD10(-23.853,-6.211) HD14(-22.121,-6.211) HD18(-20.388,-6.211) HD22(-18.656,-6.211) HE72(17.79,-6.251) HE74(19.522,-6.251) HE76(21.255,-6.251) HE78(22.987,-6.251) HE80(24.719,-6.251) HE82(26.451,-6.251) HF26(-16.843,-6.441) HF28(-15.249,-6.441) HF30(-13.655,-6.441) HF32(-12.062,-6.441) HF34(-10.468,-6.441) HF36(-8.874,-6.441) HF38(-7.281,-6.441) HF40(-5.687,-6.441) HF42(-4.094,-6.441) HF44(-2.5,-6.441) HF46(-0.907,-6.441) HF48(0.687,-6.441) HF50(2.281,-6.441) HF52(3.874,-6.441) HF54(5.468,-6.441) HF56(7.062,-6.441) HF58(8.656,-6.441) HF60(10.249,-6.441) HF62(11.843,-6.441) HF64(13.437,-6.441) HF66(15.03,-6.441) HF70(16.624,-6.441) HG3(-26.451,-6.711) HG8(-24.719,-6.711) HG12(-22.987,-6.711) HG16(-21.254,-6.711) HG20(-19.522,-6.711) HG24(-17.79,-6.711) HH73(18.656,-6.751) HH75(20.389,-6.751) HH77(22.121,-6.751) HH79(23.853,-6.751) HH81(25.585,-6.751) HH83(27.318,-6.751) HJ27(-16.046,-6.9) HJ29(-14.452,-6.9) HJ31(-12.859,-6.9) HJ33(-11.265,-6.9) HJ35(-9.672,-6.9) HJ37(-8.078,-6.9) HJ39(-6.484,-6.9) HJ41(-4.891,-6.9) HJ43(-3.297,-6.9) HJ45(-1.704,-6.9) HJ47(-0.11,-6.9) HJ49(1.484,-6.9) HJ51(3.077,-6.9) HJ53(4.671,-6.9) HJ55(6.264,-6.9) HJ57(7.858,-6.9) HJ59(9.452,-6.9) HJ61(11.045,-6.9) HJ63(12.639,-6.9) HJ65(14.232,-6.9) HJ68(15.826,-6.9) HK1(-27.317,-7.211) HK6(-25.585,-7.211) HK10(-23.853,-7.211) HK14(-22.121,-7.211) HK18(-20.388,-7.211) HK22(-18.656,-7.211) HL72(17.79,-7.251) HL74(19.522,-7.251) HL76(21.255,-7.251) HL78(22.987,-7.251) HL80(24.719,-7.251) HL82(26.451,-7.251) HM26(-16.843,-7.36) HM28(-15.249,-7.36) HM30(-13.655,-7.36) HM32(-12.062,-7.36) HM34(-10.468,-7.36) HM36(-8.874,-7.36) HM38(-7.281,-7.36) HM40(-5.687,-7.36) HM42(-4.093,-7.36) HM44(-2.5,-7.36) HM46(-0.906,-7.36) HM48(0.688,-7.36) HM50(2.282,-7.36) HM52(3.875,-7.36) HM54(5.469,-7.36) HM56(7.063,-7.36) HM58(8.656,-7.36) HM60(10.25,-7.36) HM62(11.844,-7.36) HM64(13.437,-7.36) HM66(15.031,-7.36) HM70(16.625,-7.36) HN3(-26.451,-7.711) HN8(-24.719,-7.711) HN12(-22.987,-7.711) HN16(-21.254,-7.711) HN20(-19.522,-7.711) HN24(-17.79,-7.711) HP73(18.656,-7.751) HP75(20.389,-7.751) HP77(22.121,-7.751) HP79(23.853,-7.751) HP81(25.585,-7.751) HP83(27.318,-7.751) HR27(-16.046,-7.821) HR29(-14.452,-7.821) HR31(-12.859,-7.821) HR33(-11.265,-7.821) HR35(-9.672,-7.821) HR37(-8.078,-7.821) HR39(-6.484,-7.821) HR41(-4.891,-7.821) HR43(-3.297,-7.821) HR45(-1.704,-7.821) HR47(-0.11,-7.821) HR49(1.484,-7.821) HR51(3.077,-7.821) HR53(4.671,-7.821) HR55(6.264,-7.821) HR57(7.858,-7.821) HR59(9.452,-7.821) HR61(11.045,-7.821) HR63(12.639,-7.821) HR65(14.232,-7.821) HR68(15.826,-7.821) HT1(-27.317,-8.211) HT6(-25.585,-8.211) HT10(-23.853,-8.211) HT14(-22.121,-8.211) HT18(-20.388,-8.211) HT22(-18.656,-8.211) HU72(17.79,-8.251) HU74(19.522,-8.251) HU76(21.255,-8.251) HU78(22.987,-8.251) HU80(24.719,-8.251) HU82(26.451,-8.251) HV26(-16.843,-8.281) HV28(-15.249,-8.281) HV30(-13.655,-8.281) HV32(-12.062,-8.281) HV34(-10.468,-8.281) HV36(-8.874,-8.281) HV38(-7.281,-8.281) HV40(-5.687,-8.281) HV42(-4.093,-8.281) HV44(-2.5,-8.281) HV46(-0.906,-8.281) HV48(0.688,-8.281) HV50(2.282,-8.281) HV52(3.875,-8.281) HV54(5.469,-8.281) HV56(7.063,-8.281) HV58(8.656,-8.281) HV60(10.25,-8.281) HV62(11.844,-8.281) HV64(13.437,-8.281) HV66(15.031,-8.281) HV70(16.625,-8.281) HW3(-26.451,-8.711) HW8(-24.719,-8.711) HW12(-22.987,-8.711) HW16(-21.254,-8.711) HW20(-19.522,-8.711) HW24(-17.79,-8.711) HY27(-16.046,-8.741) HY29(-14.452,-8.741) HY31(-12.859,-8.741) HY33(-11.265,-8.741) HY35(-9.672,-8.741) HY37(-8.078,-8.741) HY39(-6.484,-8.741) HY41(-4.891,-8.741) HY43(-3.297,-8.741) HY45(-1.704,-8.741) HY47(-0.11,-8.741) HY49(1.484,-8.741) HY51(3.077,-8.741) HY53(4.671,-8.741) HY55(6.264,-8.741) HY57(7.858,-8.741) HY59(9.452,-8.741) HY61(11.045,-8.741) HY63(12.639,-8.741) HY65(14.232,-8.741) HY68(15.826,-8.741) J5(-25.608,19.781) J9(-24.014,19.781) J13(-22.42,19.781) J17(-20.827,19.781) J21(-19.233,19.781) J25(-17.639,19.781) J27(-16.045,19.781) J29(-14.452,19.781) J31(-12.858,19.781) J33(-11.264,19.781) J35(-9.671,19.781) J37(-8.077,19.781) J39(-6.483,19.781) J41(-4.889,19.781) J43(-3.296,19.781) J45(-1.702,19.781) J47(-0.108,19.781) J49(1.485,19.781) J51(3.079,19.781) J53(4.673,19.781) J55(6.266,19.781) J57(7.86,19.781) J59(9.454,19.781) J61(11.048,19.781) J63(12.641,19.781) J65(14.235,19.781) JA73(18.656,-8.751) JA75(20.389,-8.751) JA77(22.121,-8.751) JA79(23.853,-8.751) JA81(25.585,-8.751) JA83(27.318,-8.751) JB26(-16.843,-9.201) JB28(-15.249,-9.201) JB30(-13.655,-9.201) JB32(-12.062,-9.201) JB34(-10.468,-9.201) JB36(-8.874,-9.201) JB38(-7.281,-9.201) JB40(-5.687,-9.201) JB42(-4.093,-9.201) JB44(-2.5,-9.201) JB46(-0.906,-9.201) JB48(0.688,-9.201) JB50(2.282,-9.201) JB52(3.875,-9.201) JB54(5.469,-9.201) JB56(7.063,-9.201) JB58(8.656,-9.201) JB60(10.25,-9.201) JB62(11.844,-9.201) JB64(13.437,-9.201) JB66(15.031,-9.201) JB70(16.625,-9.201) JC1(-27.317,-9.211) JC6(-25.585,-9.211) JC10(-23.853,-9.211) JC14(-22.121,-9.211) JC18(-20.388,-9.211) JC22(-18.656,-9.211) JD72(17.79,-9.251) JD74(19.522,-9.251) JD76(21.255,-9.251) JD78(22.987,-9.251) JD80(24.719,-9.251) JD82(26.451,-9.251) JE27(-16.046,-9.661) JE29(-14.452,-9.661) JE31(-12.859,-9.661) JE33(-11.265,-9.661) JE35(-9.672,-9.661) JE37(-8.078,-9.661) JE39(-6.484,-9.661) JE41(-4.891,-9.661) JE43(-3.297,-9.661) JE45(-1.704,-9.661) JE47(-0.11,-9.661) JE49(1.484,-9.661) JE51(3.077,-9.661) JE53(4.671,-9.661) JE55(6.264,-9.661) JE57(7.858,-9.661) JE59(9.452,-9.661) JE61(11.045,-9.661) JE63(12.639,-9.661) JE65(14.232,-9.661) JE68(15.826,-9.661) JF3(-26.451,-9.711) JF8(-24.719,-9.711) JF12(-22.987,-9.711) JF16(-21.254,-9.711) JF20(-19.522,-9.711) JF24(-17.79,-9.711) JG73(18.656,-9.751) JG75(20.389,-9.751) JG77(22.121,-9.751) JG79(23.853,-9.751) JG81(25.585,-9.751) JG83(27.318,-9.751) JH26(-16.843,-10.121) JH28(-15.249,-10.121) JH30(-13.655,-10.121) JH32(-12.062,-10.121) JH34(-10.468,-10.121) JH36(-8.874,-10.121) JH38(-7.281,-10.121) JH40(-5.687,-10.121) JH42(-4.093,-10.121) JH44(-2.5,-10.121) JH46(-0.906,-10.121) JH48(0.688,-10.121) JH50(2.282,-10.121) JH52(3.875,-10.121) JH54(5.469,-10.121) JH56(7.063,-10.121) JH58(8.656,-10.121) JH60(10.25,-10.121) JH62(11.844,-10.121) JH64(13.437,-10.121) JH66(15.031,-10.121) JH70(16.625,-10.121) JJ1(-27.317,-10.211) JJ6(-25.585,-10.211) JJ10(-23.853,-10.211) JJ14(-22.121,-10.211) JJ18(-20.388,-10.211) JJ22(-18.656,-10.211) JK72(17.79,-10.251) JK74(19.522,-10.251) JK76(21.255,-10.251) JK78(22.987,-10.251) JK80(24.719,-10.251) JK82(26.451,-10.251) JL27(-16.046,-10.581) JL29(-14.452,-10.581) JL31(-12.859,-10.581) JL33(-11.265,-10.581) JL35(-9.672,-10.581) JL37(-8.078,-10.581) JL39(-6.484,-10.581) JL41(-4.891,-10.581) JL43(-3.297,-10.581) JL45(-1.704,-10.581) JL47(-0.11,-10.581) JL49(1.484,-10.581) JL51(3.077,-10.581) JL53(4.671,-10.581) JL55(6.264,-10.581) JL57(7.858,-10.581) JL59(9.452,-10.581) JL61(11.045,-10.581) JL63(12.639,-10.581) JL65(14.232,-10.581) JL68(15.826,-10.581) JM3(-26.451,-10.711) JM8(-24.719,-10.711) JM12(-22.987,-10.711) JM16(-21.254,-10.711) JM20(-19.522,-10.711) JM24(-17.79,-10.711) JN73(18.656,-10.751) JN75(20.389,-10.751) JN77(22.121,-10.751) JN79(23.853,-10.751) JN81(25.585,-10.751) JN83(27.318,-10.751) JP26(-16.843,-11.041) JP28(-15.249,-11.041) JP30(-13.655,-11.041) JP32(-12.062,-11.041) JP34(-10.468,-11.041) JP36(-8.874,-11.041) JP38(-7.281,-11.041) JP40(-5.687,-11.041) JP42(-4.093,-11.041) JP44(-2.5,-11.041) JP46(-0.906,-11.041) JP48(0.688,-11.041) JP50(2.282,-11.041) JP52(3.875,-11.041) JP54(5.469,-11.041) JP56(7.063,-11.041) JP58(8.656,-11.041) JP60(10.25,-11.041) JP62(11.844,-11.041) JP64(13.437,-11.041) JP66(15.031,-11.041) JP70(16.625,-11.041) JR1(-27.317,-11.211) JR6(-25.585,-11.211) JR10(-23.853,-11.211) JR14(-22.121,-11.211) JR18(-20.388,-11.211) JR22(-18.656,-11.211) JT72(17.79,-11.251) JT74(19.522,-11.251) JT76(21.255,-11.251) JT78(22.987,-11.251) JT80(24.719,-11.251) JT82(26.451,-11.251) JU27(-16.046,-11.501) JU29(-14.452,-11.501) JU31(-12.859,-11.501) JU33(-11.265,-11.501) JU35(-9.672,-11.501) JU37(-8.078,-11.501) JU39(-6.484,-11.501) JU41(-4.891,-11.501) JU43(-3.297,-11.501) JU45(-1.704,-11.501) JU47(-0.11,-11.501) JU49(1.484,-11.501) JU51(3.077,-11.501) JU53(4.671,-11.501) JU55(6.264,-11.501) JU57(7.858,-11.501) JU59(9.452,-11.501) JU61(11.045,-11.501) JU63(12.639,-11.501) JU65(14.232,-11.501) JU68(15.826,-11.501) JV3(-26.451,-11.711) JV8(-24.719,-11.711) JV12(-22.987,-11.711) JV16(-21.254,-11.711) JV20(-19.522,-11.711) JV24(-17.79,-11.711) JW73(18.656,-11.751) JW75(20.389,-11.751) JW77(22.121,-11.751) JW79(23.853,-11.751) JW81(25.585,-11.751) JW83(27.318,-11.751) JY26(-16.843,-11.961) JY28(-15.249,-11.961) JY30(-13.655,-11.961) JY32(-12.062,-11.961) JY34(-10.468,-11.961) JY36(-8.874,-11.961) JY38(-7.281,-11.961) JY40(-5.687,-11.961) JY42(-4.093,-11.961) JY44(-2.5,-11.961) JY46(-0.906,-11.961) JY48(0.688,-11.961) JY50(2.282,-11.961) JY52(3.875,-11.961) JY54(5.469,-11.961) JY56(7.063,-11.961) JY58(8.656,-11.961) JY60(10.25,-11.961) JY62(11.844,-11.961) JY64(13.437,-11.961) JY66(15.031,-11.961) JY70(16.623,-11.961) K69(16.058,19.752) K72(17.79,19.752) K74(19.522,19.752) K76(21.255,19.752) K78(22.987,19.752) K80(24.719,19.752) K82(26.451,19.752) KA1(-27.317,-12.211) KA6(-25.585,-12.211) KA10(-23.853,-12.211) KA14(-22.121,-12.211) KA18(-20.388,-12.211) KA22(-18.656,-12.211) KB72(17.79,-12.251) KB74(19.522,-12.251) KB76(21.255,-12.251) KB78(22.987,-12.251) KB80(24.719,-12.251) KB82(26.451,-12.251) KC27(-16.046,-12.421) KC29(-14.452,-12.421) KC31(-12.859,-12.421) KC33(-11.265,-12.421) KC35(-9.672,-12.421) KC37(-8.078,-12.421) KC39(-6.484,-12.421) KC41(-4.891,-12.421) KC43(-3.297,-12.421) KC45(-1.704,-12.421) KC47(-0.11,-12.421) KC49(1.484,-12.421) KC51(3.077,-12.421) KC53(4.671,-12.421) KC55(6.264,-12.421) KC57(7.858,-12.421) KC59(9.452,-12.421) KC61(11.045,-12.421) KC63(12.639,-12.421) KC65(14.232,-12.421) KC68(15.826,-12.421) KD3(-26.451,-12.711) KD8(-24.719,-12.711) KD12(-22.987,-12.711) KD16(-21.254,-12.711) KD20(-19.522,-12.711) KD24(-17.79,-12.711) KE73(18.656,-12.751) KE75(20.389,-12.751) KE77(22.121,-12.751) KE79(23.853,-12.751) KE81(25.585,-12.751) KE83(27.318,-12.751) KF26(-16.843,-12.881) KF28(-15.249,-12.881) KF30(-13.655,-12.881) KF32(-12.062,-12.881) KF34(-10.468,-12.881) KF36(-8.874,-12.881) KF38(-7.281,-12.881) KF40(-5.687,-12.881) KF42(-4.093,-12.881) KF44(-2.5,-12.881) KF46(-0.906,-12.881) KF48(0.688,-12.881) KF50(2.282,-12.881) KF52(3.875,-12.881) KF54(5.469,-12.881) KF56(7.063,-12.881) KF58(8.656,-12.881) KF60(10.25,-12.881) KF62(11.844,-12.881) KF64(13.437,-12.881) KF66(15.031,-12.881) KF70(16.623,-12.881) KG1(-27.317,-13.211) KG6(-25.585,-13.211) KG10(-23.853,-13.211) KG14(-22.121,-13.211) KG18(-20.388,-13.211) KG22(-18.656,-13.211) KH72(17.79,-13.251) KH74(19.522,-13.251) KH76(21.255,-13.251) KH78(22.987,-13.251) KH80(24.719,-13.251) KH82(26.451,-13.251) KJ27(-16.046,-13.341) KJ29(-14.452,-13.341) KJ31(-12.859,-13.341) KJ33(-11.265,-13.341) KJ35(-9.672,-13.341) KJ37(-8.078,-13.341) KJ39(-6.484,-13.341) KJ41(-4.891,-13.341) KJ43(-3.297,-13.341) KJ45(-1.704,-13.341) KJ47(-0.11,-13.341) KJ49(1.484,-13.341) KJ51(3.077,-13.341) KJ53(4.671,-13.341) KJ55(6.264,-13.341) KJ57(7.858,-13.341) KJ59(9.452,-13.341) KJ61(11.045,-13.341) KJ63(12.639,-13.341) KJ65(14.232,-13.341) KJ68(15.826,-13.341) KK3(-26.451,-13.711) KK8(-24.719,-13.711) KK12(-22.987,-13.711) KK16(-21.254,-13.711) KK20(-19.522,-13.711) KK24(-17.79,-13.711) KL73(18.656,-13.751) KL75(20.388,-13.751) KL77(22.121,-13.751) KL79(23.853,-13.751) KL81(25.585,-13.751) KL83(27.317,-13.751) KM26(-16.843,-13.801) KM28(-15.249,-13.801) KM30(-13.655,-13.801) KM32(-12.062,-13.801) KM34(-10.468,-13.801) KM36(-8.874,-13.801) KM38(-7.281,-13.801) KM40(-5.687,-13.801) KM42(-4.093,-13.801) KM44(-2.5,-13.801) KM46(-0.906,-13.801) KM48(0.688,-13.801) KM50(2.282,-13.801) KM52(3.875,-13.801) KM54(5.469,-13.801) KM56(7.063,-13.801) KM58(8.656,-13.801) KM60(10.25,-13.801) KM62(11.844,-13.801) KM64(13.437,-13.801) KM66(15.031,-13.801) KM70(16.623,-13.801) KN1(-27.317,-14.211) KN6(-25.585,-14.211) KN10(-23.853,-14.211) KN14(-22.121,-14.211) KN18(-20.388,-14.211) KN22(-18.656,-14.211) KP72(17.79,-14.251) KP74(19.522,-14.251) KP76(21.255,-14.251) KP78(22.987,-14.251) KP80(24.719,-14.251) KP82(26.451,-14.251) KR27(-16.046,-14.261) KR29(-14.452,-14.261) KR31(-12.859,-14.261) KR33(-11.265,-14.261) KR35(-9.671,-14.261) KR37(-8.078,-14.261) KR39(-6.484,-14.261) KR41(-4.89,-14.261) KR43(-3.296,-14.261) KR45(-1.703,-14.261) KR47(-0.109,-14.261) KR49(1.485,-14.261) KR51(3.078,-14.261) KR53(4.672,-14.261) KR55(6.266,-14.261) KR57(7.859,-14.261) KR59(9.453,-14.261) KR61(11.047,-14.261) KR63(12.64,-14.261) KR65(14.234,-14.261) KR68(15.826,-14.261) KT3(-26.451,-14.711) KT8(-24.719,-14.711) KT12(-22.987,-14.711) KT16(-21.254,-14.711) KT20(-19.522,-14.711) KT24(-17.79,-14.711) KU26(-16.843,-14.721) KU28(-15.249,-14.721) KU30(-13.655,-14.721) KU32(-12.062,-14.721) KU34(-10.468,-14.721) KU36(-8.874,-14.721) KU38(-7.281,-14.721) KU40(-5.687,-14.721) KU42(-4.093,-14.721) KU44(-2.5,-14.721) KU46(-0.906,-14.721) KU48(0.688,-14.721) KU50(2.282,-14.721) KU52(3.875,-14.721) KU54(5.469,-14.721) KU56(7.063,-14.721) KU58(8.656,-14.721) KU60(10.25,-14.721) KU62(11.844,-14.721) KU64(13.437,-14.721) KU66(15.031,-14.721) KU70(16.623,-14.721) KV73(18.656,-14.751) KV75(20.388,-14.751) KV77(22.121,-14.751) KV79(23.853,-14.751) KV81(25.585,-14.751) KV83(27.317,-14.751) KW27(-16.046,-15.181) KW29(-14.452,-15.181) KW31(-12.859,-15.181) KW33(-11.265,-15.181) KW35(-9.672,-15.181) KW37(-8.078,-15.181) KW39(-6.484,-15.181) KW41(-4.891,-15.181) KW43(-3.297,-15.181) KW45(-1.704,-15.181) KW47(-0.11,-15.181) KW49(1.484,-15.181) KW51(3.077,-15.181) KW53(4.671,-15.181) KW55(6.264,-15.181) KW57(7.858,-15.181) KW59(9.452,-15.181) KW61(11.045,-15.181) KW63(12.639,-15.181) KW65(14.232,-15.181) KW68(15.826,-15.181) KY1(-27.317,-15.211) KY6(-25.585,-15.211) KY10(-23.853,-15.211) KY14(-22.121,-15.211) KY18(-20.388,-15.211) KY22(-18.656,-15.211) L4(-26.404,19.322) L7(-24.811,19.322) L11(-23.217,19.322) L15(-21.623,19.322) L19(-20.03,19.322) L23(-18.436,19.322) L26(-16.842,19.322) L28(-15.249,19.322) L30(-13.655,19.322) L32(-12.061,19.322) L34(-10.467,19.322) L36(-8.874,19.322) L38(-7.28,19.322) L40(-5.686,19.322) L42(-4.093,19.322) L44(-2.499,19.322) L46(-0.905,19.322) L48(0.688,19.322) L50(2.282,19.322) L52(3.876,19.322) L54(5.47,19.322) L56(7.063,19.322) L58(8.657,19.322) L60(10.251,19.322) L62(11.844,19.322) L64(13.438,19.322) LA72(17.79,-15.251) LA74(19.522,-15.251) LA76(21.255,-15.251) LA78(22.987,-15.251) LA80(24.719,-15.251) LA82(26.451,-15.251) LB26(-16.843,-15.641) LB28(-15.249,-15.641) LB30(-13.656,-15.641) LB32(-12.062,-15.641) LB34(-10.469,-15.641) LB36(-8.875,-15.641) LB38(-7.281,-15.641) LB40(-5.688,-15.641) LB42(-4.094,-15.641) LB44(-2.501,-15.641) LB46(-0.907,-15.641) LB48(0.687,-15.641) LB50(2.28,-15.641) LB52(3.874,-15.641) LB54(5.468,-15.641) LB56(7.061,-15.641) LB58(8.655,-15.641) LB60(10.248,-15.641) LB62(11.842,-15.641) LB64(13.436,-15.641) LB66(15.029,-15.641) LB70(16.623,-15.641) LC3(-26.451,-15.711) LC8(-24.719,-15.711) LC12(-22.987,-15.711) LC16(-21.254,-15.711) LC20(-19.522,-15.711) LC24(-17.79,-15.711) LD73(18.656,-15.751) LD75(20.388,-15.751) LD77(22.121,-15.751) LD79(23.853,-15.751) LD81(25.585,-15.751) LD83(27.317,-15.751) LE27(-16.046,-16.101) LE29(-14.452,-16.101) LE31(-12.859,-16.101) LE33(-11.265,-16.101) LE35(-9.672,-16.101) LE37(-8.078,-16.101) LE39(-6.484,-16.101) LE41(-4.891,-16.101) LE43(-3.297,-16.101) LE45(-1.704,-16.101) LE47(-0.11,-16.101) LE49(1.484,-16.101) LE51(3.077,-16.101) LE53(4.671,-16.101) LE55(6.264,-16.101) LE57(7.858,-16.101) LE59(9.452,-16.101) LE61(11.045,-16.101) LE63(12.639,-16.101) LE65(14.232,-16.101) LE68(15.826,-16.101) LF1(-27.317,-16.211) LF6(-25.585,-16.211) LF10(-23.853,-16.211) LF14(-22.121,-16.211) LF18(-20.388,-16.211) LF22(-18.656,-16.211) LG72(17.79,-16.251) LG74(19.522,-16.251) LG76(21.255,-16.251) LG78(22.987,-16.251) LG80(24.719,-16.251) LG82(26.451,-16.251) LH26(-16.843,-16.561) LH28(-15.249,-16.561) LH30(-13.655,-16.561) LH32(-12.062,-16.561) LH34(-10.468,-16.561) LH36(-8.874,-16.561) LH38(-7.281,-16.561) LH40(-5.687,-16.561) LH42(-4.093,-16.561) LH44(-2.5,-16.561) LH46(-0.906,-16.561) LH48(0.688,-16.561) LH50(2.282,-16.561) LH52(3.875,-16.561) LH54(5.469,-16.561) LH56(7.063,-16.561) LH58(8.656,-16.561) LH60(10.25,-16.561) LH62(11.844,-16.561) LH64(13.437,-16.561) LH66(15.031,-16.561) LJ3(-26.451,-16.631) LJ16(-21.254,-16.631) LJ20(-19.522,-16.631) LJ24(-17.79,-16.631) LK71(16.924,-16.751) LK73(18.656,-16.751) LK75(20.388,-16.751) LK77(22.121,-16.751) LK79(23.853,-16.751) LK81(25.585,-16.751) LK83(27.317,-16.751) LL27(-16.046,-17.021) LL29(-14.452,-17.021) LL31(-12.859,-17.021) LL33(-11.265,-17.021) LL35(-9.672,-17.021) LL37(-8.078,-17.021) LL39(-6.484,-17.021) LL41(-4.891,-17.021) LL43(-3.297,-17.021) LL45(-1.704,-17.021) LL47(-0.11,-17.021) LL49(1.484,-17.021) LL51(3.077,-17.021) LL53(4.671,-17.021) LL55(6.264,-17.021) LL57(7.858,-17.021) LL59(9.452,-17.021) LL61(11.045,-17.021) LL63(12.639,-17.021) LL65(14.232,-17.021) LM69(16.058,-17.251) LM72(17.79,-17.251) LM74(19.522,-17.251) LM76(21.255,-17.251) LM78(22.987,-17.251) LM80(24.719,-17.251) LM82(26.451,-17.251) LN7(-24.811,-17.481) LN11(-23.217,-17.481) LN15(-21.624,-17.481) LN19(-20.03,-17.481) LN23(-18.436,-17.481) LN26(-16.843,-17.481) LN28(-15.249,-17.481) LN30(-13.656,-17.481) LN32(-12.062,-17.481) LN34(-10.469,-17.481) LN36(-8.875,-17.481) LN38(-7.281,-17.481) LN40(-5.688,-17.481) LN42(-4.094,-17.481) LN44(-2.501,-17.481) LN46(-0.907,-17.481) LN48(0.687,-17.481) LN50(2.28,-17.481) LN52(3.874,-17.481) LN54(5.468,-17.481) LN56(7.061,-17.481) LN58(8.655,-17.481) LN60(10.248,-17.481) LN62(11.842,-17.481) LN64(13.436,-17.481) LP67(15.192,-17.751) LP71(16.924,-17.751) LP73(18.656,-17.751) LP75(20.388,-17.751) LP77(22.121,-17.751) LP79(23.853,-17.751) LP81(25.585,-17.751) LP83(27.317,-17.751) LR2(-27.201,-17.941) LR5(-25.608,-17.941) LR9(-24.014,-17.941) LR13(-22.421,-17.941) LR17(-20.827,-17.941) LR21(-19.234,-17.941) LR25(-17.64,-17.941) LR27(-16.047,-17.941) LR29(-14.453,-17.941) LR31(-12.86,-17.941) LR33(-11.266,-17.941) LR35(-9.673,-17.941) LR37(-8.079,-17.941) LR39(-6.486,-17.941) LR41(-4.892,-17.941) LR43(-3.299,-17.941) LR45(-1.705,-17.941) LR47(-0.112,-17.941) LR49(1.482,-17.941) LR51(3.075,-17.941) LR53(4.669,-17.941) LR55(6.262,-17.941) LR57(7.856,-17.941) LR59(9.449,-17.941) LR61(11.043,-17.941) LR63(12.636,-17.941) LR65(14.23,-17.941) LT69(16.058,-18.251) LT72(17.79,-18.252) LT74(19.522,-18.252) LT76(21.255,-18.252) LT78(22.987,-18.252) LT80(24.719,-18.252) LT82(26.451,-18.252) LU4(-26.404,-18.402) LU7(-24.811,-18.402) LU11(-23.217,-18.402) LU15(-21.624,-18.402) LU19(-20.03,-18.402) LU23(-18.436,-18.402) LU26(-16.843,-18.402) LU28(-15.249,-18.402) LU30(-13.656,-18.402) LU32(-12.062,-18.402) LU34(-10.469,-18.402) LU36(-8.875,-18.402) LU38(-7.281,-18.402) LU40(-5.688,-18.402) LU42(-4.094,-18.402) LU44(-2.501,-18.402) LU46(-0.907,-18.402) LU48(0.687,-18.402) LU50(2.28,-18.402) LU52(3.874,-18.402) LU54(5.468,-18.402) LU56(7.061,-18.402) LU58(8.655,-18.402) LU60(10.248,-18.402) LU62(11.842,-18.402) LU64(13.436,-18.402) LV67(15.192,-18.751) LV71(16.924,-18.751) LV73(18.656,-18.751) LV75(20.388,-18.751) LV77(22.121,-18.751) LV79(23.853,-18.751) LV81(25.585,-18.751) LV83(27.317,-18.751) LW2(-27.201,-18.862) LW5(-25.608,-18.862) LW9(-24.014,-18.862) LW13(-22.421,-18.862) LW17(-20.827,-18.862) LW21(-19.234,-18.862) LW25(-17.64,-18.862) LW27(-16.047,-18.862) LW29(-14.453,-18.862) LW31(-12.86,-18.862) LW33(-11.266,-18.862) LW35(-9.673,-18.862) LW37(-8.079,-18.862) LW39(-6.486,-18.862) LW41(-4.892,-18.862) LW43(-3.299,-18.862) LW45(-1.705,-18.862) LW47(-0.112,-18.862) LW49(1.482,-18.862) LW51(3.075,-18.862) LW53(4.669,-18.862) LW55(6.262,-18.862) LW57(7.856,-18.862) LW59(9.449,-18.862) LW61(11.043,-18.862) LW63(12.636,-18.862) LW65(14.23,-18.862) LY69(16.058,-19.251) LY72(17.79,-19.251) LY74(19.522,-19.251) LY76(21.255,-19.251) LY78(22.987,-19.251) LY80(24.719,-19.251) LY82(26.451,-19.251) M67(15.192,19.251) M71(16.924,19.251) M73(18.656,19.251) M75(20.388,19.251) M77(22.121,19.251) M79(23.853,19.251) M81(25.585,19.251) M83(27.317,19.251) MA4(-26.404,-19.322) MA7(-24.811,-19.322) MA11(-23.217,-19.322) MA15(-21.624,-19.322) MA19(-20.03,-19.322) MA23(-18.436,-19.322) MA26(-16.843,-19.322) MA28(-15.249,-19.322) MA30(-13.656,-19.322) MA32(-12.062,-19.322) MA34(-10.469,-19.322) MA36(-8.875,-19.322) MA38(-7.281,-19.322) MA40(-5.688,-19.322) MA42(-4.094,-19.322) MA44(-2.501,-19.322) MA46(-0.907,-19.322) MA48(0.687,-19.322) MA50(2.28,-19.322) MA52(3.874,-19.322) MA54(5.468,-19.322) MA56(7.061,-19.322) MA58(8.655,-19.322) MA60(10.248,-19.322) MA62(11.842,-19.322) MA64(13.436,-19.322) MB67(15.192,-19.752) MB71(16.924,-19.752) MB73(18.656,-19.752) MB75(20.389,-19.752) MB77(22.121,-19.752) MB79(23.853,-19.752) MB81(25.585,-19.752) MC5(-25.608,-19.782) MC9(-24.014,-19.782) MC13(-22.421,-19.782) MC17(-20.827,-19.782) MC21(-19.234,-19.782) MC25(-17.64,-19.782) MC27(-16.047,-19.782) MC29(-14.453,-19.782) MC31(-12.86,-19.782) MC33(-11.266,-19.782) MC35(-9.673,-19.782) MC37(-8.079,-19.782) MC39(-6.486,-19.782) MC41(-4.892,-19.782) MC43(-3.299,-19.782) MC45(-1.705,-19.782) MC47(-0.112,-19.782) MC49(1.482,-19.782) MC51(3.075,-19.782) MC53(4.669,-19.782) MC55(6.262,-19.782) MC57(7.856,-19.782) MC59(9.449,-19.782) MC61(11.043,-19.782) MC63(12.636,-19.782) MC65(14.23,-19.782) MD7(-24.811,-20.242) MD11(-23.217,-20.242) MD15(-21.624,-20.242) MD19(-20.03,-20.242) MD23(-18.436,-20.242) MD26(-16.843,-20.242) MD28(-15.249,-20.242) MD30(-13.656,-20.242) MD32(-12.062,-20.242) MD34(-10.469,-20.242) MD36(-8.875,-20.242) MD38(-7.281,-20.242) MD40(-5.688,-20.242) MD42(-4.094,-20.242) MD44(-2.501,-20.242) MD46(-0.907,-20.242) MD48(0.687,-20.242) MD50(2.28,-20.242) MD52(3.874,-20.242) MD54(5.468,-20.242) MD56(7.061,-20.242) MD58(8.655,-20.242) MD60(10.248,-20.242) MD62(11.842,-20.242) MD64(13.436,-20.242) ME69(16.058,-20.252) ME72(17.79,-20.252) ME74(19.522,-20.252) ME76(21.255,-20.252) ME78(22.987,-20.252) ME80(24.719,-20.252) MF9(-24.014,-20.702) MF13(-22.421,-20.702) MF17(-20.827,-20.702) MF21(-19.234,-20.702) MF25(-17.64,-20.702) MF27(-16.047,-20.702) MF29(-14.453,-20.702) MF31(-12.86,-20.702) MF33(-11.266,-20.702) MF35(-9.673,-20.702) MF37(-8.079,-20.702) MF39(-6.486,-20.702) MF41(-4.892,-20.702) MF43(-3.299,-20.702) MF45(-1.705,-20.702) MF47(-0.112,-20.702) MF49(1.482,-20.702) MF51(3.075,-20.702) MF53(4.669,-20.702) MF55(6.262,-20.702) MF57(7.856,-20.702) MF59(9.449,-20.702) MF61(11.043,-20.702) MF63(12.636,-20.702) MF65(14.23,-20.702) MG67(15.192,-20.752) MG71(16.924,-20.752) MG73(18.656,-20.752) MG75(20.388,-20.752) MG77(22.121,-20.752) MG79(23.853,-20.752) MH11(-23.217,-21.162) MH15(-21.624,-21.162) MH19(-20.03,-21.162) MH23(-18.436,-21.162) MH26(-16.843,-21.162) MH28(-15.249,-21.162) MH30(-13.656,-21.162) MH32(-12.062,-21.162) MH34(-10.469,-21.162) MH36(-8.875,-21.162) MH38(-7.281,-21.162) MH40(-5.688,-21.162) MH42(-4.094,-21.162) MH44(-2.501,-21.162) MH46(-0.907,-21.162) MH48(0.687,-21.162) MH50(2.28,-21.162) MH52(3.874,-21.162) MH54(5.468,-21.162) MH56(7.061,-21.162) MH58(8.655,-21.162) MH60(10.248,-21.162) MH62(11.842,-21.162) MH64(13.436,-21.162) MJ69(16.058,-21.252) MJ72(17.79,-21.252) MJ74(19.522,-21.252) MJ76(21.255,-21.252) MJ78(22.987,-21.252) MK13(-22.42,-21.622) MK17(-20.827,-21.622) MK21(-19.233,-21.622) MK25(-17.639,-21.622) MK27(-16.046,-21.622) MK29(-14.452,-21.622) MK31(-12.858,-21.622) MK33(-11.264,-21.622) MK35(-9.671,-21.622) MK37(-8.077,-21.622) MK39(-6.483,-21.622) MK41(-4.89,-21.622) MK43(-3.296,-21.622) MK45(-1.702,-21.622) MK47(-0.109,-21.622) MK49(1.485,-21.622) MK51(3.079,-21.622) MK53(4.673,-21.622) MK55(6.266,-21.622) MK57(7.86,-21.622) MK59(9.454,-21.622) MK61(11.047,-21.622) MK63(12.641,-21.622) MK65(14.235,-21.622) ML67(15.192,-21.752) ML71(16.924,-21.752) ML73(18.656,-21.752) ML75(20.388,-21.752) ML77(22.121,-21.752) N2(-27.201,18.861) N5(-25.608,18.861) N9(-24.014,18.861) N13(-22.42,18.861) N17(-20.827,18.861) N21(-19.233,18.861) N25(-17.639,18.861) N27(-16.045,18.861) N29(-14.452,18.861) N31(-12.858,18.861) N33(-11.264,18.861) N35(-9.671,18.861) N37(-8.077,18.861) N39(-6.483,18.861) N41(-4.889,18.861) N43(-3.296,18.861) N45(-1.702,18.861) N47(-0.108,18.861) N49(1.485,18.861) N51(3.079,18.861) N53(4.673,18.861) N55(6.266,18.861) N57(7.86,18.861) N59(9.454,18.861) N61(11.048,18.861) N63(12.641,18.861) N65(14.235,18.861) P69(16.058,18.751) P72(17.79,18.751) P74(19.522,18.751) P76(21.255,18.751) P78(22.987,18.751) P80(24.719,18.751) P82(26.451,18.751) R4(-26.404,18.402) R7(-24.811,18.402) R11(-23.217,18.402) R15(-21.623,18.402) R19(-20.03,18.402) R23(-18.436,18.402) R26(-16.842,18.402) R28(-15.249,18.402) R30(-13.655,18.402) R32(-12.061,18.402) R34(-10.467,18.402) R36(-8.874,18.402) R38(-7.28,18.402) R40(-5.686,18.402) R42(-4.093,18.402) R44(-2.499,18.402) R46(-0.905,18.402) R48(0.688,18.402) R50(2.282,18.402) R52(3.876,18.402) R54(5.47,18.402) R56(7.063,18.402) R58(8.657,18.402) R60(10.251,18.402) R62(11.844,18.402) R64(13.438,18.402) T67(15.192,18.251) T71(16.924,18.251) T73(18.656,18.251) T75(20.389,18.251) T77(22.121,18.251) T79(23.853,18.251) T81(25.585,18.251) T83(27.317,18.251) U2(-27.201,17.941) U5(-25.608,17.941) U9(-24.014,17.941) U13(-22.42,17.941) U17(-20.827,17.941) U21(-19.233,17.941) U25(-17.639,17.941) U27(-16.045,17.941) U29(-14.452,17.941) U31(-12.858,17.941) U33(-11.264,17.941) U35(-9.671,17.941) U37(-8.077,17.941) U39(-6.483,17.941) U41(-4.889,17.941) U43(-3.296,17.941) U45(-1.702,17.941) U47(-0.108,17.941) U49(1.485,17.941) U51(3.079,17.941) U53(4.673,17.941) U55(6.266,17.941) U57(7.86,17.941) U59(9.454,17.941) U61(11.048,17.941) U63(12.641,17.941) U65(14.235,17.941) V69(16.058,17.751) V72(17.79,17.751) V74(19.522,17.751) V76(21.255,17.751) V78(22.987,17.751) V80(24.719,17.751) V82(26.451,17.751) W4(-26.404,17.481) W7(-24.811,17.481) W11(-23.217,17.481) W26(-16.842,17.481) W28(-15.249,17.481) W30(-13.655,17.481) W32(-12.061,17.481) W34(-10.467,17.481) W36(-8.874,17.481) W38(-7.28,17.481) W40(-5.686,17.481) W42(-4.093,17.481) W44(-2.499,17.481) W46(-0.905,17.481) W48(0.688,17.481) W50(2.282,17.481) W52(3.876,17.481) W54(5.47,17.481) W56(7.063,17.481) W58(8.657,17.481) W60(10.251,17.481) W62(11.844,17.481) W64(13.438,17.481) Y67(15.192,17.251) Y71(16.924,17.251) Y73(18.656,17.251) Y75(20.388,17.251) Y77(22.121,17.251) Y79(23.853,17.251) Y81(25.585,17.251) Y83(27.317,17.251)
  round 0.475 smd: A80(24.719,21.752) B9(-24.014,21.622) C81(25.585,21.252) D7(-24.811,21.162) E82(26.451,20.752) F5(-25.608,20.702) G83(27.317,20.252) H4(-26.404,20.242) J2(-27.201,19.781) MB83(27.317,-19.752) MC2(-27.201,-19.782) MD4(-26.404,-20.242) ME82(26.451,-20.252) MF5(-25.608,-20.702) MG81(25.585,-20.752) MH7(-24.811,-21.162) MJ80(24.719,-21.252) MK9(-24.014,-21.622) ML79(23.853,-21.752)
  round 0.55 smd: A82(26.451,21.752) B5(-25.608,21.622) C83(27.317,21.252) D4(-26.404,21.162) F2(-27.201,20.702) MF2(-27.201,-20.702) MG83(27.317,-20.752) MH4(-26.404,-21.162) MJ82(26.451,-21.252) MK5(-25.608,-21.622) ML81(25.585,-21.752)
