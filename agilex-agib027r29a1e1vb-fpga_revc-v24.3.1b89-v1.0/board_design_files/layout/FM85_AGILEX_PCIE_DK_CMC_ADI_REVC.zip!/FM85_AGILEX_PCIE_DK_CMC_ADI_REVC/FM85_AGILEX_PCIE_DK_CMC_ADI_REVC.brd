# Allegro board FM85_AGILEX_PCIE_DK_CMC_ADI_REVC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FPGA_QSPI_CLK: length 57.9
  L05_SIG2 w0.081: v1(23.49,20.9) 23.87,20.53 24.65,20.53 24.95,20.84 24.95,20.89 25.34,21.27 32.65,21.27 33.12,20.8 33.12,20.75 33.34,20.53 34.59,20.53 35.34,21.27 38.39,21.27 38.87,21.75 38.87,22.6 41.95,25.68 42.01,25.68 42.22,25.88 42.22,28.12 41.92,28.41 41.92,28.74 44.1,30.92 44.1,32.11 44.25,32.26 44.25,32.47 44.52,32.74 44.52,35.74 45.16,36.38 45.16,38.47 44.76,38.87 44.76,42.05 43.3,43.51 43.3,44.46 42.54,45.22 42.54,48.17 41.04,49.68 40.74,49.68 39.73,50.68 39.73,51.69 40.11,52.06 40.11,52.86 40.47,53.22 40.47,53.57 40.25,53.79 39.5,53.79 38.67,52.96 38.67,52.88 38.04,52.25 v1(37.5,52.25)
FPGA_QSPI_CS_N: length 42.3
  TOP w0.149: U34.K6 v1(28.98,24.28)
  L05_SIG2 w0.081: v1(36.2,52.25) 35.43,51.49 35.43,47.5 38.65,44.28 38.65,40.78 40.89,38.55 40.89,33.02 40.05,32.18 40.05,26.94 37.4,24.28 30.9,24.28 30.65,24.53 29.23,24.53 v1(28.98,24.28)
  BOTTOM w0.149: R6107.1 35.9,51.95 v1(36.2,52.25)
FPGA_QSPI_DATA0: length 59.3
  L05_SIG2 w0.081: v1(38.15,52.89) 39.29,54.02 40.35,54.02 40.7,53.67 40.7,52.84 40.34,52.48 40.34,51.96 39.97,51.59 39.97,50.78 40.84,49.91 41.14,49.91 42.78,48.27 42.78,45.42 44.09,44.11 44.09,43.05 44.99,42.15 44.99,39.29 45.39,38.9 45.39,36.25 45,35.86 45,33.23 45.16,33.08 45.16,32.26 44.82,31.93 44.6,31.93 44.37,31.7 44.37,30.51 44.06,30.21 43.13,29.27 43.13,28.83 42.6,28.3 42.6,25.98 42.83,25.76 42.83,25.23 42.56,24.96 42.32,24.96 41.68,24.32 41.4,24.32 41.18,24.11 41.18,21.96 39.57,20.35 33.09,20.35 32.99,20.46 29.58,20.46 28.65,19.53 25.4,19.53 24.65,20.27 23.87,20.27 v1(23.49,19.9)
FPGA_QSPI_DATA1: length 46.1
  L05_SIG2 w0.081: v1(24.49,22.9) 24.87,22.53 35.56,22.53 36.31,23.27 37.39,23.27 40.88,26.76 40.88,27.71 41.03,27.86 41.03,28.84 41.6,29.42 41.6,34.87 42.02,35.29 42.02,36.09 41.62,36.49 41.62,46.19 39.01,48.8 38.72,48.8 38.35,49.17 38.35,51.8 v1(38.8,52.25)
FPGA_QSPI_DATA2: length 49.5
  L05_SIG2 w0.081: v1(24.49,20.9) 25.05,21.46 33.51,21.46 33.85,21.12 34.16,21.12 34.56,21.52 37.64,21.52 38.02,21.9 38.02,22.01 41.98,25.98 41.98,28.02 41.74,28.27 41.74,28.89 42.67,29.83 42.67,33.74 43.5,34.56 43.5,40.56 42.08,41.97 42.08,46.44 39.48,49.05 39.48,51.76 39.71,51.99 39.71,52.62 v1(39.45,52.89)
FPGA_QSPI_DATA3: length 48.8
  L05_SIG2 w0.081: v1(40.1,53.42) 39.46,53.42 39.08,53.04 39.08,52.6 39.17,52.51 39.17,52.08 38.58,51.49 38.58,49.26 38.81,49.03 39.11,49.03 41.85,46.29 41.85,41.87 43.26,40.46 43.26,34.66 42.44,33.84 42.44,29.92 41.21,28.7 41.21,27.77 41.06,27.62 41.06,25.95 37.39,22.27 25.87,22.27 v1(25.5,21.9)
FPGA_SDM_SCL: length 96.5
  L12_SIG4 w0.089: v1(99.29,81.14) 97.81,82.62 88.3,82.62 83.71,87.21 77.88,87.21 74.26,90.83 71.13,90.83 67.14,94.82 67.14,96.51 65.06,98.59 61.16,98.59 59.64,97.07 26.16,97.07 18.76,104.47 18.76,105.62 18.89,105.75 18.89,107.22 v1(18.47,107.64)
  BOTTOM w0.149: U26.7 v1(18.47,107.64)
FPGA_SDM_SDA: length 97.7
  L12_SIG4 w0.089: v1(101.02,81.14) 99.15,83.01 88.41,83.01 83.41,88.01 77.6,88.01 73.98,91.63 71.39,91.63 67.52,95.49 67.52,97.02 65.62,98.92 61,98.92 59.53,97.45 26.25,97.45 19.89,103.81 19.89,107.36 v1(19.55,107.7)
  BOTTOM w0.149: v1(19.55,107.7) 19.36,107.89 19.36,108.16 19.25,108.27 U26.6
FPGA_SEU_ERROR: length 90.9
  L12_SIG4 w0.089: v1(137.25,37.01) 137.5,37.01 137.95,36.56 137.95,35.52 137.97,35.5 137.97,31.35 141,28.32 141,26.52 143.08,24.44 150.88,24.44 150.92,24.4 153.11,24.4 153.19,24.48 159.9,24.48 159.94,24.44 171.34,24.44 173.85,26.95 175.49,26.95 176.61,25.83 176.61,21.96 180.47,18.09 183.89,18.09 184.55,17.43 184.55,17.35 184.79,17.1 186.32,17.1 186.61,17.4 186.61,17.43 187.29,18.11 190.6,18.11 190.77,18.27 192.13,18.27 192.3,18.11 194.17,18.11 194.79,17.49 195.12,17.49 195.41,17.78 197.54,17.78 v1(197.69,17.63)
  BOTTOM w0.149: v1(137.25,37.01) 137.02,37.24 136.83,37.24 136.43,37.64 136.19,37.64 135.64,38.19 135.28,38.19 134.35,37.26 133.76,37.26 133.41,37.61 132.85,37.61 132.19,36.95 132.19,33.62 131.31,32.75 130.7,32.75 130.48,32.97 U105.14
FPGA_SEU_ERROR_B: length 26.4
  L14_SIG5 w0.081: v1(124.29,37.74) 124.29,37.04 123.63,36.38 123.63,29.57 123.47,29.42 123.44,29.42 123.32,29.3 122.88,29.3 122.55,29.63 122.45,29.63 122.42,29.66 v1(122.38,29.66)
  BOTTOM w0.149: v1(122.38,29.66) 122.38,29.69 122.74,30.05 123.27,30.05 123.37,29.95 131.45,29.95 134.47,32.97 U105.7 137.29,32.97 R6216.1
FPGA_TEMP0AN: length 40.6
  L12_SIG4 w0.203: v1(102.77,75.95) 101.82,75.95 101.38,75.51 100.98,75.51 100.38,76.11 99.88,76.11 99.47,75.7 99.06,75.7 98.55,76.21 96.92,76.21 96.42,76.7 95.64,76.7 95.09,77.24 94.42,77.24 93.35,76.17 91.8,76.17 91.28,76.69 90.42,76.69 90,77.12 89.52,77.12 89.01,76.61 88.63,76.61 88.22,76.2 87.85,76.2 87.58,76.47 80.26,76.47 76.42,80.31 75.79,80.31 75.33,80.77 75.33,81.39 74.59,82.13 69.23,82.13 v1(67.98,80.88)
FPGA_TEMP0AP: length 41.5
  L12_SIG4 w0.203: v1(103.57,76.41) 102.59,76.41 102.14,76.86 101.76,76.86 101.43,76.52 100.9,76.52 100.35,77.08 99.97,77.08 99.48,76.59 99.09,76.59 98.6,77.08 98.24,77.08 97.71,76.55 97.05,76.55 96.02,77.57 94.28,77.57 93.78,77.07 93.04,77.07 92.68,76.71 91.78,76.71 90.86,77.63 89.29,77.63 88.79,77.13 87.84,77.13 87.51,76.8 80.4,76.8 76.56,80.64 75.93,80.64 75.66,80.9 75.66,81.53 74.73,82.46 69.1,82.46 68.12,81.49 v1(67.97,81.63)
FPGA_TEMP0CN: length 71.9
  L12_SIG4 w0.203: v1(67.98,78.77) 68.2,78.99 68.74,78.99 69.16,78.57 69.16,75.46 69.66,74.96 69.71,74.96 69.72,74.94 72.69,74.94 73.02,74.61 73.02,74.24 73.54,73.71 75.26,73.71 75.62,73.35 75.62,72.56 79.98,68.2 80.75,68.2 81.38,67.58 81.38,64.57 80.39,63.58 80.39,52.93 80.81,51.92 80.81,51.75 arc(80.89,51.32) 81.14,50.96 82.04,50.06 arc(82.4,49.82) 82.83,49.73 84.03,49.73 84.59,49.17 88.38,49.17 88.73,49.53 89.06,49.53 89.41,49.17 90.11,49.17 90.46,49.53 90.79,49.53 91.15,49.17 93.43,49.17 93.78,49.53 94.29,49.53 94.73,49.97 94.88,50.03 95.37,50.03 95.66,49.74 95.99,49.74 96.36,50.12 97.02,50.12 97.39,49.74 97.72,49.74 98.09,50.12 98.51,50.12 99.02,50.62 arc(99.03,50.63) 99.04,50.63 99.73,50.63 arc(99.75,50.63) 99.76,50.64 100.19,51.07 arc(100.2,51.08) 100.21,51.08 100.55,51.08 arc(100.56,51.08) 100.57,51.07 100.97,50.68 101.36,50.68 101.76,51.08 102.16,51.08 102.56,50.68 102.95,50.68 103.36,51.08 103.75,51.08 104.16,50.67 104.6,50.67 104.76,50.83 104.76,50.9 104.99,51.13 105.32,51.13 105.83,50.62 106.14,50.62 106.54,50.22 106.94,50.22 107.34,50.62 107.73,50.62 108.14,50.22 108.53,50.22 108.94,50.63 109.35,50.63 109.95,50.04 v1(109.95,49.73)
FPGA_TEMP0CP: length 72.2
  L12_SIG4 w0.203: v1(67.98,79.61) 68.26,79.32 68.87,79.32 69.49,78.71 69.49,75.64 69.86,75.27 72.83,75.27 73.35,74.75 73.35,74.37 73.68,74.04 75.39,74.04 75.95,73.48 75.95,72.7 80.12,68.53 80.89,68.53 81.71,67.71 81.71,64.43 80.72,63.44 80.72,52.99 81.14,51.99 81.14,51.75 arc(81.2,51.45) 81.37,51.19 82.27,50.29 arc(82.53,50.12) 82.83,50.06 84.17,50.06 84.72,49.5 87.21,49.5 87.95,50.24 90.18,50.24 90.46,50.53 90.79,50.53 91.67,49.65 92.51,49.65 93.11,50.24 93.39,50.24 93.89,50.74 94.25,50.74 94.6,51.09 95.18,51.09 95.52,50.74 95.99,50.74 96.31,51.07 96.95,51.07 97.31,50.71 97.73,50.71 98.23,51.21 98.6,51.21 99.39,52 100.56,52 100.97,51.6 101.36,51.6 101.76,52 102.16,52 102.56,51.6 102.95,51.6 103.36,52 103.75,52 104.15,51.6 104.56,51.6 104.96,52 105.34,52 105.8,51.54 106.14,51.54 106.54,51.14 106.94,51.14 107.34,51.54 107.73,51.54 108.14,51.14 108.53,51.14 108.93,51.54 109.35,51.54 109.95,50.95 v1(109.95,50.65)
FPGA_TEMP1N: length 40.1
  L12_SIG4 w0.203: v1(73.58,77) 74.1,76.48 74.14,76.48 74.61,76.02 74.61,75.51 74.92,75.2 75.99,75.2 77.26,73.92 77.26,72.75 79.78,70.24 80.43,70.24 81.02,69.65 82.1,69.65 82.38,69.37 82.38,68.81 82.93,68.27 83.85,68.27 84.06,68.05 88.33,68.05 88.73,67.65 90.9,67.65 91.35,68.1 93.41,68.1 93.77,67.74 94.16,67.74 94.34,67.81 94.77,68.25 95.16,68.25 95.75,67.65 95.93,67.65 96.4,67.19 96.89,67.19 97.33,67.62 97.75,67.62 98.25,68.12 99.76,68.12 100.21,67.67 100.56,67.67 101.01,68.13 101.36,68.13 101.81,67.68 102.49,67.68 103.23,66.93 arc(103.26,66.9) 103.3,66.88 arc(103.41,66.81) 103.53,66.78 arc(103.82,66.81) 104.06,66.99 arc(104.39,67.14) 104.71,66.95 arc(104.85,66.8) 105.05,66.75 v1(105.96,66.75)
FPGA_TEMP1P: length 42.7
  L12_SIG4 w0.203: v1(72.69,77) 73.55,76.14 74.02,76.14 74.28,75.88 74.28,75.37 74.78,74.87 75.85,74.87 76.93,73.79 76.93,72.62 79.64,69.91 80.29,69.91 80.88,69.32 80.88,69.32 82.3,67.9 82.3,67.5 82.56,67.24 86.03,67.24 86.39,67.6 87.39,67.6 87.83,67.17 89.98,67.17 90.4,66.74 90.79,66.74 91.2,67.15 91.76,67.15 92.14,67.53 92.64,67.53 93.1,67.07 93.35,67.07 93.89,66.53 94.27,66.53 94.77,67.03 95.23,67.03 95.61,66.65 95.95,66.65 96.47,66.13 96.85,66.13 97.37,66.65 97.8,66.65 98.34,67.2 99.77,67.2 100.21,66.77 100.58,66.77 101.04,67.23 102.47,67.23 103,66.7 arc(103.01,66.69) 103.02,66.68 103.17,66.52 103.17,66.52 103.32,66.37 arc(103.41,66.31) 103.51,66.29 104.44,66.29 arc(104.54,66.27) 104.63,66.22 104.99,65.86 105.35,65.86 105.81,66.32 106.73,66.32 v1(106.76,66.29)
FPGA_TEMP3N: length 96.8
  L07_SIG3 w0.203: v1(146.9,78.26) 147.28,77.87 155.71,77.87 160.07,82.23 160.07,88.5 162.03,90.46 163.05,90.46 v1(163.4,90.81)
  L16_SIG6 w0.203: v1(146.9,78.26) 146.86,78.26 146.65,78.05 146.65,77.5 145.57,76.41 142.5,76.41 142.11,76.02 140.73,76.02 140.5,75.79 140.5,75.42 140.1,75.03 139.68,75.03 139.46,74.8 139.46,74.4 139.59,74.26 139.59,73.94 139.36,73.71 139,73.71 138.5,73.21 138.17,73.21 137.84,73.53 137.29,73.53 136.75,72.99 136.44,72.99 136.11,72.66 135.51,72.66 134.88,72.03 134.69,72.03 134.15,71.49 133.84,71.49 133.25,70.91 arc(133.24,70.9) 133.23,70.9 132.85,70.9 arc(132.83,70.9) 132.82,70.89 132.41,70.48 arc(132.4,70.47) 132.39,70.47 132.15,70.47 arc(132.05,70.45) 131.97,70.4 131.91,70.33 arc(131.87,70.29) 131.83,70.23 arc(131.75,70.13) 131.64,70.05 arc(131.61,70.03) 131.58,70.01 131.58,70 131.55,70 131.31,70 arc(131.3,69.99) 131.29,69.99 130.8,69.49 arc(130.79,69.49) 130.77,69.48 130.4,69.48 130.03,69.12 129.7,69.12 129.34,69.48 128.81,69.48 128.44,69.12 128.11,69.12 127.74,69.48 127.21,69.48 126.84,69.12 126.52,69.12 126.15,69.48 125.73,69.48 125.31,69.91 124.45,69.91 123.66,69.12 123.33,69.12 122.96,69.48 122.52,69.48 122.15,69.12 121.74,69.12 121.31,69.54 120.98,69.54 120.45,69.01 arc(120.44,69) 120.43,69 120.14,69 arc(120.13,68.99) 120.12,68.99 119.72,68.58 arc(119.71,68.58) 119.69,68.57 119.36,68.57 arc(119.35,68.57) 119.34,68.57 118.93,68.16 118.91,68.15 118.74,68.15 arc(118.72,68.15) 118.69,68.15 arc(118.65,68.14) 118.6,68.15 arc(118.58,68.15) 118.55,68.15 118.52,68.15 118.49,68.16 118.48,68.17 arc(118.46,68.19) 118.44,68.2 arc(118.37,68.25) 118.32,68.32 arc(118.29,68.35) 118.27,68.38 118.16,68.49 arc(118.16,68.5) 118.15,68.5 118.06,68.53 arc(117.88,68.57) 117.7,68.52 117.68,68.5 117.28,68.1 116.94,68.1 116.48,67.65 116.14,67.65 115.73,67.24 115.31,67.24 114.89,66.81 114.61,66.81 114.11,66.32 113.81,66.32 113.25,65.76 112.97,65.76 112.56,65.35 112.14,65.35 111.72,64.94 111.42,64.94 arc(111.41,64.93) 111.4,64.93 110.93,64.46 arc(110.92,64.45) 110.91,64.45 110.55,64.45 arc(110.53,64.45) 110.52,64.44 110.15,64.06 arc(110.14,64.06) 110.13,64.05 109.83,64.05 109.33,63.56 109.03,63.56 108.47,63 108.19,63 107.86,62.67 107.44,62.67 106.94,62.18 106.6,62.18 106.14,61.72 105.89,61.72 105.45,61.27 104.97,61.27 104.53,60.83 104.25,60.83 103.75,60.34 103.5,60.34 102.95,59.78 102.61,59.78 102.37,59.54 102.37,56.92 102.14,56.69 101.83,56.69 101.24,56.1 101.02,56.1 100.79,55.87 100.79,55.46 100.82,55.43 100.82,55.01 arc(100.81,54.95) 100.8,54.89 arc(100.79,54.8) 100.8,54.71 arc(100.81,54.61) 100.82,54.5 100.82,54.26 arc(100.8,54.16) 100.74,54.07 100.44,53.77 100.44,52.13 100.82,51.75 100.82,51.52 arc(100.8,51.42) 100.76,51.33 arc(100.74,51.28) 100.74,51.23 100.74,51.02 arc(100.75,50.92) 100.78,50.82 arc(100.81,50.68) 100.8,50.54 arc(100.8,50.54) 100.8,50.54 100.8,50.1 100.88,50.02 100.88,49.55 100.79,49.46 100.79,49.1 101.18,48.71 v1(101.18,48.35)
  BOTTOM w0.254: R471.2 164.94,90.88 164.62,90.57 163.64,90.57 v1(163.4,90.81)
FPGA_TEMP3P: length 98.2
  L07_SIG3 w0.203: v1(163.18,89.79) 163.18,89.93 162.98,90.13 162.17,90.13 160.4,88.37 160.4,82.09 155.85,77.54 146.8,77.54 146.12,78.21 v1(146.12,78.26)
  L16_SIG6 w0.203: v1(100.38,47.89) 100.38,48.17 arc(100.37,48.24) 100.32,48.31 100.08,48.55 arc(99.98,48.8) 100.07,49.05 arc(100.12,49.14) 100.14,49.24 arc(100.13,49.34) 100.07,49.43 arc(99.96,49.66) 99.99,49.91 arc(100.05,50.17) 99.99,50.42 99.97,50.46 arc(99.93,50.65) 99.98,50.84 100,50.89 arc(100.04,51.04) 100.02,51.2 arc(99.97,51.37) 99.95,51.55 arc(99.95,51.55) 99.95,51.56 arc(99.97,51.68) 100.02,51.79 arc(100.02,51.8) 100.02,51.8 arc(100.08,51.96) 100.11,52.13 100.11,53.89 arc(100.09,53.99) 100.03,54.07 arc(99.92,54.31) 100.01,54.56 arc(100.09,54.77) 100.02,54.99 arc(99.97,55.09) 99.95,55.2 99.95,55.35 arc(99.96,55.45) 99.99,55.55 arc(100.02,55.69) 100.01,55.82 arc(100,55.86) 99.99,55.91 arc(99.98,55.99) 99.97,56.06 arc(99.99,56.34) 100.18,56.55 arc(100.24,56.59) 100.3,56.63 arc(100.36,56.68) 100.44,56.69 arc(100.54,56.71) 100.63,56.77 100.93,57.08 arc(101.02,57.13) 101.12,57.15 101.26,57.15 arc(101.34,57.17) 101.4,57.21 101.52,57.33 arc(101.56,57.39) 101.58,57.47 101.58,59.89 arc(101.68,60.14) 101.92,60.24 arc(102.14,60.28) 102.31,60.4 102.67,60.76 arc(102.75,60.81) 102.85,60.83 arc(103.02,60.87) 103.15,60.96 103.37,61.18 arc(103.46,61.24) 103.56,61.26 103.76,61.26 arc(103.83,61.27) 103.9,61.32 104.23,61.64 arc(104.31,61.7) 104.41,61.72 arc(104.54,61.74) 104.65,61.82 104.97,62.14 arc(105.05,62.19) 105.15,62.21 105.33,62.21 arc(105.41,62.23) 105.48,62.27 105.76,62.56 arc(105.85,62.62) 105.95,62.64 106.06,62.64 arc(106.14,62.65) 106.2,62.7 106.53,63.02 arc(106.61,63.08) 106.71,63.1 106.86,63.1 arc(106.93,63.11) 107,63.16 107.29,63.45 arc(107.38,63.51) 107.48,63.53 107.65,63.53 arc(107.72,63.54) 107.79,63.59 108.08,63.88 arc(108.17,63.94) 108.28,63.96 arc(108.45,63.99) 108.59,64.09 108.94,64.44 arc(109.03,64.5) 109.12,64.51 109.23,64.51 arc(109.31,64.53) 109.37,64.57 109.65,64.85 arc(109.73,64.9) 109.83,64.92 110.09,64.92 arc(110.16,64.94) 110.23,64.98 110.54,65.3 arc(110.63,65.36) 110.73,65.37 110.85,65.37 arc(110.93,65.39) 111,65.43 111.29,65.72 arc(111.37,65.78) 111.47,65.8 111.67,65.8 arc(111.75,65.82) 111.81,65.86 112.19,66.24 arc(112.28,66.3) 112.38,66.32 arc(112.51,66.34) 112.61,66.42 112.9,66.7 arc(112.98,66.76) 113.08,66.78 113.23,66.78 arc(113.31,66.79) 113.37,66.84 113.7,67.16 arc(113.78,67.22) 113.88,67.24 114.07,67.24 arc(114.15,67.25) 114.22,67.3 114.45,67.53 arc(114.54,67.59) 114.64,67.61 114.77,67.61 arc(114.85,67.62) 114.91,67.67 115.27,68.02 arc(115.35,68.08) 115.45,68.1 115.67,68.1 arc(115.68,68.1) 115.69,68.11 116.14,68.56 arc(116.15,68.57) 116.17,68.57 116.49,68.57 arc(116.5,68.57) 116.51,68.58 117.04,69.11 arc(117.05,69.11) 117.06,69.12 117.37,69.12 117.74,69.48 118.18,69.48 118.55,69.12 118.96,69.12 119.33,69.48 119.72,69.48 120.14,69.9 120.43,69.9 120.92,70.4 121.37,70.4 121.74,70.04 122.01,70.04 arc(122.02,70.04) 122.03,70.04 122.42,70.43 arc(122.43,70.44) 122.44,70.44 122.95,70.44 arc(122.96,70.44) 122.97,70.43 123.37,70.04 arc(123.49,69.99) 123.61,70.04 123.95,70.37 arc(124.03,70.43) 124.13,70.45 125.91,70.45 arc(126.07,70.42) 126.2,70.33 126.28,70.25 arc(126.31,70.22) 126.33,70.19 arc(126.41,70.1) 126.51,70.04 arc(126.53,70.03) 126.55,70.03 arc(126.65,70.01) 126.75,70.01 arc(126.78,70.01) 126.81,70.02 126.85,70.02 126.87,70.02 126.91,70.06 arc(126.93,70.08) 126.94,70.1 arc(126.98,70.13) 127.01,70.17 arc(127.03,70.18) 127.04,70.2 127.25,70.41 arc(127.26,70.42) 127.28,70.42 127.68,70.42 arc(127.69,70.42) 127.7,70.41 128.1,70.01 arc(128.11,70) 128.13,70 128.45,70 128.86,70.4 129.29,70.4 129.69,70 130.05,70 130.47,70.42 arc(130.48,70.43) 130.49,70.43 130.81,70.43 arc(130.82,70.43) 130.83,70.44 131.27,70.88 arc(131.28,70.89) 131.29,70.89 131.69,70.89 arc(131.7,70.89) 131.71,70.9 132.09,71.28 132.38,71.28 132.93,71.84 133.23,71.84 133.61,72.21 133.61,72.26 134.05,72.71 134.38,72.71 134.73,73.05 135.13,73.05 135.75,73.67 135.91,73.67 136.45,74.21 136.76,74.21 137.23,74.67 137.65,74.67 138.2,74.11 138.57,74.11 138.94,74.48 138.94,74.8 138.8,74.94 138.8,75.26 139.04,75.49 139.35,75.49 139.89,76.03 140.27,76.03 140.59,76.35 141.97,76.35 142.36,76.74 145.43,76.74 146.32,77.63 146.32,78.05 v1(146.12,78.26)
  BOTTOM w0.254: R470.2 164.94,89.87 164.62,90.19 163.79,90.19 163.4,89.79 v1(163.18,89.79)
FPGA_TEMP4N: length 61.4
  L07_SIG3 w0.203: v1(170.97,95.9) 170.63,95.56 170.63,95 170.13,94.5 162.53,94.5 162.2,94.83 159.14,94.83 157.47,93.16 157.47,91.87 154.27,88.68 146.98,88.68 145.29,87 145.29,80.59 145.59,80.3 146.31,80.3 146.71,79.9 146.71,79.4 v1(146.87,79.24)
  BOTTOM w0.203: v1(146.87,79.24) 146.87,79.16 146.45,78.74 144.49,78.74 144.12,78.37 143.51,77.75 143.51,77.62 141.92,76.03 141.62,76.03 141.37,75.78 141.37,74.9 140.99,74.53 140.75,74.53 140.25,74.03 139.89,74.03 139.39,73.53 139.02,73.53 138.52,73.03 138.15,73.03 137.65,72.53 137.29,72.53 136.85,72.1 136.49,72.1 136.06,71.67 135.56,71.67 135.13,72.09 134.61,72.09 134.18,71.67 133.82,71.67 133.65,71.84 132.93,71.84 132.43,71.34 132.08,71.34 131.84,71.09 131.84,71.08 131.83,71.07 131.83,70.84 arc(131.84,70.74) 131.89,70.65 arc(131.92,70.58) 131.93,70.5 131.93,70.4 arc(131.92,70.33) 131.89,70.28 131.81,70.17 arc(131.77,70.09) 131.76,70.02 131.76,69.87 arc(131.78,69.79) 131.82,69.72 131.89,69.65 arc(131.94,69.59) 131.95,69.5 131.95,69.33 v1(132.26,69.02)
FPGA_TEMP4P: length 63.2
  L07_SIG3 w0.203: v1(169.96,95.9) 170.3,95.56 170.3,95.14 170,94.83 162.67,94.83 162.34,95.16 159,95.16 157.13,93.3 157.13,92.01 154.14,89.01 146.84,89.01 144.96,87.13 144.96,80.46 145.45,79.97 146.17,79.97 146.38,79.76 146.38,79.45 146.22,79.3 v1(146.21,79.3)
  BOTTOM w0.203: v1(146.21,79.3) 146.22,79.3 146.27,79.3 146.27,79.29 146.05,79.07 144.36,79.07 143.99,78.7 143.27,78.7 142.99,78.42 142.99,78.08 143.05,78.02 143.05,77.63 141.78,76.36 141.48,76.36 140.15,75.03 139.89,75.03 139.39,74.53 139.02,74.53 138.52,74.03 138.15,74.03 137.74,73.62 137.23,73.62 136.78,73.17 136.51,73.17 135.97,72.62 135.45,72.62 135.05,73.03 134.69,73.03 134.33,72.67 133.82,72.67 133.76,72.73 132.87,72.73 132.56,72.42 132.56,72.42 132.44,72.3 132.1,72.3 131.58,71.78 131.28,71.78 131.03,71.53 131.03,71.17 131.1,71.09 arc(131.11,71.08) 131.11,71.07 131.11,70.71 arc(131.11,70.7) 131.1,70.69 131.04,70.62 arc(131.03,70.61) 131.03,70.6 131.03,70.27 arc(131.03,70.25) 131.04,70.24 131.12,70.16 131.12,69.78 131.03,69.69 131.03,69.33 131.28,69.08 131.3,69.08 131.32,69.06 131.6,69.06 132.26,68.4 v1(132.26,68.1)
FPGA_TEMP6N: length 66.5
  L07_SIG3 w0.203: v1(145.78,80.88) 145.96,81.07 145.93,82.07 145.93,82.07 145.93,86.46 147.44,87.96 154.86,87.96 159.25,92.36 163.13,92.36 v1(163.37,92.6)
  BOTTOM w0.203: v1(132.26,59.85) 131.29,59.85 130.92,60.22 130.91,60.22 130.84,60.28 130.54,60.28 130.03,60.8 129.69,60.8 129.44,61.05 129.44,61.41 129.57,61.54 129.57,61.84 129.44,61.97 129.44,62.33 129.57,62.46 129.57,62.76 129.44,62.89 129.44,63.25 129.57,63.38 129.57,63.64 129.43,63.78 129.43,64.2 129.5,64.27 129.5,64.63 129.43,64.7 129.43,65.12 129.5,65.19 129.5,65.55 129.43,65.62 129.43,66.04 129.5,66.11 129.5,66.47 129.43,66.54 129.43,66.96 129.5,67.03 129.5,67.39 129.43,67.46 129.43,67.88 129.5,67.95 129.5,68.23 arc(129.49,68.29) 129.47,68.35 129.4,68.44 arc(129.38,68.49) 129.37,68.55 arc(129.39,68.69) 129.46,68.8 arc(129.5,68.88) 129.51,68.96 129.51,69.14 arc(129.5,69.19) 129.48,69.24 arc(129.45,69.33) 129.43,69.43 129.43,69.57 arc(129.45,69.67) 129.49,69.76 arc(129.52,69.82) 129.52,69.87 129.52,70.01 arc(129.51,70.12) 129.47,70.21 129.43,70.29 arc(129.41,70.33) 129.4,70.39 129.4,70.46 arc(129.41,70.52) 129.44,70.58 129.44,70.58 arc(129.49,70.67) 129.51,70.78 129.51,71.1 129.44,71.17 129.44,71.53 129.5,71.59 129.5,72.02 129.44,72.09 129.44,72.45 129.5,72.51 129.5,72.94 129.44,73.01 129.44,73.37 129.69,73.62 130,73.62 130.52,74.15 130.84,74.15 131.23,74.54 131.64,74.54 132.03,74.15 132.43,74.15 132.89,74.61 133.23,74.61 133.47,74.86 133.47,75.18 133.82,75.53 134.18,75.53 134.61,75.11 135.13,75.11 135.56,75.53 135.92,75.53 137.17,76.78 138.38,76.78 138.67,77.08 138.67,79.14 139.06,79.53 140.99,79.53 142.44,80.98 143.84,80.98 144.3,80.52 145.41,80.52 v1(145.78,80.88)
  BOTTOM w0.254: v1(163.37,92.6) 163.77,92.6 163.89,92.47 164.65,92.47 164.94,92.76 R473.2
FPGA_TEMP6P: length 70.2
  L07_SIG3 w0.203: v1(163.37,91.79) 163.13,92.03 159.39,92.03 154.99,87.63 147.57,87.63 146.26,86.32 146.26,81.94 146.29,81.08 v1(146.48,80.9)
  BOTTOM w0.203: v1(133.05,59.39) 133.36,59.08 133.4,59.08 133.82,58.67 134.18,58.67 134.68,59.17 135.05,59.17 135.38,59.5 135.38,59.84 135.3,59.92 135.3,60.22 135.37,60.35 135.37,60.81 135.22,60.96 135.2,61.05 135.01,61.15 134.99,61.17 134.69,61.17 134.2,61.66 132.9,61.66 132.44,62.12 132.1,62.12 131.62,62.6 131.28,62.6 130.84,63.04 130.54,63.04 130.23,63.35 130.23,63.74 130.3,63.81 130.3,64.2 130.23,64.27 130.23,64.63 130.3,64.69 130.3,65.12 130.23,65.19 130.23,65.55 130.3,65.61 130.3,66.04 130.23,66.11 130.23,66.47 130.3,66.53 130.3,66.96 130.23,67.03 130.23,67.39 130.3,67.45 130.3,67.88 130.23,67.95 130.23,68.21 arc(130.24,68.3) 130.28,68.38 arc(130.33,68.48) 130.34,68.6 arc(130.33,68.67) 130.31,68.73 130.26,68.81 arc(130.23,68.9) 130.21,69 130.21,69.14 arc(130.22,69.19) 130.24,69.24 arc(130.28,69.34) 130.29,69.44 130.29,69.65 arc(130.28,69.72) 130.24,69.78 arc(130.19,69.87) 130.18,69.97 130.18,70.13 130.3,70.25 130.3,70.61 130.23,70.67 130.23,71.1 130.3,71.17 130.3,71.53 130.23,71.59 130.23,72.02 130.3,72.09 130.3,72.45 130.23,72.51 130.23,72.91 130.49,73.16 130.49,73.16 130.55,73.22 130.84,73.22 130.85,73.23 130.89,73.23 131.28,73.62 131.68,73.62 132.08,73.22 132.44,73.22 132.84,73.62 133.37,73.62 133.57,73.83 133.57,74.28 133.82,74.53 134.33,74.53 134.69,74.17 135.05,74.17 135.41,74.53 135.92,74.53 136.42,75.03 136.79,75.03 137.29,75.53 137.59,75.53 139,76.94 139,79 139.2,79.2 141.13,79.2 142.04,80.12 142.8,80.12 143.33,80.65 143.7,80.65 144.17,80.19 145.41,80.19 145.42,80.18 145.75,80.18 v1(146.48,80.9)
  BOTTOM w0.254: R472.2 164.94,91.8 164.65,92.09 164.05,92.09 163.75,91.79 v1(163.37,91.79)
FPGA_VCC: length 55.3
  L14_SIG5 w0.203: v1(175,62.28) 174.89,62.17 143.15,62.17 142.83,62.49 142.5,62.49 142.18,62.17 141.47,62.17 141.11,62.53 140.75,62.53 140.39,62.17 139.68,62.17 139.36,62.49 138.84,62.49 138.51,62.17 137.95,62.17 137.63,62.49 137.3,62.49 136.98,62.17 136.27,62.17 135.91,62.53 135.56,62.53 135.2,62.17 134.49,62.17 134.08,62.58 132.88,62.58 132.47,62.17 131.99,62.17 131.62,62.54 131.3,62.54 130.93,62.17 130.4,62.17 130.03,62.54 129.7,62.54 129.33,62.17 128.81,62.17 128.44,62.54 128.11,62.54 127.74,62.17 127.21,62.17 126.84,62.54 126.52,62.54 126.15,62.17 125.67,62.17 125.24,62.61 v1(124.29,62.61)
  BOTTOM w0.381: R5887.2 175.38,61.52 175,61.9 v1(175,62.28)
  vias: v1(108.35,58.93) v1(108.35,58.01) v1(108.35,56.17) v1(108.35,55.25) v1(108.35,53.41) v1(108.35,52.49) v1(109.15,52.95) v1(109.15,52.03) v1(109.15,63.99) v1(109.15,63.07) v1(109.15,61.23) v1(109.15,60.31) v1(109.15,58.47) v1(109.15,57.55) v1(109.15,55.71) v1(109.15,54.79) v1(109.91,66.28) v1(109.93,65.37) v1(109.95,63.53) v1(109.95,62.61) v1(109.95,60.77) v1(109.95,59.85) v1(109.95,58.01) v1(109.95,57.09) v1(109.95,55.25) v1(109.95,54.33) v1(109.95,52.49) v1(109.95,51.57) v1(110.74,63.07) v1(110.74,62.15) v1(110.74,60.31) v1(110.74,59.39) v1(110.74,57.55) v1(110.74,56.63) v1(110.74,54.79) v1(110.74,53.87) v1(110.74,52.03) v1(110.76,65.83) v1(110.75,64.91) v1(111.54,67.21) v1(111.54,65.37) v1(111.54,64.45) v1(111.54,63.53) v1(111.54,62.61) v1(111.54,61.69) v1(111.54,60.77) v1(111.54,59.85) v1(111.54,58.93) v1(111.54,58.01) v1(111.54,57.09) v1(111.54,56.17) v1(111.54,55.25) v1(111.54,54.33) v1(111.54,53.41) v1(111.54,51.57) v1(111.55,35.64) v1(111.82,36.63) v1(112.34,67.67) v1(112.34,66.75) v1(112.34,64.91) v1(112.34,53.87) v1(112.34,52.95) v1(113.14,67.2) v1(113.13,66.29) v1(113.13,53.41) v1(113.13,52.49) v1(113.13,50.65) v1(113.13,49.73) v1(113.93,66.75) v1(113.93,65.83) v1(113.93,52.95) v1(113.93,52.03) v1(114.73,69.03) v1(114.73,68.13) v1(114.73,66.29) v1(114.73,65.37) v1(114.73,52.49) v1(114.73,51.57) v1(114.73,50.65) v1(114.73,49.73) v1(115.52,65.83) v1(115.52,64.91) v1(115.52,53.87) v1(115.52,52.03) v1(116.32,69.01) v1(116.32,68.13) v1(116.32,67.21) v1(116.32,65.37) v1(116.32,53.41) v1(116.32,51.57) v1(116.32,50.65) v1(116.32,49.73) v1(117.12,66.75) v1(117.12,64.91) v1(117.12,53.87) v1(117.12,52.95) v1(117.92,69.01) v1(117.92,68.13) v1(117.92,67.21) v1(117.92,66.29) v1(117.92,53.41) v1(117.91,52.49) v1(117.91,50.65) v1(117.91,49.73) v1(118.71,66.75) v1(118.71,65.83) v1(118.71,52.95) v1(118.71,52.03) v1(119.51,69.05) v1(119.51,68.11) v1(119.51,66.29) v1(119.51,65.37) v1(119.51,52.49) v1(119.51,51.57) v1(119.51,50.65) v1(119.51,49.73) v1(120.31,67.67) v1(120.31,65.83) v1(120.31,64.91) v1(120.31,53.87) v1(120.31,52.03) v1(120.31,51.11) v1(120.91,88.25) v1(121.1,69.06) v1(121.1,68.1) v1(121.1,67.21) v1(121.1,65.37) v1(121.1,53.41) v1(121.1,51.57) v1(121.9,67.67) v1(121.9,66.75) v1(121.9,64.91) v1(121.9,63.99) v1(121.9,63.07) v1(121.9,62.15) v1(121.9,61.23) v1(121.9,60.31) v1(121.9,59.39) v1(121.9,58.47) v1(121.9,57.55) v1(121.9,56.63) v1(121.9,55.71) v1(121.9,54.79) v1(121.9,53.87) v1(121.9,52.95) v1(121.9,51.11) v1(122.7,67.21) v1(122.7,66.29) v1(122.7,64.45) v1(122.7,63.53) v1(122.7,61.69) v1(122.7,60.77) v1(122.7,58.01) v1(122.7,56.17) v1(122.7,55.25) v1(122.7,53.41) v1(122.7,52.49) v1(123.49,66.75) v1(123.49,65.83) v1(123.49,63.99) v1(123.49,63.07) v1(123.49,61.23) v1(123.49,60.31) v1(123.49,58.47) v1(123.49,57.55) v1(123.49,55.71) v1(123.49,54.79) v1(123.49,52.95) v1(123.49,52.03) v1(124.29,66.29) v1(124.29,65.37) v1(124.29,63.53) v1(124.29,60.77) v1(124.29,59.85) v1(124.29,58.01) v1(124.29,57.09) v1(124.29,55.25) v1(124.29,54.33) v1(144.4,45.1) v1(144.4,44.1) v1(145.23,71.6) v3(97,86.42) v3(97,85.32) v3(106.25,86.19) v3(106.25,85.14) v3(110.74,32.53) v3(110.79,33.74) v3(117.91,33.74) v3(117.91,32.53) v3(122.28,33.64) v3(122.28,32.43) v3(124.28,85.14) v3(130.66,86.14) v3(130.68,85.12) v3(148.57,60.86) v3(148.8,42.91) v8(151.38,76.73) v8(151.38,74.6) v8(151.38,72.34) v8(151.38,70.6) v8(151.38,68.98) v8(151.38,67.23) v8(151.38,65.74) v8(153.16,76.73) v8(153.16,74.6) v8(153.16,72.34) v8(153.16,70.6) v8(153.16,68.98) v8(153.16,67.23) v8(153.16,65.74) v8(154.94,76.73) v8(154.94,74.6) v8(154.94,72.34) v8(154.94,70.6) v8(154.94,68.98) v8(154.94,67.23) v8(154.94,65.74) v8(155,33.37) v8(155.1,35.09) v8(155.77,34.28) v8(156.45,33.45) v8(156.49,35.06) v8(156.7,57.67) v8(156.7,56.23) v8(156.82,54.46) v8(156.99,84.89) v8(157.05,41.05) v8(157.09,86.61) v8(157.07,42.67) v8(157.26,68.85) v8(157.36,70.57) v8(157.59,56.86) v8(157.59,55.33) v8(157.75,41.87) v8(157.76,85.81) v8(158.04,69.77) v8(158.44,84.98) v8(158.42,41.04) v8(158.45,83.42) v8(158.47,57.67) v8(158.47,56.23) v8(158.47,54.46) v8(158.46,42.65) v8(158.75,70.55) v8(158.71,68.94)
FPGA_VCC_EN: length 228.2
  TOP w0.127: v1(178.62,55.4) 178.62,55.42 R853.2 R6037.1 179.64,55.46 180.29,56.11 U119.20
  L05_SIG2 w0.127: v1(25.01,32.5) 25.77,32.5 27.89,30.39 27.89,28.74 27.89,27.55 28.02,27.42 31.54,27.42 31.89,27.07 31.89,26.74 32.28,26.35 36.5,26.35 36.89,26.74 36.89,26.92 37.51,27.55 37.71,27.55 37.97,27.8 v1(37.97,28.29)
  L07_SIG3 w0.127: v1(179.84,26.17) 179.82,26.15 179.82,24.43 179.42,24.03 179.42,24 179.19,23.77 179.16,23.77 177.58,22.19 175.73,22.19 173.88,20.34 173.88,15.98 173.22,15.33 165.11,15.33 164.87,15.1 163.72,15.1 163.62,15.2 163.19,15.2 162.66,14.67 137.83,14.67 137.56,14.94 132.87,14.94 130.88,12.95 130.87,12.95 130.63,12.71 130.63,12.36 130.63,12.36 130.63,12.25 128.86,10.47 128.84,10.47 128.56,10.19 128.04,9.67 128.04,9.66 127.45,9.07 123.53,9.07 62.34,9.07 59.73,11.68 59.04,11.68 58.8,11.92 58.8,13.57 57.31,15.06 54.92,15.06 53.09,16.89 49.69,16.89 49.23,16.43 48.39,16.43 47.33,15.37 46.59,15.37 45.69,16.27 45.69,18.18 44.95,18.92 44.95,19.57 44.49,20.03 44.49,21.88 44.74,22.14 44.74,23.08 42.85,24.98 42.26,24.98 41.51,25.73 41.29,25.73 39.98,27.04 38.76,27.04 37.97,27.84 v1(37.97,28.29)
  BOTTOM w0.127: R6229.2 25.03,31.01 24.83,31.22 24.83,31.68 24.89,31.74 24.89,32.38 v1(25.01,32.5) ; 176.08,49.07 176.08,45.44 175.02,44.38
  BOTTOM w0.149: 175.02,44.38 174.44,43.81 174.35,43.81 174.35,43.81 174.16,43.81 173.86,43.51 173.86,40.26 174.93,39.2 174.93,33.99 176.15,32.76 176.15,29.87 v1(179.84,26.17) ; v1(178.62,55.4) 178.62,55.39 178.64,55.41 179.34,55.41 179.82,54.94 179.82,54.31 179.17,53.67 179.17,53.02 178.36,52.21 175.4,52.21 174.99,51.8 174.99,50.16 176.08,49.07
FPGA_VCC_PG: length 223.9
  TOP w0.127: v1(175.79,40.85) 176.02,40.61 176.02,38.69 175.17,37.84 175.17,36.95 174.92,36.7 174.92,35.32 175.23,35.01 175.23,33.41 175.59,33.05 175.59,31.66 175.39,31.46 175.39,27.41 177.48,25.32 177.48,20.7 177.45,20.66 v1(177.45,20.27)
  L03_SIG1 w0.127: v1(176.01,56.1) 176.28,55.83 178.78,55.83 179.28,55.33 183.18,55.33 184.01,54.51 v1(184.06,54.51)
  L05_SIG2 w0.127: v1(177.15,15.88) 174.98,13.71 130.45,13.71 130.03,14.12 120.17,14.12 115.24,9.19 59.85,9.19 57.77,11.27 56.66,11.27 56,11.93 55.19,11.93 54.08,13.05 52.59,13.05 52.11,12.57 48.52,12.57 48.04,13.04 47.07,13.04 45.1,15.02 33.45,15.02 32.28,16.19 28.31,16.19 26.89,17.61 26.89,18.51 v1(26.5,18.9)
  L07_SIG3 w0.127: v1(175.79,40.85) 176.03,41.09 176.03,41.94 175.51,42.45 175.51,44.91 176.92,46.32 176.92,50.67 177.53,51.28 180.45,51.28 181.8,52.64 181.84,52.64 182.15,52.95 182.5,52.95 v1(184.06,54.51) ; v1(177.45,20.27) 177.15,19.97 v1(177.15,15.88)
  BOTTOM w0.127: C7664.2 177.2,58.56 177.18,58.54 176.62,58.54 175.85,57.77 175.45,57.77 ; 175.45,57.77 174.92,58.31 174.92,58.49 174.87,58.53 174.87,59.59 R6291.1 ; 175.45,57.77 175.45,56.65 v1(176.01,56.1) 176.01,56.16 R6036.1 R6279.1
FPGA_VID_ALERTN: length 17.2
  TOP w0.149: U34.N4 v1(26.08,20.46)
  L12_SIG4 w0.089: v1(41.59,18.98) 39.15,18.98 38.69,18.53 31.34,18.53 31.12,18.75 31.12,18.81 30.58,19.35 28.52,19.35 27.87,20 27.87,20.06 27.65,20.28 26.86,20.28 26.68,20.46 v1(26.08,20.46)
FX2_D_N: length 19.9
  TOP w0.102: U143.9 15.11,24.91 14.99,24.79 14.99,24.33 v1(15.23,24.1) ; J8.2 4.21,29.04 6.11,29.04 v1(6.17,28.98)
  BOTTOM w0.102: v1(6.17,28.98) 6.39,28.76 6.71,28.76 7.12,28.35 7.12,25.76 9.75,23.13 15.37,23.13 15.85,23.61 15.85,24.72 15.75,24.82 15.17,24.82 14.97,24.62 14.97,24.35 v1(15.23,24.1)
FX2_D_P: length 21.1
  TOP w0.102: U143.8 14.61,24.92 14.72,24.82 14.72,24.32 v1(14.49,24.1) ; v1(6.17,28.28) 6.09,28.19 4.23,28.19 J8.3
  BOTTOM w0.102: v1(6.17,28.28) 6.42,28.53 6.62,28.53 6.89,28.25 6.89,25.67 9.66,22.9 15.47,22.9 16.08,23.51 16.08,24.81 15.84,25.05 15.08,25.05 14.74,24.71 14.74,24.35 v1(14.49,24.1)
FX2_FLAGA: length 25.6
  TOP w0.149: v1(20.2,31.25) 20.2,32.08 19.27,33.01 U143.29
  L03_SIG1 w0.081: v2(27.5,24.9) 27.87,25.27 27.87,26.06 27.65,26.27 25.39,26.27 24.87,26.8 24.87,28.06 24.65,28.27 23.21,28.27 23.03,28.1 23.03,27.63 22.95,27.55 22.78,27.55 22.7,27.63 22.7,28.1 22.62,28.18 22.44,28.18 22.36,28.1 22.36,27.63 22.28,27.55 22.11,27.55 22.03,27.63 22.03,28.1 21.95,28.18 21.77,28.18 21.69,28.1 21.69,27.63 21.61,27.55 21.44,27.55 21.36,27.63 21.36,28.1 21.27,28.18 20.68,28.18 20.11,28.75 20,28.75 19.41,29.34 18.74,29.34 17.97,30.11 17.97,30.41 17.37,31.01 17.37,31.13 17.55,31.31 17.73,31.31 18.57,30.47 19.22,30.47 19.58,30.82 19.77,30.82 v1(20.2,31.25)
FX2_FLAGB: length 25.2
  TOP w0.149: v2(17.35,34.13) 17.35,33.99 17.11,33.74 U143.30
  L03_SIG1 w0.081: v2(28.5,25.9) 27.94,26.46 27.94,26.98 27.65,27.27 26.27,27.27 25.87,27.68 25.87,29.06 25.65,29.27 25.39,29.27 25.15,29.52 23.35,29.52 22.63,30.23 22.63,30.78 22.85,30.99 22.85,31.31 22.57,31.58 22.57,32 21.84,32.74 21.84,33.05 21.75,33.13 21.46,33.13 21.38,33.22 21.38,33.39 21.46,33.47 21.75,33.47 21.84,33.55 21.84,34.16 21.54,34.45 21.31,34.45 21.23,34.37 21.23,34.12 21.15,34.04 20.98,34.04 20.89,34.12 20.89,34.37 20.81,34.45 20.68,34.45 20.11,33.89 19.05,33.89 18.88,34.06 18.88,34.45 18.8,34.53 17.98,34.53 17.9,34.61 17.9,34.78 17.98,34.86 18.8,34.86 18.88,34.95 18.88,35.34 18.62,35.61 17.52,35.61 17.35,35.45 v2(17.35,34.13)
FX2_FLAGC: length 29
  TOP w0.149: v2(14.04,35.47) 14.34,35.17 15.51,35.17 16.61,34.07 U143.31
  L03_SIG1 w0.081: v2(14.04,35.47) 11.19,35.47 10.33,34.61 10.33,33.25 10.73,32.85 10.73,32.28 12.47,30.54 12.47,30.36 15.71,27.12 17.09,27.12 19.23,24.98 22.82,24.98 23.27,24.53 25.12,24.53 v2(25.5,24.9)
FX2_PA0: length 29.4
  TOP w0.149: v2(15.42,34.57) 15.61,34.39 U143.33
  L03_SIG1 w0.081: v2(27.5,27.9) 27.5,28.28 26.87,28.9 26.87,29.06 26.65,29.27 26.59,29.27 25.63,30.24 25.28,30.24 25.04,30.48 24.39,30.48 24.08,30.78 24.08,31.13 23.68,31.53 23.34,31.53 23.12,31.75 23.12,32.33 22.4,33.05 22.4,36.54 21.52,37.42 21.52,37.84 21.08,38.28 18.02,38.28 17.93,38.2 17.93,38.06 17.33,37.45 17.1,37.45 16.63,36.98 16.63,33.57 16.3,33.24 14.16,33.24 13.74,33.66 13.74,33.96 13.97,34.2 14.61,34.2 14.98,34.57 v2(15.42,34.57)
FX2_PA1: length 25.1
  TOP w0.149: U143.34 v2(15.11,33.81)
  L03_SIG1 w0.081: v2(15.11,33.81) 15.52,33.81 16.28,34.58 16.28,37.46 17.33,38.5 21.13,38.5 21.7,37.92 21.7,37.59 22.69,36.61 22.69,36.13 22.77,36.05 23.32,36.05 23.4,35.97 23.4,35.8 23.32,35.72 22.77,35.72 22.69,35.64 22.69,33.97 22.77,33.89 23.57,33.89 23.65,33.81 23.65,33.64 23.57,33.55 22.77,33.55 22.69,33.47 22.69,33.24 24.12,31.8 24.12,31.75 24.49,31.38 24.69,31.38 24.87,31.56 24.98,31.56 25.1,31.44 25.1,31.32 24.93,31.15 24.93,30.95 25.34,30.53 26.12,30.53 v2(26.5,30.9)
FX2_PA2: length 25.2
  TOP w0.149: v2(14.43,34.61) 14.42,34.61 14.42,34.58 14.61,34.4 U143.35
  L03_SIG1 w0.081: v2(14.43,34.61) 14.06,34.61 13.5,34.06 13.5,33.56 14.06,33.01 16.56,33.01 16.97,33.41 16.97,35.59 17.23,35.84 18.77,35.84 19.13,35.49 19.13,34.53 19.33,34.33 20.22,34.33 20.58,34.69 21.68,34.69 22.07,34.3 22.07,32.86 22.81,32.12 22.81,31.68 23.08,31.4 23.08,30.51 23.31,30.29 24.64,30.29 25.36,29.57 25.61,29.57 26.05,29.13 26.05,28.35 v2(26.5,27.9)
FX2_PA3: length 25.2
  TOP w0.149: U143.36 v2(14.11,33.81)
  L03_SIG1 w0.081: v2(14.11,33.81) 14.58,33.81 14.97,34.2 15.58,34.2 15.96,34.59 15.96,35.99 15.88,36.07 15.01,36.07 14.93,36.15 14.93,36.32 15.01,36.4 15.88,36.4 15.96,36.48 15.96,36.66 15.88,36.74 15.01,36.74 14.93,36.82 14.93,36.99 15.01,37.07 15.88,37.07 15.96,37.15 15.96,37.48 17.17,38.69 21.19,38.69 21.89,37.99 21.89,37.67 22.1,37.45 22.43,37.45 23.72,36.16 23.72,34.56 24.08,34.19 24.08,32.64 24.45,32.27 24.65,32.27 24.87,32.06 24.87,31.98 25.5,31.35 v2(25.5,30.9)
FX2_PA4: length 25.1
  TOP w0.149: v2(13.49,34.69) 13.61,34.57 U143.37
  L03_SIG1 w0.081: v2(13.49,34.69) 13.11,35.07 11.52,35.07 11.07,34.62 11.07,34.24 19.77,25.53 27.12,25.53 v2(27.5,25.9)
FX2_PA5: length 25.1
  TOP w0.149: U143.38 13.11,34.07 v2(12.98,34.2)
  L03_SIG1 w0.081: v2(25.5,28.9) 25.11,29.29 24.27,29.29 24.19,29.21 24.19,29.09 24.11,29 23.94,29 23.86,29.09 23.86,29.21 23.78,29.29 23.25,29.29 23,29.54 22.88,29.54 22.71,29.37 22.6,29.37 22.47,29.49 22.47,29.61 22.64,29.78 22.64,29.89 22.4,30.14 22.4,31.41 22.03,31.78 21.91,31.78 21.7,31.57 21.58,31.57 21.46,31.69 21.46,31.8 21.68,32.02 21.68,32.13 21.52,32.29 20.87,32.29 20.41,32.75 19.98,32.75 19.9,32.83 19.9,32.93 19.82,33.01 19.65,33.01 19.57,32.93 19.57,32.83 19.49,32.75 19.11,32.75 19.02,32.83 19.02,33.49 18.94,33.57 18.77,33.57 18.69,33.49 18.69,32.41 18.61,32.32 18.44,32.32 18.35,32.41 18.35,33.49 18.27,33.57 18.1,33.57 18.02,33.49 18.02,32.41 17.94,32.32 17.77,32.32 17.68,32.41 17.68,33.49 17.6,33.57 17.43,33.57 17.35,33.49 17.35,32.83 17.27,32.75 13.99,32.75 13.18,33.55 13.18,34 v2(12.98,34.2)
FX2_PA6: length 25.1
  TOP w0.149: v2(12.61,33.81) U143.39
  L03_SIG1 w0.081: v2(12.61,33.81) 12.87,33.55 12.87,33.53 13.96,32.45 14.94,32.45 15.02,32.36 15.02,31.97 15.1,31.89 15.27,31.89 15.35,31.97 15.35,32.36 15.43,32.45 15.61,32.45 15.69,32.36 15.69,31.97 15.77,31.89 15.94,31.89 16.02,31.97 16.02,32.36 16.1,32.45 16.28,32.45 16.36,32.36 16.36,31.97 16.44,31.89 16.61,31.89 16.69,31.97 16.69,32.36 16.77,32.45 16.96,32.45 17.59,31.81 18.55,31.81 18.89,31.47 19.22,31.47 19.72,31.96 19.94,31.96 20.02,32.04 20.02,32.2 20.1,32.28 20.28,32.28 20.36,32.2 20.36,32.04 20.44,31.96 20.79,31.96 21.08,31.67 21.08,31.56 20.7,31.18 20.7,31.07 20.82,30.95 20.94,30.95 21.31,31.32 21.43,31.32 22.17,30.58 22.17,29.32 22.99,28.5 24.68,28.5 25.12,28.06 25.12,26.8 25.4,26.53 27.12,26.53 v2(27.5,26.9)
FX2_PA7: length 25.2
  TOP w0.149: U143.40 12.11,33.82 11.9,34.03 v2(11.9,34.15)
  L03_SIG1 w0.081: v2(24.49,27.9) 23.65,27.06 23.65,26.21 23.57,26.13 23.4,26.13 23.32,26.21 23.32,27.12 23.24,27.2 23.06,27.2 22.98,27.12 22.98,26.21 22.9,26.13 22.73,26.13 22.65,26.21 22.65,27.12 22.56,27.2 22.39,27.2 22.31,27.12 22.31,26.21 22.23,26.13 22.06,26.13 21.98,26.21 21.98,27.12 21.89,27.2 21.72,27.2 21.64,27.12 21.64,26.21 21.56,26.13 21.39,26.13 21.3,26.21 21.3,27.12 21.22,27.2 20.78,27.2 20.15,27.83 19.92,27.83 19.31,28.44 18.86,28.44 17.63,29.67 17.63,30.11 16.7,31.03 15.41,31.03 14.52,31.92 13.85,31.92 11.9,33.87 v2(11.9,34.15)
FX2_PB0: length 25.3
  TOP w0.149: v1(19.95,27.43) 19.87,27.36 U143.18
  L05_SIG2 w0.081: v1(24.49,26.9) 24.49,26.18 24.2,25.89 20.3,25.89 19.75,25.33 17.34,25.33 16.37,26.31 16.37,30.71 16.57,30.91 16.92,30.91 17.18,30.66 17.18,26.32 17.62,25.87 19.37,25.87 19.62,26.12 19.62,27.1 v1(19.95,27.43)
FX2_PB1: length 24.8
  TOP w0.149: v1(19.08,27.86) U143.19
  L05_SIG2 w0.081: v1(19.08,27.86) 18.3,27.86 18.1,27.66 18.1,27.28 18.18,27.19 18.67,27.19 18.75,27.11 18.75,26.94 18.67,26.86 18.18,26.86 18.1,26.78 18.1,26.55 17.97,26.42 17.75,26.42 17.58,26.59 17.58,28.1 17.86,28.37 19.21,28.37 19.72,27.86 20.23,27.86 20.43,27.66 20.43,26.47 20.78,26.12 23.78,26.12 24.12,26.46 24.12,27.06 24.34,27.27 26.76,27.27 26.97,27.49 26.97,30.58 26.55,31 25.86,31 25.39,31.48 24.65,31.48 24.49,31.32 v1(24.49,30.9)
FX2_PB2: length 24.8
  TOP w0.149: U143.20 v1(19.95,28.36)
  L05_SIG2 w0.081: v1(23.49,27.9) 23.28,27.68 23.28,26.47 23.19,26.39 23.02,26.39 22.94,26.47 22.94,29.81 22.85,29.91 22.71,29.91 22.61,29.8 22.61,26.47 22.52,26.39 22.35,26.39 22.27,26.47 22.27,29.13 22.19,29.21 22.02,29.21 21.93,29.13 21.93,26.47 21.85,26.39 21.68,26.39 21.6,26.47 21.6,28.42 21.5,28.51 21.33,28.51 21.26,28.45 21.26,26.47 21.18,26.39 21.01,26.39 20.93,26.47 20.93,28.27 20.84,28.36 v1(19.95,28.36)
FX2_PB3: length 26.6
  TOP w0.149: U143.21 v1(19.06,28.86)
  L05_SIG2 w0.081: v1(19.06,28.86) 18.75,28.86 17.79,29.83 17.79,32.02 16.69,33.12 16.69,37.91 17.4,38.62 23.56,38.62 25.69,36.49 25.69,34.63 24.12,33.06 24.12,32.7 24.49,32.33 v1(24.49,31.9)
FX2_PB4: length 26
  TOP w0.149: U143.22 v1(19.95,29.36)
  L05_SIG2 w0.081: v1(19.95,29.36) 19.47,29.83 19.47,31.02 19.02,31.47 18.89,31.47 18.59,31.77 18.59,32.9 19.51,33.83 22.33,33.83 22.67,33.48 22.67,31.08 23.32,30.43 25.65,30.43 26.01,30.07 26.01,29.48 25.93,29.4 24.98,29.4 24.89,29.32 24.89,29.14 24.98,29.06 25.93,29.06 26.01,28.98 26.01,28.61 25.88,28.48 25.09,28.48 25.01,28.39 25.01,27.69 24.93,27.61 24.75,27.61 24.67,27.69 24.67,28.39 24.59,28.48 24.42,28.48 24.34,28.39 24.34,27.69 24.26,27.61 24.08,27.61 24,27.69 24,28.39 v1(23.49,28.9)
FX2_PB5: length 24.9
  TOP w0.149: U143.23 v1(19.06,29.86)
  L05_SIG2 w0.081: v1(19.06,29.86) 18.81,29.61 18.54,29.61 18.1,30.06 18.1,32.05 16.92,33.23 16.92,37.04 17.6,37.73 17.6,38.1 17.85,38.34 23.46,38.34 25.42,36.38 25.42,34.71 23.94,33.23 23.94,32.35 v1(23.49,31.9)
FX2_PB6: length 25.2
  TOP w0.149: U143.24 v1(19.84,30.36)
  L05_SIG2 w0.081: v1(19.84,30.36) 20.17,30.36 20.26,30.45 20.26,30.76 20.17,30.84 19.89,30.84 19.81,30.92 19.81,31.59 19.89,31.67 20.14,31.67 20.22,31.75 20.22,31.92 20.14,32 19.89,32 19.81,32.08 19.81,32.25 19.73,32.33 18.93,32.33 18.85,32.42 18.85,32.59 18.93,32.67 19.73,32.67 19.81,32.75 19.81,32.84 19.96,32.99 20.47,32.99 20.61,32.84 20.61,31.08 20.69,31 20.87,31 20.95,31.08 20.95,32.21 21.03,32.29 21.2,32.29 21.28,32.21 21.28,31.08 21.36,31 21.54,31 21.62,31.08 21.62,33.26 21.74,33.38 22.26,33.38 22.38,33.26 22.38,33.03 22.3,32.95 22.13,32.95 22.05,32.87 22.05,32.69 22.13,32.61 22.3,32.61 22.38,32.53 22.38,32.36 22.3,32.28 22.13,32.28 22.05,32.2 22.05,32.02 22.13,31.94 22.3,31.94 22.38,31.86 22.38,31.69 22.3,31.61 22.13,31.61 22.05,31.52 22.05,31.35 22.13,31.27 22.3,31.27 22.38,31.19 22.38,30.71 22.27,30.6 22.16,30.6 22,30.75 21.89,30.75 21.77,30.63 21.77,30.52 21.92,30.36 21.92,30.25 21.4,29.73 21.4,29.61 21.54,29.47 21.78,29.47 22.74,30.43 22.96,30.43 v1(23.49,29.9)
FX2_PB7: length 24.9
  TOP w0.149: U143.25 v1(19.06,30.86)
  L05_SIG2 w0.081: v1(23.49,30.9) 23.1,31.3 23.1,33.12 23.65,33.68 23.99,33.68 24.72,34.41 24.72,35.62 24.63,35.7 24.63,36.45 24.26,36.83 23.28,36.83 20.72,34.26 18.44,34.26 18.23,34.47 18.23,35 18.31,35.08 18.58,35.08 18.67,35.16 18.67,35.34 18.58,35.42 18.31,35.42 18.23,35.5 18.23,36.65 18.1,36.77 17.89,36.77 17.78,36.66 17.78,33.04 18.33,32.48 18.33,31.59 v1(19.06,30.86)
FX2_PD0: length 25.3
  TOP w0.149: U143.45 v1(9.66,31.36) ; U38.16 v2(19.03,16.28)
  L03_SIG1 w0.081: v2(19.03,16.28) 15.66,16.28 13.65,18.29 13.65,20.26 13.27,20.64 12.33,20.64 11.93,21.03 11.93,21.22 10.75,22.41 10.61,22.41 10.4,22.62 10.11,22.62 9.19,23.54 9.19,24.62 8.95,24.86 8.95,25.66 8.56,26.04 8.56,26.57 7.74,27.4 7.74,30.51 8.55,31.32 8.55,31.34 8.57,31.36 v1(9.66,31.36)
FX2_PD1: length 25.5
  TOP w0.149: v2(19.56,17.74) 19.53,17.77 U38.3 ; U143.46 v1(8.64,30.86)
  L03_SIG1 w0.081: v1(8.64,30.86) 7.97,30.19 7.97,27.5 8.8,26.67 8.8,26.14 9.18,25.75 9.18,24.96 9.43,24.72 9.43,23.64 10.21,22.85 10.49,22.85 10.71,22.64 10.85,22.64 11.8,21.69 12.61,21.69 13.02,21.27 13.02,21.14 13.27,20.89 13.4,20.89 13.91,20.39 13.91,18.36 15.67,16.6 18.42,16.6 v2(19.56,17.74)
FX2_PD2: length 23.3
  TOP w0.149: U38.9 16.78,18.17 16.41,18.53 v2(16.41,18.89) ; U143.47 v2(9.66,30.36)
  L03_SIG1 w0.081: v2(16.41,18.89) 15.92,19.38 15.92,21.05 15.82,21.15 15.7,21.15 15.37,20.82 15.25,20.82 15.13,20.94 15.13,21.05 15.46,21.39 15.46,21.5 15.34,21.63 15.23,21.63 14.96,21.35 14.84,21.35 14.72,21.48 14.72,21.59 14.99,21.86 14.99,21.98 14.87,22.1 14.75,22.1 14.42,21.76 14.3,21.76 14.18,21.89 14.18,22 14.52,22.34 14.52,22.45 14.39,22.57 14.28,22.57 13.94,22.24 13.83,22.24 13.71,22.36 13.71,22.48 14.04,22.81 14.04,22.93 13.83,23.14 11.71,23.14 11.54,23.32 10.4,23.32 9.89,23.83 9.89,24.91 9.65,25.15 9.65,25.95 9.27,26.33 9.27,26.86 8.44,27.69 8.44,29.13 9.66,30.35 v2(9.66,30.36)
FX2_PD3: length 23.3
  TOP w0.149: U38.12 17.03,16.97 16,16.97 v2(16,16.97) ; U143.48 v2(8.64,29.86)
  L03_SIG1 w0.081: v2(16,16.97) 15.18,17.79 14.93,18.04 14.93,20.51 14.65,20.79 14.18,20.79 13.93,21.03 13.93,21.44 13.25,22.12 13.13,22.12 12.9,21.89 12.78,21.89 12.66,22.01 12.66,22.12 13,22.46 13,22.7 12.79,22.91 12.21,22.91 12.13,22.83 12.13,22.1 12.04,22.01 11.87,22.01 11.79,22.1 11.79,22.83 11.71,22.91 10.81,22.91 10.63,23.09 10.31,23.09 9.66,23.73 9.66,24.81 9.42,25.05 9.42,25.85 9.03,26.24 9.03,26.77 8.2,27.59 8.2,29.42 v2(8.64,29.86)
FX2_PD4: length 30.1
  TOP w0.149: U143.49 v2(9.66,29.36)
  L03_SIG1 w0.081: v2(9.66,29.36) 11.17,29.36 12.69,27.84 12.69,27.68 14.69,25.68 17.7,25.68 19.85,23.53 23.14,23.53 23.32,23.35 26.6,23.35 27.12,22.82 27.12,22.75 27.34,22.53 27.47,22.53 28.12,21.88 28.12,21.75 28.34,21.53 28.39,21.53 29.12,20.8 29.12,20.75 29.6,20.27 31.65,20.27 31.87,20.06 31.87,18.75 31.02,17.9 v2(30.5,17.9)
FX2_PD5: length 25.2
  TOP w0.149: U143.50 9.23,28.86 9.15,28.94 9.15,28.94 v1(9.15,28.94)
  L03_SIG1 w0.081: v1(9.15,28.94) 10.41,28.94 12.47,26.89 12.47,26.69 13.7,25.45 17.6,25.45 19.75,23.29 22.58,23.29 23.34,22.53 26.34,22.53 26.83,22.04 26.83,21.49 27.02,21.29 27.73,21.29 27.87,21.15 27.87,20.61 28.5,19.99 v1(28.5,19.9)
FX2_PD6: length 28.3
  TOP w0.149: U143.51 9.42,28.36 9.42,28.37 9.08,28.37 9.08,28.36 v2(8.82,28.36)
  L03_SIG1 w0.081: v2(8.82,28.36) 8.81,28.35 8.81,27.69 9.53,26.97 9.82,26.97 10.54,26.26 10.54,24.97 10.13,24.56 10.13,23.92 10.5,23.55 14.14,23.55 14.23,23.47 14.85,23.47 17.01,21.31 19.75,21.31 20.25,20.81 23.02,20.81 23.29,20.53 25.34,20.53 26.34,19.53 27,19.53 27.18,19.35 27.57,19.35 27.94,18.98 27.94,18.67 28.07,18.54 28.07,18.32 v2(28.5,17.9)
FX2_PD7: length 28.1
  TOP w0.149: U143.52 10.41,27.91 9.43,27.91 9.38,27.96 v2(9.38,27.96)
  L03_SIG1 w0.081: v2(9.38,27.96) 9.38,27.96 9.43,27.91 10,27.91 10.77,27.15 10.77,24.87 10.37,24.47 10.37,24.02 10.6,23.79 14.24,23.79 14.33,23.7 14.94,23.7 17.11,21.54 19.94,21.54 20.28,21.2 23.26,21.2 23.34,21.27 25.78,21.27 27.05,20.01 27.05,19.82 27.34,19.53 27.65,19.53 28.12,19.06 28.12,18.75 28.34,18.53 29.12,18.53 v2(29.5,18.9)
FX2_RESETN: length 44.1
  TOP w0.149: U143.42 11.11,33.28 v2(10.7,33.68)
  L03_SIG1 w0.081: v2(10.7,33.68) 11.17,33.22 11.17,33.11 12.69,31.59 12.69,31.36 12.92,31.13 13.05,31.13 16.38,27.81 16.38,27.68 16.7,27.35 17.29,27.35 19.36,25.28 24.12,25.28 v1(24.49,24.9)
  L05_SIG2 w0.081: v1(24.49,24.9) 25.77,24.9 26.17,24.51 27.38,24.51 28.14,25.27 31.65,25.27 32.41,24.51 36.63,24.51 37.12,25.01 37.12,25.06 37.34,25.27 37.39,25.27 39.83,27.72 39.83,32.18 39.58,32.44 v1(39.23,32.44)
  BOTTOM w0.149: R374.1 40.45,33.24 39.74,32.53 39.32,32.53 v1(39.23,32.44)
  BOTTOM w0.203: U33.2 R374.1
FX2_SCL: length 19.2
  TOP w0.149: U143.15 18.26,24.06 18.02,23.82 18.02,22.99 R376.1 18.21,22.88 18.55,23.22 v1(18.55,23.6)
  L07_SIG3 w0.089: v1(30.5,18.9) 30.09,18.9 29.5,18.31 22.92,18.31 21.63,19.6 21.47,19.6 21.46,19.61 21.3,19.61 21.06,19.84 21.06,20.08 19.44,21.7 19.44,22.15 18.55,23.04 v1(18.55,23.6)
FX2_SDA: length 5
  TOP w0.149: U143.16 18.75,26.36 19.04,26.07 R377.1 R372.1
FX2_SLRDN: length 25.2
  TOP w0.149: U143.1 11.11,24.66 10.76,24.31 v1(10.74,24.31)
  L03_SIG1 w0.081: v1(31.5,18.9) 31.02,18.9 30.44,19.48 28.39,19.48 28.05,19.82 28.05,20.17 27.69,20.53 27.17,20.53 26.16,21.54 26.16,22.03 25.85,22.35 23.1,22.35 22.94,22.51 22.24,22.51 22.16,22.42 20.45,22.42 19.9,22.97 17.33,22.97 15.34,24.96 11.43,24.96 10.78,24.31 v1(10.74,24.31)
FX2_SLWRN: length 27.7
  TOP w0.149: U143.2 11.61,24.74 11.4,24.52 v1(11.4,24.3)
  L03_SIG1 w0.081: v1(33.5,17.9) 33.12,17.53 30.16,17.53 29.87,17.82 29.87,18.07 29.72,18.22 29.72,18.52 29.87,18.67 29.87,19.06 29.65,19.27 28.34,19.27 27.87,19.75 27.87,20.06 27.61,20.31 27.13,20.31 25.98,21.46 23.42,21.46 23.12,21.75 23.12,21.8 22.65,22.27 22.34,22.27 22.25,22.18 20.35,22.18 19.8,22.74 17.15,22.74 15.16,24.73 11.6,24.73 11.4,24.52 v1(11.4,24.3)
FX2_WAKEUP: length 5.6
  TOP w0.149: R383.2 R381.2 C499.1 R382.2 8.16,31.35 8.68,31.86 U143.44
G0_EN: length 5.1
  BOTTOM w0.149: v1(31.5,28.9) 31.96,29.37 31.96,33.11 32.4,33.56 R6228.1
G1_EN:
  vias: v1(25.5,31.9)
G2_EN: length 16
  TOP w0.149: v1(39.43,22.23) 39.55,22.35 R6232.2 ; R6232.2 R6237.2 R6231.2 R6235.2 R6233.2 ; R6232.2 v1(40.2,21.54)
  L12_SIG4 w0.089: v1(39.43,22.23) 38.7,22.23 38.65,22.28 36.99,22.28 34.91,24.36 33.51,24.36 32.87,25 32.87,27.53 v1(32.5,27.9)
  BOTTOM w0.149: R6234.2 v1(40.2,21.54)
G3_EN: length 8.9
  TOP w0.149: R6249.2 39.21,31.08 38.9,31.4 36,31.4 U34.B13 ; R6249.2 R6253.1 R6239.2 R6254.1 ; R6249.2 R6240.2 R6238.2
G4_EN: length 10
  TOP w0.149: U34.B8 30.7,31.9 31.24,32.45 31.68,32.45 31.95,32.72 31.95,34.13 R6246.2 v1(32.22,34.38) R6242.2 R6244.2 R6245.2 R6247.2
  BOTTOM w0.149: R6248.2 R6243.2 v1(32.22,34.38)
G5_EN:
  vias: v1(29.5,22.9)
GXF_PERSTN: length 175.7
  L12_SIG4 w0.089: v1(245.24,49.86) 244.11,51 244.11,58.25 241.25,61.11 241.25,61.61 240.99,61.87 240.83,61.87 239.98,62.72 239.98,62.97 239.3,63.65 236.09,63.65 235.66,63.22 233.22,63.22 230.54,63.22 229.5,64.26 223.95,64.26 221.73,62.03 216.67,62.03 215.5,63.21 214.94,63.21 212.99,65.16 212.99,65.16 212.76,65.39 212.75,65.39 212.27,65.88 209.55,65.88 204.54,70.89 193.83,70.89 193.08,70.13 193.08,67.19 192.58,66.68 192.19,66.68 191.97,66.9 191.97,67.21 192.02,67.27 192.02,68.05 191.94,68.13 191.94,68.46 192.02,68.53 192.02,70.28 190.81,71.49 177.1,71.49 175.19,73.4 172.57,73.4 171.71,74.27 166.37,74.27 166.16,74.06 158.02,74.06 155.73,71.77 149.19,71.77 146.86,74.1 143.53,74.1 arc(143.28,74.03) 143.1,73.85 143.09,73.85 arc(142.91,73.67) 142.66,73.6 arc(142.41,73.53) 142.23,73.35 142.23,73.34 arc(142.04,73.16) 141.8,73.1 arc(141.55,73.17) 141.36,73.35 141.36,73.35 arc(140.93,73.6) 140.5,73.35 140.5,73.34 arc(140.06,73.1) 139.63,73.34 139.63,73.35 arc(139.45,73.53) 139.2,73.6 139.2,73.6 arc(138.95,73.53) 138.77,73.35 138.76,73.34 arc(138.58,73.16) 138.33,73.1 138.33,73.1 arc(138.08,73.03) 137.9,72.85 arc(137.72,72.67) 137.47,72.6 137.46,72.6 arc(137.21,72.67) 137.03,72.85 137.03,72.85 arc(136.6,73.1) 136.17,72.85 arc(135.99,72.67) 135.74,72.6 135.73,72.6 arc(135.48,72.67) 135.3,72.85 arc(135.12,73.03) 134.87,73.1 134.87,73.1 arc(134.62,73.03) 134.44,72.85 arc(134.26,72.67) 134.01,72.6 134,72.6 arc(133.74,72.52) 133.55,72.32 133.53,72.18 arc(133.41,71.95) 133.2,71.81 133.05,71.81 arc(132.82,71.75) 132.66,71.58 arc(132.49,71.41) 132.26,71.35 132.26,71.35 arc(132.03,71.41) 131.86,71.58 arc(131.69,71.75) 131.46,71.81 arc(131.23,71.87) 131.07,72.04 131.06,72.04 arc(130.89,72.21) 130.66,72.27 130.64,72.21 130.47,72.21 130.34,72.08 130.19,71.83 130.02,71.73 129.74,71.73 129.53,71.61 129.4,71.38 129.21,71.27 128.94,71.27 128.74,71.15 128.63,70.97 arc(128.54,70.88) 128.43,70.85 128.15,70.85 arc(128.11,70.84) 128.07,70.82 127.96,70.77 arc(127.93,70.74) 127.9,70.7 127.79,70.51 arc(127.76,70.48) 127.72,70.47 127.17,70.47 126.84,70.8 126.52,70.8 126.19,70.47 124.12,70.47 123.7,70.89 arc(123.66,70.91) 123.62,70.92 123.31,70.92 arc(123.27,70.91) 123.23,70.89 122.84,70.49 arc(122.8,70.47) 122.76,70.46 122.52,70.46 arc(122.42,70.44) 122.34,70.39 122.02,70.06 arc(121.98,70.03) 121.94,70.03 121.62,70.03 arc(121.58,70.03) 121.54,70.06 121.26,70.34 120.95,70.34 120.7,70.09 120.17,70.09 120.07,70.19 119.91,70.19 arc(119.9,70.19) 119.89,70.2 119.67,70.41 arc(119.66,70.42) 119.65,70.42 119.37,70.42 arc(119.36,70.42) 119.34,70.41 119.13,70.2 arc(119.12,70.19) 119.11,70.19 119.03,70.19 118.85,70.01 118.58,70.01 arc(118.54,70.02) 118.5,70.04 118.14,70.41 arc(118.1,70.44) 118.06,70.44 117.84,70.44 arc(117.79,70.44) 117.76,70.41 117.38,70.04 arc(117.35,70.01) 117.3,70 116.95,70 116.53,70.43 116.17,70.43 arc(116,70.49) 115.89,70.62 arc(115.76,70.78) 115.56,70.85 arc(115.45,70.89) 115.34,70.95 115.19,71.08 arc(115.03,71.2) 114.86,71.28 114.83,71.3 arc(114.57,71.29) 114.4,71.09 arc(114.26,70.92) 114.05,70.87 113.84,70.89 arc(113.63,70.96) 113.48,71.13 arc(113.29,71.33) 113.01,71.34 arc(112.92,71.29) 112.84,71.22 112.68,71.02 arc(112.45,70.84) 112.17,70.77 112.07,70.77 111.73,70.43 111.37,70.43 111.02,70.77 110.47,70.77 110.13,70.43 109.77,70.43 109.3,70.9 109,70.9 108.53,70.43 108.17,70.43 107.7,70.9 107.33,70.9 106.95,71.28 106.6,71.28 106.22,70.9 105.8,70.9 105.17,70.26 v1(105.17,69.97)
  BOTTOM w0.149: R854.1 244.74,49.35 v1(245.24,49.86)
