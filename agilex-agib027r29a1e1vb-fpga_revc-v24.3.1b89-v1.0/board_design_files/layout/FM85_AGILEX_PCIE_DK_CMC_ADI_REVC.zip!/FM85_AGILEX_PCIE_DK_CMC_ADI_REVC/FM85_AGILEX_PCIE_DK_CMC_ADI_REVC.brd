# Allegro board FM85_AGILEX_PCIE_DK_CMC_ADI_REVC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
REFCLK_FGT12ACH5_P: length 75.6
  TOP w0.102: C447.2 62.08,21.61 62.29,21.61 v2(62.54,21.86)
  L03_SIG1 w0.079: v1(96.69,66.64) 96.96,66.49 arc(96.99,66.44) 96.98,66.38 96.93,66.28 arc(96.87,66.08) 96.93,65.88 97,65.76 arc(97.23,65.55) 97.52,65.47 97.63,65.47 arc(97.76,65.44) 97.86,65.36 97.9,65.32 arc(97.95,65.2) 97.94,65.08 97.87,64.88 arc(97.83,64.64) 97.91,64.41 97.98,64.29 arc(98.02,64.15) 97.98,64.01 97.85,63.75 arc(97.81,63.53) 97.89,63.33 97.92,63.3 arc(97.96,63.2) 97.95,63.09 97.81,62.76 arc(97.77,62.54) 97.86,62.33 97.89,62.28 arc(97.93,62.2) 97.91,62.12 97.81,61.89 arc(97.78,61.6) 97.9,61.33 97.94,61.27 arc(97.99,61.17) 97.97,61.05 97.85,60.85 arc(97.8,60.64) 97.84,60.42 97.98,60.13 arc(98,60.05) 97.97,59.98 97.91,59.88 arc(97.84,59.65) 97.9,59.42 97.99,59.27 arc(98.02,59.14) 97.99,59.01 97.9,58.85 arc(97.79,58.74) 97.65,58.7 97.51,58.7 arc(97.32,58.66) 97.15,58.55 96.97,58.37 arc(96.83,58.28) 96.67,58.25 96.57,58.25 arc(96.31,58.18) 96.12,57.99 96.05,57.87 arc(95.96,57.78) 95.83,57.75 95.81,57.75 arc(95.74,57.76) 95.69,57.8 95.36,58.13 arc(95.22,58.22) 95.06,58.25 94.89,58.25 arc(94.65,58.19) 94.48,58.01 94.4,57.88 arc(94.31,57.79) 94.18,57.75 94.02,57.75 arc(93.9,57.79) 93.8,57.88 93.73,58.01 arc(93.55,58.19) 93.31,58.25 93.16,58.25 arc(92.92,58.19) 92.74,58.01 92.66,57.88 arc(92.57,57.79) 92.44,57.75 92.29,57.75 arc(92.16,57.79) 92.07,57.88 91.99,58.01 arc(91.81,58.19) 91.57,58.25 91.46,58.25 arc(91.23,58.19) 91.06,58.02 90.97,57.87 arc(90.89,57.78) 90.77,57.75 90.55,57.75 arc(90.42,57.79) 90.33,57.88 90.25,58.01 arc(90.08,58.19) 89.84,58.25 89.74,58.25 arc(89.51,58.21) 89.32,58.08 89.19,57.94 arc(88.96,57.79) 88.7,57.74 88.16,57.74 88.02,57.88 87.82,57.88 87.69,57.74 87.49,57.74 87.35,57.88 87.16,57.88 87.02,57.74 86.62,57.74 84.94,57.04 84.48,57.04 84.32,57.2 84.14,57.2 83.99,57.04 83.65,57.04 arc(82.05,56.73) 80.7,55.82 78.39,53.51 arc(77.22,52.73) 75.84,52.45 71.75,52.45 arc(70.7,52.24) 69.81,51.65 66.78,48.62 arc(66.23,47.79) 66.03,46.82 66.03,46.58 arc(65.96,46.19) 65.73,45.85 65.43,45.56 arc(63.68,42.94) 63.07,39.85 63.07,32.35 arc(63.06,32.17) 63.03,32 arc(62.97,31.76) 62.88,31.54 arc(62.77,31.23) 62.73,30.9 62.73,23.75 arc(62.79,23.43) 62.94,23.15 arc(63.02,23) 63.05,22.84 63.05,21.75 arc(63.01,21.65) 62.91,21.61 62.83,21.61 arc(62.8,21.61) 62.77,21.63 v2(62.54,21.86)
REFCLK_FGT12ACH6_N: length 68.6
  L03_SIG1 w0.079: v1(97.56,61.14) 97.31,61 arc(97.23,60.99) 97.17,61.03 97.12,61.12 arc(96.99,61.25) 96.8,61.3 arc(96.44,61.21) 96.18,60.95 arc(96.14,60.88) 96.12,60.8 arc(96.11,60.76) 96.1,60.73 arc(96.09,60.68) 96.08,60.62 96.08,60.62 arc(96.12,60.43) 96.21,60.26 arc(96.23,60.23) 96.24,60.19 arc(96.25,60.12) 96.24,60.05 arc(96.23,60.02) 96.2,59.98 96.11,59.89 arc(96,59.62) 96.11,59.35 96.23,59.24 arc(96.28,59.11) 96.23,58.99 96.1,58.87 arc(96.01,58.8) 95.89,58.78 95.8,58.78 arc(95.71,58.8) 95.64,58.85 95.36,59.13 arc(95.22,59.22) 95.06,59.25 94.89,59.25 arc(94.65,59.19) 94.48,59.01 94.4,58.88 arc(94.31,58.79) 94.18,58.75 94.02,58.75 arc(93.9,58.79) 93.8,58.88 93.73,59.01 arc(93.55,59.19) 93.31,59.25 93.16,59.25 arc(92.92,59.19) 92.74,59.01 92.66,58.88 arc(92.57,58.79) 92.44,58.75 92.29,58.75 arc(92.16,58.79) 92.07,58.88 91.99,59.01 arc(91.81,59.19) 91.57,59.25 91.46,59.25 arc(91.23,59.19) 91.06,59.02 90.97,58.87 arc(90.89,58.78) 90.77,58.75 90.55,58.75 arc(90.42,58.79) 90.33,58.88 90.25,59.01 arc(90.08,59.19) 89.84,59.25 89.74,59.25 arc(89.51,59.21) 89.32,59.08 89.15,58.91 arc(88.97,58.78) 88.75,58.74 88.24,58.74 arc(87.89,58.81) 87.58,59.01 arc(87.28,59.22) 86.93,59.29 84.41,59.29 arc(83.62,59.13) 82.94,58.68 82.26,57.99 arc(82.12,57.87) 81.96,57.76 arc(81.9,57.72) 81.83,57.68 arc(81.18,57.55) 80.62,57.18 78.11,54.67 arc(77.3,54.13) 76.35,53.94 69.53,53.94 arc(68.94,53.72) 68.62,53.18 arc(68.54,52.95) 68.4,52.76 66.95,51.31 arc(66.32,50.86) 65.59,50.62 arc(64.72,50.33) 63.98,49.79 62.25,48.06 arc(62.15,47.96) 62.06,47.85 arc(61.56,47.37) 60.96,47.03 arc(60.85,46.97) 60.75,46.89 60.62,46.76 arc(60.39,46.4) 60.3,45.98 60.3,44 arc(60.28,43.8) 60.23,43.61 arc(60.17,43.37) 60.14,43.12 arc(60.14,43.11) 60.14,43.11 60.14,42.9 arc(60.15,42.74) 60.18,42.58 arc(60.21,42.51) 60.25,42.44 60.29,42.37 arc(60.33,42.32) 60.37,42.27 60.56,42.09 arc(60.59,42.06) 60.62,42.04 61.93,41.23 arc(62.07,41.09) 62.12,40.9 62.12,32.72 arc(62.12,32.68) 62.11,32.65 61.92,32.24 arc(61.53,31.8) 60.96,31.63 60.34,31.63 arc(59.91,31.55) 59.54,31.3 59.01,30.78 arc(58.98,30.75) 58.94,30.75 56.77,30.75 arc(56.7,30.76) 56.65,30.8 56.54,30.91 arc(56.5,30.96) 56.49,31.02 56.49,31.25 arc(56.51,31.31) 56.57,31.33 v2(56.96,31.33)
REFCLK_FGT12ACH6_P: length 68.7
  L03_SIG1 w0.079: v2(55.82,31.33) 56.18,31.33 arc(56.24,31.31) 56.26,31.25 56.26,31.02 arc(56.29,30.87) 56.38,30.75 56.49,30.63 arc(56.62,30.55) 56.77,30.52 58.94,30.52 arc(59.07,30.54) 59.17,30.61 59.7,31.14 arc(59.99,31.34) 60.34,31.4 60.96,31.4 arc(61.65,31.61) 62.12,32.14 62.31,32.55 arc(62.34,32.64) 62.35,32.72 62.35,40.9 arc(62.27,41.2) 62.05,41.43 60.74,42.24 arc(60.73,42.24) 60.72,42.25 60.53,42.44 arc(60.51,42.47) 60.48,42.5 60.44,42.57 arc(60.42,42.6) 60.4,42.64 arc(60.38,42.77) 60.37,42.9 60.37,43.11 arc(60.39,43.32) 60.45,43.53 arc(60.51,43.76) 60.53,44 60.53,45.98 arc(60.6,46.31) 60.79,46.6 60.92,46.73 arc(60.98,46.78) 61.05,46.82 arc(61.7,47.19) 62.24,47.7 arc(62.32,47.8) 62.41,47.9 64.14,49.63 arc(64.83,50.12) 65.63,50.39 arc(66.43,50.65) 67.11,51.15 68.56,52.6 arc(68.74,52.85) 68.84,53.13 arc(69.08,53.55) 69.53,53.71 76.35,53.71 arc(77.39,53.92) 78.27,54.51 80.79,57.02 arc(81.22,57.32) 81.74,57.45 arc(81.92,57.49) 82.08,57.56 arc(82.26,57.69) 82.42,57.83 83.11,58.52 arc(83.7,58.92) 84.41,59.06 84.8,59.06 84.89,58.97 85.13,58.97 85.22,59.06 86.93,59.06 arc(87.19,59) 87.42,58.85 arc(87.8,58.6) 88.24,58.51 88.75,58.51 arc(89.05,58.57) 89.31,58.75 89.48,58.92 arc(89.6,59) 89.74,59.02 89.84,59.02 arc(89.96,58.99) 90.06,58.9 90.13,58.76 arc(90.31,58.59) 90.55,58.52 90.77,58.52 arc(91,58.59) 91.17,58.76 91.26,58.91 arc(91.34,58.99) 91.46,59.02 91.57,59.02 arc(91.7,58.99) 91.79,58.9 91.87,58.76 arc(92.05,58.59) 92.29,58.52 92.44,58.52 arc(92.68,58.59) 92.86,58.76 92.94,58.9 arc(93.03,58.99) 93.16,59.02 93.31,59.02 arc(93.44,58.99) 93.53,58.9 93.61,58.76 arc(93.78,58.59) 94.02,58.52 94.18,58.52 arc(94.42,58.59) 94.6,58.76 94.67,58.9 arc(94.77,58.99) 94.89,59.02 95.06,59.02 arc(95.13,59.01) 95.19,58.97 95.48,58.69 arc(95.63,58.58) 95.8,58.55 95.89,58.55 arc(96.09,58.59) 96.27,58.7 96.39,58.83 arc(96.51,59.11) 96.39,59.4 96.27,59.52 arc(96.23,59.62) 96.27,59.73 96.37,59.82 arc(96.43,59.9) 96.46,60 arc(96.48,60.12) 96.47,60.24 arc(96.44,60.33) 96.39,60.4 arc(96.33,60.51) 96.31,60.62 arc(96.31,60.65) 96.32,60.68 arc(96.33,60.71) 96.34,60.74 arc(96.35,60.78) 96.38,60.83 arc(96.55,61.01) 96.8,61.08 arc(96.87,61.06) 96.93,61 96.97,60.92 arc(96.98,60.84) 96.94,60.78 v1(96.69,60.64)
REFCLK_FM41_14C_PCIE_N: length 49.9
  TOP w0.116: R6322.1 60.74,44.47 59.9,44.47 arc(59.89,44.46) v1(59.88,44.46)
  L07_SIG3 w0.09: v1(99.59,55.71) 99.8,55.71 arc(99.82,55.71) 99.83,55.71 arc(99.89,55.81) 99.9,55.92 99.88,55.94 arc(99.75,56.04) 99.59,56.08 99.59,56.08 arc(99.59,56.08) 99.59,56.08 arc(99.5,56.07) 99.42,56.04 arc(99.41,56.04) 99.41,56.03 arc(99.3,55.95) 99.24,55.83 arc(99.22,55.79) 99.2,55.76 99.2,55.75 arc(99.2,55.75) 99.2,55.75 arc(99.19,55.72) 99.18,55.68 arc(99.1,55.5) 98.97,55.34 98.92,55.29 arc(98.45,55.09) 97.98,55.29 97.89,55.38 arc(97.75,55.47) 97.59,55.51 arc(97.47,55.5) 97.36,55.46 arc(97.31,55.42) 97.26,55.38 97.09,55.21 arc(97.05,55.18) 97.01,55.16 arc(97,55.15) 97,55.15 arc(96.52,55.08) 96.16,55.4 arc(96.1,55.47) 96.01,55.5 95.82,55.5 arc(95.67,55.47) 95.55,55.39 95.4,55.24 arc(95.21,55.11) 94.98,55.07 arc(94.73,55.12) 94.52,55.26 94.36,55.42 arc(94.29,55.46) 94.21,55.48 94.04,55.48 arc(93.95,55.46) 93.87,55.41 93.57,55.1 arc(93.47,55.04) 93.36,55.02 93.1,55.02 arc(92.82,55.11) 92.64,55.34 arc(92.56,55.45) 92.42,55.49 92.25,55.49 arc(92.05,55.43) 91.92,55.26 arc(91.79,55.11) 91.6,55.05 91.37,55.05 arc(91.16,55.12) 91.04,55.32 arc(91.03,55.35) 91.02,55.38 arc(90.95,55.45) 90.86,55.48 90.81,55.48 arc(90.8,55.48) 90.78,55.48 arc(90.77,55.49) 90.75,55.49 arc(90.48,55.48) 90.29,55.3 arc(90.24,55.23) 90.18,55.16 arc(90.02,55.07) 89.83,55.03 89.69,55.03 arc(89.49,55.08) 89.34,55.24 89.34,55.24 arc(89.33,55.27) 89.32,55.29 arc(89.31,55.33) 89.3,55.36 arc(89.29,55.37) 89.28,55.38 89.28,55.39 arc(89.25,55.42) 89.22,55.45 arc(89.19,55.46) 89.17,55.46 arc(89.01,55.48) 88.86,55.47 arc(88.8,55.47) 88.74,55.47 87.25,55.47 arc(87.12,55.48) 86.98,55.51 arc(86.85,55.54) 86.72,55.51 arc(86.59,55.48) 86.45,55.47 85.43,55.47 arc(85.3,55.48) 85.16,55.51 arc(85.03,55.54) 84.9,55.51 arc(84.76,55.48) 84.63,55.47 84.43,55.47 arc(84.29,55.48) 84.16,55.51 arc(84.02,55.54) 83.89,55.51 arc(83.75,55.48) 83.61,55.47 83.3,55.47 arc(83.16,55.48) 83.03,55.51 arc(82.89,55.54) 82.76,55.51 arc(82.63,55.48) 82.49,55.47 arc(81.32,55.23) 80.32,54.57 77.2,51.44 arc(76.46,50.95) 75.59,50.78 64.54,50.78 arc(63.7,50.61) 63,50.14 60.06,47.2 arc(59.7,46.66) 59.57,46.03 59.57,44.91 arc(59.57,44.9) 59.57,44.9 59.57,44.81 59.57,44.62 arc(59.58,44.58) 59.6,44.55 arc(59.7,44.48) 59.83,44.46 v1(59.88,44.46)
REFCLK_FM41_14C_PCIE_P: length 50.1
  TOP w0.149: R6323.1 59.05,44.47 v1(59.05,44.46)
  L07_SIG3 w0.09: v1(59.05,44.46) 59.34,44.75 arc(59.34,44.75) 59.35,44.76 arc(59.36,44.78) 59.37,44.81 59.37,44.9 arc(59.37,44.9) 59.37,44.91 59.37,46.03 arc(59.51,46.74) 59.92,47.35 62.85,50.28 arc(63.63,50.8) 64.54,50.98 75.59,50.98 arc(76.38,51.14) 77.05,51.59 80.18,54.71 arc(81.24,55.42) 82.49,55.67 arc(82.59,55.68) 82.69,55.71 arc(82.89,55.74) 83.1,55.71 arc(83.2,55.68) 83.3,55.67 83.61,55.67 arc(83.72,55.68) 83.82,55.71 arc(84.02,55.74) 84.23,55.71 arc(84.33,55.68) 84.43,55.67 84.63,55.67 arc(84.73,55.68) 84.83,55.7 arc(85.03,55.74) 85.23,55.7 arc(85.33,55.68) 85.43,55.67 86.45,55.67 arc(86.55,55.68) 86.65,55.7 arc(86.85,55.74) 87.05,55.7 arc(87.15,55.68) 87.25,55.67 88.74,55.67 arc(88.79,55.67) 88.83,55.67 arc(89.02,55.68) 89.2,55.66 arc(89.26,55.65) 89.31,55.63 arc(89.4,55.57) 89.46,55.48 89.46,55.48 arc(89.47,55.47) 89.47,55.47 arc(89.5,55.4) 89.52,55.34 arc(89.52,55.34) 89.52,55.33 89.53,55.33 arc(89.59,55.25) 89.69,55.23 89.82,55.23 arc(89.94,55.26) 90.05,55.32 arc(90.08,55.35) 90.11,55.39 arc(90.15,55.47) 90.2,55.53 arc(90.4,55.67) 90.63,55.72 arc(90.72,55.71) 90.81,55.69 arc(90.81,55.69) 90.81,55.69 arc(90.83,55.68) 90.84,55.68 90.86,55.68 arc(91.06,55.63) 91.2,55.48 arc(91.22,55.42) 91.24,55.36 arc(91.29,55.28) 91.37,55.25 91.6,55.25 arc(91.68,55.27) 91.73,55.34 arc(91.94,55.6) 92.25,55.7 92.42,55.7 arc(92.67,55.62) 92.83,55.41 arc(92.94,55.27) 93.1,55.22 93.36,55.22 arc(93.39,55.23) 93.42,55.25 93.73,55.55 arc(93.87,55.65) 94.04,55.68 94.21,55.68 arc(94.37,55.65) 94.5,55.56 94.66,55.4 arc(94.96,55.28) 95.26,55.39 95.41,55.53 arc(95.6,55.66) 95.82,55.7 96.01,55.7 arc(96.21,55.64) 96.35,55.48 arc(96.58,55.28) 96.89,55.32 arc(96.9,55.33) 96.92,55.34 arc(96.93,55.35) 96.95,55.36 97.11,55.52 arc(97.18,55.58) 97.26,55.63 arc(97.43,55.7) 97.61,55.71 arc(97.84,55.66) 98.03,55.52 98.12,55.43 arc(98.45,55.3) 98.78,55.43 98.83,55.48 arc(98.92,55.6) 98.98,55.74 arc(99,55.79) 99.02,55.84 arc(99.02,55.84) 99.02,55.85 99.02,55.85 arc(99.03,55.87) 99.04,55.89 arc(99.15,56.08) 99.31,56.21 arc(99.32,56.22) 99.32,56.22 arc(99.45,56.27) 99.59,56.28 arc(99.59,56.28) 99.59,56.28 arc(99.84,56.22) 100.04,56.06 arc(100.25,56) v1(100.39,56.17)
REFCLK_FM41_15C_CXL_N: length 91.4
  L03_SIG1 w0.085: v1(133.08,68.56) 133.08,68.85 133.17,68.93 135.14,68.93 135.51,68.56 135.88,68.56 136.38,68.06 136.74,68.06 137.24,67.56 137.52,67.56 138.12,66.96 138.48,66.96 139.01,66.43 139.34,66.43 139.81,65.96 140.28,65.96 140.78,66.46 141.08,66.46 141.58,65.96 142.05,65.96 142.52,66.43 142.8,66.43 143.3,65.93 150.8,65.93 151.16,66.29 166.1,66.29 168.2,68.39 168.2,72.67 172.92,77.4 174.89,77.4 177.5,80 182.11,80 184.04,78.08 189.57,78.08 190,78.51 190.74,78.51 191.3,77.94 193.44,77.94 193.66,77.72 193.66,73.82 197.18,70.3 202.81,70.3 204.89,68.22 204.89,67.82 205.05,67.67 205.32,67.67 v1(205.64,67.35)
REFCLK_FM41_15C_CXL_P: length 92.5
  TOP w0.116: R6316.1 205.61,68.15 v1(205.63,68.14)
  L03_SIG1 w0.085: v1(133.08,69.48) 133.09,69.47 133.09,69.21 133.16,69.14 135.22,69.14 135.6,68.76 135.96,68.76 136.46,68.26 136.83,68.26 137.33,67.76 137.6,67.76 138.2,67.17 138.57,67.17 139.1,66.64 139.42,66.64 139.89,66.17 140.2,66.17 140.7,66.67 141.17,66.67 141.67,66.17 141.97,66.17 142.44,66.64 142.89,66.64 143.39,66.14 150.72,66.14 151.07,66.49 166.01,66.49 167.99,68.47 167.99,72.76 172.84,77.6 174.81,77.6 177.41,80.21 182.2,80.21 184.12,78.28 189.48,78.28 189.91,78.71 190.82,78.71 191.39,78.15 193.53,78.15 193.86,77.81 193.86,73.91 197.27,70.5 202.9,70.5 205.1,68.3 205.1,67.91 205.13,67.87 205.35,67.87 v1(205.63,68.14)
REFCLK_PCIE_14C_CH0_N: length 49.1
  L03_SIG1 w0.079: v1(99.59,53.87) 99.59,54.11 arc(99.56,54.16) 99.51,54.19 99.37,54.19 arc(99.2,54.22) 99.06,54.31 98.85,54.52 arc(98.79,54.63) 98.75,54.75 arc(98.75,54.75) 98.75,54.76 arc(98.73,54.85) 98.68,54.93 arc(98.57,55) 98.45,55.02 98.36,55.02 arc(98.11,55.09) 97.94,55.26 97.87,55.38 arc(97.77,55.48) 97.63,55.52 97.52,55.52 arc(97.25,55.59) 97.04,55.8 96.99,55.89 arc(96.99,55.89) 96.99,55.9 arc(96.9,55.99) 96.77,56.02 96.57,56.02 arc(96.42,55.98) 96.32,55.87 96.25,55.76 arc(96.08,55.58) 95.83,55.52 95.81,55.52 arc(95.66,55.55) 95.52,55.64 95.19,55.97 arc(95.13,56.01) 95.06,56.02 94.89,56.02 arc(94.77,55.99) 94.67,55.9 94.6,55.76 arc(94.42,55.59) 94.18,55.52 94.02,55.52 arc(93.78,55.59) 93.61,55.76 93.53,55.9 arc(93.44,55.99) 93.31,56.02 93.16,56.02 arc(93.03,55.99) 92.94,55.9 92.86,55.76 arc(92.68,55.59) 92.44,55.52 92.29,55.52 arc(92.05,55.59) 91.87,55.76 91.79,55.9 arc(91.7,55.99) 91.57,56.02 91.42,56.02 arc(91.29,55.99) 91.2,55.9 91.12,55.76 arc(90.95,55.59) 90.71,55.52 90.55,55.52 arc(90.31,55.59) 90.13,55.76 90.06,55.9 arc(89.96,55.99) 89.84,56.02 89.74,56.02 arc(89.6,56) 89.48,55.92 89.31,55.74 arc(89.05,55.57) 88.75,55.51 83.11,55.51 arc(82.16,55.32) 81.35,54.78 78.95,52.38 arc(77.69,51.54) 76.2,51.24 74.48,51.24 arc(71.99,50.75) 69.88,49.34 67.68,47.13 arc(67.48,46.83) 67.41,46.48 arc(67.28,45.84) 66.92,45.3 66.52,44.9 66,44.38 arc(64.91,42.75) 64.53,40.82 64.53,39.44 arc(64.54,39.38) 64.57,39.32 64.99,38.9 arc(65.08,38.78) 65.11,38.63 65.11,38.22 arc(65.07,38.02) 64.95,37.85 64.95,37.84 arc(64.82,37.76) 64.67,37.73 64.59,37.73 arc(64.44,37.67) 64.38,37.52 v2(64.38,37.37)
REFCLK_PCIE_14C_CH0_P: length 49.8
  L03_SIG1 w0.079: v1(100.39,54.33) 99.86,54.33 99.65,54.38 arc(99.58,54.41) 99.51,54.41 99.37,54.41 arc(99.29,54.43) 99.22,54.47 99.02,54.67 arc(99,54.72) 98.98,54.78 arc(98.94,54.94) 98.85,55.08 arc(98.66,55.21) 98.45,55.25 98.36,55.25 arc(98.23,55.29) 98.14,55.38 98.07,55.5 arc(97.88,55.68) 97.63,55.75 97.52,55.75 arc(97.36,55.79) 97.24,55.91 97.19,56 arc(97.19,56.01) 97.18,56.01 arc(97.01,56.18) 96.77,56.25 96.57,56.25 arc(96.31,56.18) 96.12,55.99 96.05,55.87 arc(95.96,55.78) 95.83,55.75 95.81,55.75 arc(95.74,55.76) 95.69,55.8 95.36,56.13 arc(95.22,56.22) 95.06,56.25 94.89,56.25 arc(94.65,56.19) 94.48,56.01 94.4,55.88 arc(94.31,55.79) 94.18,55.75 94.02,55.75 arc(93.9,55.79) 93.8,55.88 93.73,56.01 arc(93.55,56.19) 93.31,56.25 93.16,56.25 arc(92.92,56.19) 92.74,56.01 92.66,55.88 arc(92.57,55.79) 92.44,55.75 92.29,55.75 arc(92.16,55.79) 92.07,55.88 91.99,56.01 arc(91.81,56.19) 91.57,56.25 91.42,56.25 arc(91.18,56.19) 91,56.01 90.93,55.88 arc(90.83,55.79) 90.71,55.75 90.55,55.75 arc(90.42,55.79) 90.33,55.88 90.25,56.01 arc(90.08,56.19) 89.84,56.25 89.74,56.25 arc(89.51,56.21) 89.32,56.08 89.15,55.91 arc(88.97,55.78) 88.75,55.74 83.11,55.74 arc(82.07,55.53) 81.19,54.95 78.79,52.54 arc(77.6,51.75) 76.2,51.47 74.48,51.47 arc(71.9,50.96) 69.72,49.5 67.52,47.29 arc(67.27,46.92) 67.18,46.48 arc(67.07,45.93) 66.76,45.46 65.84,44.54 arc(64.7,42.83) 64.3,40.82 64.3,39.44 arc(64.33,39.29) 64.41,39.16 64.83,38.74 arc(64.87,38.69) 64.88,38.63 64.88,38.22 arc(64.86,38.11) 64.79,38.01 64.79,38.01 arc(64.73,37.97) 64.67,37.96 64.56,37.96 arc(64.43,38.01) 64.38,38.13 v2(64.38,38.38)
REFCLK_PCIE_14C_CH1_N: length 46.8
  L03_SIG1 w0.079: v1(99.59,51.11) 99.71,51.55 arc(99.71,51.58) 99.7,51.61 99.67,51.66 arc(99.66,51.68) 99.64,51.69 99.59,51.75 arc(99.54,51.81) 99.5,51.88 arc(99.46,51.96) 99.43,52.04 arc(99.38,52.13) 99.32,52.21 99.02,52.51 arc(98.83,52.79) 98.76,53.13 98.76,53.66 arc(98.74,53.77) 98.68,53.86 98.62,53.91 arc(98.5,53.99) 98.36,54.02 arc(98.12,54.09) 97.94,54.26 97.91,54.31 arc(97.8,54.43) 97.64,54.47 97.49,54.47 arc(97.22,54.54) 97.02,54.74 96.98,54.81 arc(96.86,54.93) 96.71,54.97 96.65,54.97 arc(96.49,54.93) 96.37,54.81 96.34,54.76 arc(96.17,54.59) 95.94,54.52 95.85,54.52 arc(95.64,54.57) 95.46,54.68 95.21,54.93 arc(95.11,55) 94.99,55.02 94.93,55.02 arc(94.77,54.98) 94.66,54.87 94.6,54.76 arc(94.42,54.59) 94.18,54.52 94.02,54.52 arc(93.78,54.59) 93.61,54.76 93.53,54.9 arc(93.44,54.99) 93.31,55.02 93.16,55.02 arc(93.03,54.99) 92.94,54.9 92.86,54.76 arc(92.68,54.59) 92.44,54.52 92.29,54.52 arc(92.05,54.59) 91.87,54.76 91.79,54.9 arc(91.7,54.99) 91.57,55.02 91.42,55.02 arc(91.29,54.99) 91.2,54.9 91.12,54.76 arc(90.95,54.59) 90.71,54.52 90.55,54.52 arc(90.31,54.59) 90.13,54.76 90.06,54.9 arc(89.96,54.99) 89.84,55.02 89.71,55.02 arc(89.6,55) 89.5,54.94 89.27,54.71 arc(89.07,54.57) 88.82,54.52 87.76,54.52 87.61,54.37 87.36,54.37 87.2,54.52 86.95,54.52 86.8,54.37 86.54,54.37 86.39,54.52 83.52,54.52 arc(82.67,54.35) 81.96,53.87 80.49,52.41 79.98,51.9 arc(79.95,51.85) 79.94,51.8 arc(79.87,51.48) 79.69,51.2 79.61,51.12 79.29,50.8 arc(78.62,50.35) 77.83,50.2 75.86,50.2 arc(73.92,49.81) 72.28,48.72 71.29,47.73 arc(70.86,47.44) 70.36,47.34 arc(69.76,47.22) 69.24,46.88 68.71,46.34 arc(68.67,46.29) 68.66,46.23 arc(68.56,45.74) 68.29,45.33 66.75,43.79 arc(66.09,42.81) 65.86,41.65 65.86,40.49 arc(65.81,40.23) 65.67,40.01 65.66,40 arc(65.53,39.92) 65.38,39.89 65.3,39.89 arc(65.16,39.83) 65.09,39.68 v2(65.09,39.53)
REFCLK_PCIE_14C_CH1_P: length 46.9
  L03_SIG1 w0.079: v2(65.09,40.54) 65.09,40.29 arc(65.15,40.17) 65.27,40.11 65.38,40.11 arc(65.44,40.13) 65.5,40.17 65.5,40.17 arc(65.6,40.31) 65.64,40.49 65.64,41.58 65.64,41.65 arc(65.88,42.9) 66.59,43.95 68.12,45.49 arc(68.35,45.83) 68.43,46.23 arc(68.46,46.38) 68.54,46.5 69.08,47.04 arc(69.67,47.43) 70.36,47.57 arc(70.78,47.65) 71.12,47.89 72.12,48.88 arc(73.83,50.02) 75.86,50.43 77.83,50.43 arc(78.53,50.57) 79.13,50.96 79.53,51.36 arc(79.66,51.56) 79.71,51.8 arc(79.74,51.94) 79.82,52.06 80.23,52.47 81.79,54.04 arc(82.58,54.56) 83.52,54.75 88.82,54.75 arc(88.98,54.78) 89.11,54.87 89.34,55.1 arc(89.51,55.21) 89.71,55.25 89.84,55.25 arc(90.08,55.19) 90.25,55.01 90.33,54.88 arc(90.42,54.79) 90.55,54.75 90.71,54.75 arc(90.83,54.79) 90.93,54.88 91,55.01 arc(91.18,55.19) 91.42,55.25 91.57,55.25 arc(91.81,55.19) 91.99,55.01 92.07,54.88 arc(92.16,54.79) 92.29,54.75 92.44,54.75 arc(92.57,54.79) 92.66,54.88 92.74,55.01 arc(92.92,55.19) 93.16,55.25 93.31,55.25 arc(93.55,55.19) 93.73,55.01 93.8,54.88 arc(93.9,54.79) 94.02,54.75 94.18,54.75 arc(94.31,54.79) 94.4,54.88 94.46,54.98 arc(94.66,55.18) 94.93,55.25 94.99,55.25 arc(95.2,55.21) 95.37,55.1 95.62,54.85 arc(95.72,54.78) 95.85,54.75 95.94,54.75 arc(96.06,54.78) 96.14,54.87 96.17,54.92 arc(96.38,55.12) 96.65,55.2 96.71,55.2 arc(96.98,55.12) 97.18,54.92 97.22,54.85 arc(97.33,54.74) 97.49,54.7 97.64,54.7 arc(97.91,54.63) 98.11,54.43 98.14,54.38 arc(98.23,54.29) 98.36,54.25 arc(98.59,54.2) 98.79,54.07 98.84,54.02 arc(98.95,53.85) 98.99,53.66 98.99,53.13 arc(99.04,52.88) 99.18,52.67 99.48,52.37 arc(99.58,52.25) 99.64,52.12 arc(99.67,52.05) 99.7,51.97 arc(99.72,51.94) 99.75,51.91 99.81,51.85 arc(99.84,51.81) 99.87,51.77 arc(99.92,51.71) 100,51.67 v1(100.38,51.57)
REFCLK_PCIE_EP_EDGE_N: length 36.6
  L03_SIG1 w0.079: v2(56.9,32.78) 56.9,32.78 56.78,32.78 arc(56.59,32.7) 56.5,32.5 56.5,32.43 arc(56.39,32.16) 56.12,32.05 54.95,32.05 arc(54.91,32.05) 54.87,32.04 arc(54.75,31.98) 54.64,31.9 54.52,31.78 arc(54.49,31.73) 54.48,31.67 54.48,29.09 arc(54.49,29.03) 54.52,28.98 54.88,28.62 arc(54.93,28.59) 55,28.57 58.3,28.57 arc(58.45,28.54) 58.58,28.46 60.95,26.09 arc(61.03,25.96) 61.06,25.81 61.06,18.24 arc(61.08,18.17) 61.11,18.12 61.46,17.78 arc(61.54,17.65) 61.57,17.5 61.57,14.06 arc(61.54,13.91) 61.46,13.79 60.59,12.92 arc(60.55,12.87) 60.54,12.8 60.54,12.58 arc(60.57,12.43) 60.66,12.3 v1(60.81,12.15)
  BOTTOM w0.102: v1(60.81,12.15) 60.53,11.87 60.53,9.3 60.08,8.84 60.08,7.42 60.28,7.22 60.28,6.49 60.65,6.11 J5.A14
REFCLK_PCIE_EP_EDGE_P: length 36.6
  L03_SIG1 w0.079: v1(60.05,12.15) 60.2,12.3 arc(60.28,12.43) 60.31,12.58 60.31,12.8 arc(60.34,12.95) 60.43,13.08 61.29,13.95 arc(61.33,14) 61.34,14.06 61.34,17.5 arc(61.33,17.56) 61.29,17.61 60.95,17.96 arc(60.86,18.09) 60.83,18.24 60.83,25.81 arc(60.82,25.87) 60.79,25.93 58.42,28.3 arc(58.37,28.33) 58.3,28.34 55,28.34 arc(54.85,28.37) 54.72,28.46 54.36,28.82 arc(54.28,28.94) 54.25,29.09 54.25,31.67 arc(54.28,31.82) 54.36,31.94 54.48,32.06 arc(54.63,32.18) 54.81,32.26 arc(54.88,32.27) 54.95,32.28 56.12,32.28 arc(56.23,32.32) 56.28,32.43 56.28,32.5 arc(56.19,32.7) 56,32.78 55.89,32.78 v2(55.88,32.78)
  BOTTOM w0.102: J5.A13 59.65,6.13 60.05,6.52 60.05,7.13 59.85,7.32 59.85,8.94 60.3,9.39 60.3,11.87 60.19,11.98 60.19,12 v1(60.05,12.15)
REFCLK_PCIE_EP_N: length 15.5
  L03_SIG1 w0.079: v2(60.59,32.53) 60.27,32.53 arc(60.22,32.55) 60.19,32.61 60.19,33.29 arc(60.19,33.34) 60.19,33.39 60.05,33.9 59.11,34.84 58.83,34.95 arc(58.75,34.97) 58.67,34.97 58.57,34.96 arc(58.36,34.93) 58.16,34.87 arc(57.98,34.82) 57.79,34.8 55.71,34.8 arc(55.57,34.82) 55.45,34.87 arc(55.21,34.97) 54.95,35.01 51.57,35.01 arc(50.74,34.84) 50.03,34.37 48.79,33.13 arc(48.7,33.07) 48.58,33.05 48.25,33.05 arc(48.21,33.05) 48.17,33.06 arc(48.11,33.09) 48.06,33.13 arc(48.04,33.16) 48.03,33.19 48.02,33.22 arc(48.06,33.36) 48.19,33.42 v2(48.39,33.42)
REFCLK_PCIE_EP_P: length 15.5
  L03_SIG1 w0.079: v2(47.38,33.42) 47.49,33.42 arc(47.68,33.35) 47.79,33.18 arc(47.79,33.18) 47.79,33.18 47.8,33.18 47.81,33.14 arc(47.84,33.05) 47.89,32.97 arc(47.98,32.9) 48.09,32.85 arc(48.17,32.83) 48.25,32.82 48.58,32.82 arc(48.78,32.86) 48.95,32.97 50.19,34.21 arc(50.82,34.63) 51.57,34.78 54.95,34.78 arc(55.15,34.75) 55.33,34.68 arc(55.52,34.6) 55.71,34.57 57.8,34.57 arc(58.02,34.59) 58.24,34.66 arc(58.41,34.71) 58.59,34.73 58.69,34.74 arc(58.72,34.74) 58.76,34.74 58.98,34.65 59.85,33.78 59.96,33.35 arc(59.96,33.32) 59.96,33.29 59.96,32.61 arc(59.94,32.55) 59.88,32.53 v2(59.57,32.53)
RUN0: length 2.3
  TOP w0.203: v1(174.07,84.57) 173.95,84.7 U120.30
  L07_SIG3 w0.089: v1(174.7,84.75) 174.25,84.75 v1(174.07,84.57)
  BOTTOM w0.254: v1(174.07,84.57) 174.07,84.52 173.82,84.27 C7578.2
RUN1: length 2.8
  TOP w0.203: U121.30 174.03,70.66 174.34,70.35 v1(174.49,70.35)
  TOP w0.254: v1(174.49,70.35) 174.66,70.35 174.91,70.6 R6274.1
  BOTTOM w0.203: C1729.2 174.42,70.28 v1(174.49,70.35)
RUN2: length 2
  TOP w0.149: R6275.1 175.31,56.5 v1(174.53,56.5) 174.21,56.5 174.05,56.66 U125.30
RUN3: length 4.7
  TOP w0.203: U126.30 174.89,41.85 C7582.2 175.27,41.79 v1(175.56,41.5)
  BOTTOM w0.149: R6276.1 175.87,41.67 175.7,41.5 v1(175.56,41.5)
  BOTTOM w0.203: R6276.1 175.05,42.11 R6068.1
SEL_CXL_REFCLK: length 268.4
  L16_SIG6 w0.081: v1(3.3,76.71) 8.03,81.44 8.03,93.23 16.12,101.33 16.12,101.46 16.21,101.55 16.21,102.53 17.4,103.73 19.77,103.73 19.78,103.72 21.3,103.72 24.46,106.89 62.65,106.89 63.96,108.19 71.86,108.19 72.23,108.56 72.82,108.56 73.19,108.19 138.15,108.19 138.24,108.28 153.1,108.28 153.19,108.19 181.29,108.19 181.31,108.2 181.62,108.2 181.63,108.19 200.69,108.19 204.15,104.73 204.15,101.67 203.21,100.74 203.21,99.06 203.96,98.32 203.96,68.54 v1(204.44,68.05)
  BOTTOM w0.149: v1(204.44,68.05) 205.19,68.8 205.78,68.8 206.05,68.53 206.05,66.35 206.82,65.58 206.99,65.58 207,65.6 U25.20 ; SW3.2 v1(3.3,76.71) R281.2
SEL_PCIE_REFCLK: length 92.7
  TOP w0.149: U24.20 61.17,42.6 v1(61.18,42.61)
  L12_SIG4 w0.089: v1(3.25,77.93) 3.65,77.53 14.49,77.53 14.96,77.06 14.97,77.06 15.2,76.83 15.2,76.82 17.31,74.71 17.31,66.09 19.63,63.77 27.94,63.77 28.47,63.24 28.47,59.69 30.32,57.84 30.32,57.26 30.46,57.12 30.46,54.72 29.07,53.34 29.07,51.79 29.59,51.28 29.59,47.59 v1(32.27,44.91)
  L14_SIG5 w0.081: v1(61.18,42.61) 60.25,43.54 arc(60.18,43.62) 60.14,43.72 arc(60.04,43.89) 59.87,43.99 arc(59.78,44.03) 59.7,44.1 59.68,44.11 arc(59.66,44.13) 59.64,44.15 arc(59.55,44.22) 59.48,44.31 arc(59.45,44.37) 59.44,44.44 arc(59.42,44.61) 59.32,44.76 57.59,46.5 arc(57.55,46.52) 57.51,46.53 48.61,46.53 46.37,44.29 44.8,44.29 42.77,46.32 35.52,46.32 34.51,45.32 32.67,45.32 v1(32.27,44.91)
  BOTTOM w0.149: SW3.3 3.3,77.98 v1(3.25,77.93)
SH_CLK: length 3.5
  TOP w0.149: R5878.1 184.67,56.21 184.51,56.37 184.51,57.74 184.11,58.14 U119.29
SI2204_OUT0N: length 2
  TOP w0.102: R250.2 48,34.7 48,35.63 48.14,35.76 U23.13
SI2204_OUT0P: length 2
  TOP w0.102: R249.2 47.77,34.7 47.77,35.63 47.64,35.76 U23.12
SI2204_OUT1N: length 2
  TOP w0.102: U23.18 50.66,37.31 50.8,37.17 51.77,37.17 R254.2
SI2204_OUT1P: length 2
  TOP w0.102: U23.17 50.66,36.81 50.79,36.95 51.72,36.95 R252.2
SI2204_OUT2N: length 2
  TOP w0.102: R256.2 51.74,39.17 50.8,39.17 50.67,39.31 U23.22
SI2204_OUT2P: length 2
  TOP w0.102: R255.2 51.75,38.95 50.79,38.95 50.65,38.81 U23.21
SI2204_OUT3N: length 2
  TOP w0.102: U23.26 49.14,41.38 49.27,41.52 49.27,42.44 R262.2
SI2204_OUT3P: length 2
  TOP w0.102: R259.2 49.5,42.4 49.5,41.52 49.64,41.38 U23.25
SI5391_1P8V_VDDO: length 6.4
  TOP w0.191: U22.29 58.1,26.33 v1(58.05,26.28)
  TOP w0.254: U22.57 v3(50.93,23.83) ; U22.49 50.74,27.83 v1(50.93,27.64) ; U22.26 v1(58.05,24.83) ; U22.40 v1(54.74,27.64)
  BOTTOM w0.381: C437.1 50.93,23.87 v1(50.93,24.84) ; v1(50.93,27.64) 51,27.57 C440.1
  vias: v1(56.01,27.64) v1(59.63,29.54) v4(59.19,28.53)
SI5391_2P5V_VDDO: length 5.8
  TOP w0.191: U22.36 v1(56.74,29.33)
  TOP w0.203: U22.52 v1(50.93,26.33) ; U22.22 v1(58.05,22.83)
  TOP w0.254: v1(53.3,27.64) 53.24,27.69 U22.43
  BOTTOM w0.254: C431.1 58.01,29.07 57.75,29.33 v1(56.74,29.33)
  BOTTOM w0.381: v1(50.93,26.33) 50.93,25.9 C429.1
  vias: v1(58.01,23.83)
SI5391_A0: length 2.9
  TOP w0.149: U22.19 59.76,21.33 60.32,20.77 60.32,20.09 R223.1
SI5391_A1: length 3.1
  TOP w0.149: U22.17 59.21,20.33 59.32,20.23 R225.1
SI5391_ENN: length 276.3
  TOP w0.254: U22.11 v1(55.74,20.65)
  L12_SIG4 w0.089: v1(26.6,73.26) 25.1,73.26 18.89,79.47 17.46,79.47 17.18,79.76 3.72,79.76 3.54,79.57 3.09,79.57 2.8,79.28 2.8,76.17 3.25,75.72 v1(3.25,75.39) ; v1(55.74,20.65) 56.42,19.97 60.94,19.97 61.29,19.62 64.29,19.62 69.15,14.75 113.95,14.75 114.22,15.02 128.4,15.02 128.62,14.8 133.77,14.8 137.06,18.09 140.11,18.09 140.16,18.14 142.98,18.14 143.03,18.09 150.27,18.09 150.32,18.14 151.81,18.14 152.56,18.89 170.36,18.89 170.39,18.86 170.7,18.86 170.72,18.89 172.03,18.89 173.38,17.54 180.17,17.54 180.63,17.08 183.64,17.08 184.03,16.68 186.66,16.68 186.86,16.87 195.19,16.87 195.5,17.19 197.22,17.19 197.42,16.99 197.97,16.44 198.79,16.44 v1(199.19,16.84)
  L14_SIG5 w0.081: v1(55.74,20.65) 55.74,22.18 51.15,26.77 50.81,26.77 49.98,25.94 48.2,25.94 47.75,25.49 46.92,25.49 46.46,25.03 45.02,25.03 43.38,26.67 43.1,26.67 42.01,27.76 42.01,28 37.97,32.04 37.97,34.39 38.41,34.83 38.41,35.49 43.25,40.34 43.25,42.77 40.31,45.71 35.69,45.71 34.53,44.54 32.11,44.54 31.81,44.85 31.81,47.48 33.57,49.24 38.32,49.24 38.58,49.51 38.58,49.59 38.81,49.82 38.9,49.82 39.84,50.77 39.84,53.12 37,55.96 34.67,55.96 29.98,60.65 29.98,65.18 30.22,65.41 30.22,69.89 26.85,73.26 v1(26.6,73.26)
  BOTTOM w0.149: SW3.1 4.66,75.39 v1(3.25,75.39) ; U107.1 v1(199.19,16.84)
SI5391_I2C_SEL: length 1.1
  TOP w0.254: U22.39 55.24,29.4 v1(55.1,29.54)
SI5391_IN_SEL0: length 2.9
  TOP w0.149: U22.3 51.74,19.25 50.43,17.94 R227.1
SI5391_IN_SEL1: length 2.7
  TOP w0.149: R226.1 51.32,18.34 52.24,19.27 U22.4
SI5391_OUT0AN: length 2.3
  TOP w0.102: C448.1 60.34,21.44 60.18,21.44 59.65,21.97 59.42,21.97 59.28,21.83 U22.20
SI5391_OUT0AP: length 2.3
  TOP w0.102: U22.21 59.25,22.33 59.39,22.2 59.75,22.2 60.28,21.67 60.47,21.67 C447.1
SI5391_OUT0N: length 2.1
  TOP w0.102: C446.1 60.78,23 60.43,23.35 59.96,23.35 59.82,23.49 59.51,23.49 59.35,23.33 U22.23
SI5391_OUT0P: length 2.1
  TOP w0.102: C445.1 60.78,23.97 60.38,23.57 60.05,23.57 59.91,23.71 59.43,23.71 59.31,23.83 U22.24
SI5391_OUT1N: length 2.1
  TOP w0.102: U22.27 59.28,25.33 59.41,25.47 60.41,25.47 R232.2
SI5391_OUT1P: length 2.1
  TOP w0.102: R231.2 60.41,25.7 59.42,25.7 59.29,25.83 U22.28
SI5391_OUT2N: length 2.2
  TOP w0.102: R230.2 60.39,27.41 60.17,27.41 59.73,26.97 59.46,26.97 59.33,26.83 U22.30
SI5391_OUT2P: length 2.2
  TOP w0.102: R229.2 60.39,27.64 60.08,27.64 59.64,27.2 59.45,27.2 59.31,27.33 U22.31
SI5391_OUT3N: length 2.7
  TOP w0.149: R1064.2 58.94,30.46 58.56,30.09 58.56,29.9 58.13,29.47 57.88,29.47 57.6,29.2 57.6,29.04 57.74,28.91 U22.34
SI5391_OUT3P: length 2.7
  TOP w0.149: U22.35 57.24,28.89 57.3,28.95 57.3,29.32 57.75,29.77 58.01,29.77 58.26,30.03 58.26,30.15 R1063.2
SI5391_OUT4N: length 2.3
  TOP w0.102: C452.1 56.49,30.1 56.49,29.87 56.1,29.48 56.1,29.07 56.24,28.94 U22.37
SI5391_OUT4P: length 2.3
  TOP w0.102: C451.1 56.26,30.11 56.26,29.96 55.88,29.58 55.88,29.02 55.74,28.89 U22.38
SI5391_OUT5N: length 2.3
  TOP w0.149: R1066.2 54.57,30.19 54.57,29.75 54.13,29.31 54.13,29.09 54.24,28.98 U22.41
SI5391_OUT5P: length 2.3
  TOP w0.149: U22.42 53.74,28.95 53.83,29.03 53.83,29.44 54.21,29.82 54.21,30.14 R1065.2
SI5391_OUT6N: length 2.2
  TOP w0.102: C454.1 52.6,30.13 52.6,29.41 52.74,29.28 U22.44
SI5391_OUT6P: length 2.2
  TOP w0.102: C453.1 52.38,30.12 52.38,29.41 52.24,29.27 U22.45
SI5391_OUT7P: length 1.1
  TOP w0.149: U22.51 49.53,26.83 v1(49.11,27.26)
  BOTTOM w0.149: R239.2 49.11,27.24 v1(49.11,27.26)
SI5391_OUT8N: length 2.6
  TOP w0.102: U22.53 49.67,25.83 49.56,25.72 49.28,25.72 49.16,25.85 49.16,26.24 48.84,26.56 48.62,26.56 C1452.1
SI5391_OUT8P: length 2.6
  TOP w0.102: C1451.1 48.58,26.33 48.74,26.33 48.93,26.15 48.93,25.75 49.19,25.49 49.5,25.49 49.66,25.33 U22.54
SI5391_OUT9A: length 1
  TOP w0.149: U22.59 49.01,22.83 R237.2
SI5391_OUT9N: length 2
  TOP w0.102: U22.55 49.68,24.83 49.55,24.7 48.6,24.7 R236.2
SI5391_OUT9P: length 2
  TOP w0.102: U22.56 49.67,24.33 49.53,24.47 48.59,24.47 R235.2
SI5391_RSTN: length 155.5
  TOP w0.149: U22.6 53.24,19.3 52.76,18.81 v1(52.39,18.81)
  L12_SIG4 w0.089: v1(196.35,16.82) 195.53,16.82 195.35,16.63 186.96,16.63 186.76,16.44 183.93,16.44 183.54,16.83 180.53,16.83 180.07,17.3 175.67,17.3 175.66,17.29 171.46,17.29 170.9,17.84 170.59,17.84 170.28,17.53 170.28,17.51 170.06,17.29 136.65,17.29 133.96,14.59 128.54,14.59 128.31,14.81 114.36,14.81 114.05,14.51 66.18,14.51 66.06,14.64 66.06,17.44 64.12,19.38 61.24,19.38 60.86,18.99 58.91,18.99 58.77,19.12 58.72,19.12 58.65,19.2 57.61,19.2 57.59,19.22 57.24,19.22 57.21,19.2 52.77,19.2 v1(52.39,18.81)
  BOTTOM w0.149: U107.6 196.69,17.16 v1(196.35,16.82)
  BOTTOM w0.254: v1(52.39,18.81) 52.39,19.31 52.97,19.89 52.97,20.38 53.6,21.01 R228.1
SI5391_VDD: length 4.2
  TOP w0.191: v1(58.05,27.51) 58.37,27.83 U22.32
  TOP w0.254: v1(52.23,27.6) 52.23,27.56 51.74,28.05 U22.46
  TOP w0.255: U22.60 50.71,22.33 v3(50.93,22.56)
  BOTTOM w0.381: v1(52.23,27.6) 52.23,27.6 52.19,27.6 51.94,27.85 51.93,27.85 51.82,27.97 51.82,27.97 51.74,28.05 51.74,28.18 C427.1
  vias: v3(50.93,21.8)
SI5391_VDDA: length 1.3
  TOP w0.254: U22.13 56.74,19.06 57,18.8 v3(57.41,18.8)
SI5391_X1: length 2.4
  TOP w0.159: Y1.2 53.74,18.21 U22.7
SI5391_X2: length 5.5
  TOP w0.159: Y1.4 55.92,16.17 56.27,16.17 56.42,16.33 56.42,18.2 56.24,18.38 55.48,18.38 55.24,18.63 U22.10
SI5391_XA: length 5
  TOP w0.159: U22.8 54.24,15.92 54,15.68 Y1.3
SI5391_XB: length 2.4
  TOP w0.159: U22.9 54.74,18.21 Y1.1
SI52204_FS: length 3.1
  TOP w0.149: R257.1 R260.1 46.36,34.75 47.14,35.52 U23.11
SI52204_OE0N: length 3.1
  TOP w0.149: R241.1 R242.1 49.41,34.37 48.64,35.14 U23.14
SI52204_OE1N: length 3.7
  TOP w0.149: U23.16 49.64,35.84 49.99,35.49 50.26,35.49 R246.1 R245.1
SI52204_OE2N: length 3.1
  TOP w0.149: R247.1 R248.1 51.95,40.59 51.17,39.81 U23.23
SI52204_OE3N: length 3.1
  TOP w0.149: U23.27 48.64,41.59 47.89,42.34 R244.1 R243.1
SI52204_PWRDNB: length 77.7
  TOP w0.149: v1(44.33,40.97) 44.46,40.85 44.46,40.21 44.86,39.81 U23.2
  L12_SIG4 w0.089: v1(3.25,79.2) 3.6,78.84 14.43,78.84 14.95,78.33 14.97,78.33 15.2,78.09 15.2,78.07 18.19,75.08 18.19,66.21 20.01,64.38 28.16,64.38 28.87,63.67 28.87,59.76 30.79,57.84 30.79,57.82 30.88,57.82 31.11,57.59 31.11,57.26 30.88,57.03 30.79,57.03 30.79,54.59 30.06,53.85 30.06,48.14 v1(33.28,44.91)
  L14_SIG5 w0.081: v1(44.33,40.97) 44.33,44.07 42.72,45.68 41.41,45.68 41.27,45.53 40.94,45.53 40.53,45.94 35.6,45.94 34.57,44.91 v1(33.28,44.91)
  BOTTOM w0.149: SW3.4 3.3,79.25 v1(3.25,79.2)
SI52204_SA: length 3.3
  TOP w0.149: U23.7 44.98,37.31 44.84,37.16 43.89,37.16 R264.1 R263.1
SI52204_SSEN: length 3.9
  TOP w0.149: R251.1 R253.1 44.84,40.67 45.19,40.31 U23.1
STRAP_1_PCLASS1: length 371.4
  L07_SIG3 w0.089: v1(236.14,108.96) 235.11,109.98 196.42,109.98 195.56,109.12 189.12,109.12 187.41,107.4 186.74,107.4 184.63,109.51 72.46,109.51 64.18,101.23 56.21,101.23 56.1,101.34 51.35,101.34 48.04,98.03 24.43,98.03 23.54,98.93 21.39,98.93 18.86,96.4 7.25,96.4 4.77,93.91 4.77,75.27 1.81,72.31 1.81,67.57 13.39,55.99 13.39,53.86 v1(14.04,53.22) 14.37,53.22 15.47,52.11 15.47,50.04 15.17,49.74 13.67,49.74 12.67,48.73 12.67,44.51 13.03,44.15 13.03,38.44 15.46,36.01 16.73,36.01 18.71,34.03 20.92,34.03 21.53,33.42 21.53,31.81 22.22,31.12 22.22,26.71 23.88,25.05 23.88,23.99 24.34,23.53 24.65,23.53 25.12,23.06 25.12,22.75 25.34,22.53 25.72,22.53 26.12,22.12 26.12,21.75 26.91,20.96 26.91,19.79 26.65,19.53 25.59,19.53 25.12,19.06 25.12,18.75 25.34,18.53 28.12,18.53 v1(28.5,18.9)
  L12_SIG4 w0.089: v1(1.82,53.83) 13.43,53.83 v1(14.04,53.22) ; v1(236.14,108.96) 236.14,109 235.52,108.38 235.52,100.81 235.35,100.65 235.35,99.35 235.42,99.28 235.42,98.21 235.52,98.11 235.52,97.84 234.71,97.03 234.71,96.81 233.53,95.63 v1(233.53,95.26)
  BOTTOM w0.149: R2727.2 231.99,94.17 R2206.2 232.19,93.97 R2734.2 233.26,93.97 233.53,94.24 v1(233.53,95.26) ; SW5.2 v1(14.04,53.22)
STRAP_2_SMBUS_I2C_ADDR: length 42.8
  TOP w0.149: TP28.1 v1(15.1,43.19)
  L03_SIG1 w0.081: v1(14.82,50.31) 15.2,49.93 15.2,48.99 14.61,48.4 14.61,43.69 v1(15.1,43.19)
  L07_SIG3 w0.089: v1(14.82,50.31) 13.62,50.31 12.03,48.72 12.03,38.44 15.26,35.22 16.23,35.22 18.83,32.62 20.35,32.62 21.98,31 21.98,26.42 v1(23.49,24.9)
  BOTTOM w0.149: R2721.1 14.79,50.33 v1(14.82,50.31)
STRAP_3_CVL_PRSNT0_N: length 366.6
  L07_SIG3 w0.089: v1(28.5,22.9) 28.02,22.9 27.65,23.28 27.35,23.28 26.87,23.76 26.87,24.06 26.65,24.28 26.35,24.28 22.5,28.13 22.5,31.21 21.83,31.88 21.83,33.5 21.06,34.27 19.07,34.27 16.56,36.78 15.88,36.78 13.27,39.39 13.27,44.29 12.94,44.62 12.94,48.18 v1(13.91,49.15)
  L12_SIG4 w0.089: v1(1.84,49.97) 2.44,50.57 12.49,50.57 v1(13.91,49.15) ; v1(28.5,22.9) 28.06,22.47 27.53,22.47 27.12,22.06 27.12,20.75 27.38,20.49 27.74,20.49 27.94,20.29 33.28,20.29 34.26,19.31 41.26,19.31 42.03,20.08 42.87,20.08 43.6,19.35 43.6,18.75 44.19,18.16 44.19,17.65 44.78,17.07 45.11,17.07 45.74,17.7 46.62,17.7 47.06,17.26 48.14,17.26 48.57,16.83 48.9,16.83 49.12,17.05 51.63,17.05 51.7,16.98 59.95,16.98 61.59,18.61 63.8,18.61 65.26,17.16 65.26,14.3 66.48,13.08 113.7,13.08 114.7,14.08 127.97,14.08 128.52,13.52 128.52,13.47 128.76,13.23 129.25,13.23 129.85,13.83 134.27,13.83 136.18,15.73 175.96,15.73 176.74,16.51 178.74,16.51 179.73,15.52 185.82,15.52 185.83,15.53 186.93,15.53 187.27,15.87 193.08,15.87 193.78,15.16 194.55,15.16 195.09,15.7 196.04,15.7 196.82,14.92 201.42,14.92 201.78,14.56 203.71,14.56 204.23,15.08 206.3,15.08 206.48,14.9 211.97,14.9 214.05,16.98 220.1,16.98 221.44,15.65 v1(225.05,15.65)
  L16_SIG6 w0.081: v4(231.25,94.3) 232.73,94.3 232.91,94.48 236.75,94.48 237.54,93.69 237.54,83.53 238.93,82.13 238.93,78.44 237.63,77.13 230.03,77.13 229.81,77.36 229.44,77.36 229.22,77.13 228.51,77.13 228.28,77.36 227.91,77.36 227.69,77.13 226.98,77.13 226.76,77.36 226.39,77.36 225.63,76.6 225.63,68.69 224.53,67.59 224.53,62.17 224.12,61.77 224.12,37.79 225.35,36.55 225.35,32.03 223.83,30.51 223.83,24.41 225.05,23.19 v1(225.05,15.65)
  BOTTOM w0.149: v1(13.91,49.15) 13.04,49.15 12.33,49.86 SW5.4 ; R2735.1 231.25,94.85 v4(231.25,94.3)
STRAP_4_BRD_REV0: length 4.1
  TOP w0.149: v1(36.49,27.9) 37.06,27.33 38.74,27.33 39.52,26.56 arc(39.64,26.47) 39.79,26.44 R2635.2
STRAP_5_BRD_REV1: length 2.8
  TOP w0.149: R6193.2 40.05,27.88 arc(40.06,27.93) R6192.2 arc(40.08,27.98) 40.07,27.98 39.28,27.98 38.5,28.76 v1(38.5,28.9)
SW1_3: length 14.6
  L12_SIG4 w0.089: v1(1.82,52) 1.87,51.95 v1(13.98,51.95)
  BOTTOM w0.149: R2721.2 14,51.92 v1(13.98,51.95) SW5.3
SW1_5: length 3.2
  BOTTOM w0.149: R2719.2 R2732.1 2.83,50.08 4.11,50.08 SW5.5
SW1_6: length 4.4
  BOTTOM w0.149: SW5.6 4.31,51.95 3.27,50.91 TP25.1 2.71,50.94 R2731.1 R2718.2
SW1_7: length 4.1
  BOTTOM w0.149: TP24.1 2.74,55.66 R2717.2 2.74,53.85 R2730.1 2.76,53.77 3.39,53.77 3.94,53.22 SW5.7
SYNC: length 2.4
  TOP w0.149: U119.14 178.16,58.54 178.07,58.45 177.8,58.45 177.47,58.12 177.47,57.52 R5877.1
TEMP1_THERMN: length 362.3
  TOP w0.149: v1(66.76,100.26) 66.5,100 66.5,92.95 65.07,91.53 65.07,87.62 69.75,82.95 75.08,82.95 76.6,81.42 76.6,80.64 75.95,79.99 v1(74.64,79.99) 74.64,79.99 EU1.9
  L07_SIG3 w0.089: v1(195.56,18.17) 196.49,19.1 196.49,20.96 196.29,21.16 196.29,22.23 197.18,23.11 203.16,23.11 205.6,25.56 206.13,25.56 210.1,25.56 215.13,30.59 220.77,30.59 221.81,31.62 223.67,31.62 231.2,24.1 236.66,24.1 238.51,25.94 238.51,27.16 241.58,30.23 241.58,33.57 244.03,36.02 244.03,39.53 244.18,39.69 244.18,43.24 243.73,43.7 243.73,43.7 243.72,43.71 243.72,44.22 244.93,45.42 246.57,45.42 246.77,45.62 246.77,46.34 246.09,47.02 246.09,47.37 248.2,49.48 248.2,49.77 250.07,51.64 250.07,54.43 249.67,54.83 249.67,66.22 251.5,68.05 251.5,98.95 242.48,107.98 235.71,107.98 234.44,109.26 196.72,109.26 195.86,108.4 189.42,108.4 187.71,106.68 186.41,106.68 185.75,107.34 185.44,107.34 185.13,107.03 176.75,107.03 176.46,106.75 175.85,106.75 173.81,108.79 150.08,108.79 150.08,108.79 76.88,108.79 73.57,105.49 72.6,105.49 67.38,100.26 v1(66.76,100.26)
  BOTTOM w0.149: U107.7 v1(195.56,18.17) ; R453.1 v1(74.64,79.99)
TEMP2_THERMN: length 222.2
  L07_SIG3 w0.089: v1(195.03,19.89) 195.03,21.56 196.92,23.45 203.15,23.45 206.75,27.05 209.35,27.05 214.24,31.94 221.05,31.94 221.46,32.35 230.24,32.35 232.92,35.02 242.69,35.02 243.7,36.03 243.7,39.55 243.94,39.79 243.94,43.14 243.49,43.6 243.49,43.6 243.48,43.61 243.48,46.37 248.63,51.52 248.63,66.2 250.78,68.35 250.78,98.65 242.18,107.26 235.39,107.26 234.11,108.53 197.02,108.53 196.16,107.67 189.72,107.67 187.69,105.64 187.69,105.4 186.82,104.53 v1(173.69,104.53)
  BOTTOM w0.149: v1(173.69,104.53) 173.29,104.13 173.29,96.68 172.87,96.26 172.87,94.77 173.58,94.06 v1(173.58,92.03) 173.11,92.03 172.72,91.64 EU2.9 ; U107.8 195.42,18.67 195.03,19.06 v1(195.03,19.89)
TMON0: length 2.2
  TOP w0.149: v1(174.43,80.42) 174.15,80.7 U120.22
  BOTTOM w0.149: C7686.2 R6039.1 174.43,80.51 v1(174.43,80.42)
TMON1: length 2
  TOP w0.203: R5885.1 C7689.2 174.1,66.81 173.94,66.66 U121.22
TMON3: length 2.1
  TOP w0.203: U125.22 173.69,52.66 174.01,52.34 C2028.2 R5890.1
TMON4: length 2.1
  TOP w0.203: U126.22 174.37,37.85 C7690.2 174.51,38.75 R5893.1
TSNS0: length 64.6
  TOP w0.149: v1(177.67,60.89) 177.72,60.94 U119.8 ; v1(178.15,66.54) 176.63,66.54 176.01,65.93 R5885.2
  L07_SIG3 w0.089: v1(175.39,51.5) 175.67,51.22 176.33,51.22 177.14,52.02 180.14,52.02 181.01,52.89 181.01,54.67 179.98,55.7 179.98,62.43 179.58,62.83 179.37,62.83 179.14,63.06 179.14,63.5 178.27,64.37 178.27,66.42 v1(178.15,66.54)
  L12_SIG4 w0.089: v1(177.67,60.89) 177.93,61.15 177.93,63.73 176.81,64.85 176.81,65.2 177.4,65.8 177.4,66.04 177.91,66.54 v1(178.15,66.54)
  BOTTOM w0.149: v1(177.67,60.89) 177.79,61.01 178.26,61.01 C1719.1 ; v1(175.39,51.5) 175.39,50.23 176.43,49.19 176.43,44.58 176.35,44.49 176.35,40.7 175.33,39.68 v1(175.33,38.81) ; v1(178.15,66.54) 176.62,66.54 175.14,68.02 175.14,81.13 174.85,81.42 R6039.2
USB_DISABLEN: length 304.6
  L03_SIG1 w0.081: v1(24.49,17.9) 27.03,15.37 28.07,15.37 29.24,14.2 35.55,14.2 35.79,13.96 41.35,13.96 41.53,14.14 42.72,14.14 42.86,14.17 44.36,14.17 44.68,14.49 46.62,14.49 49.17,17.04 49.17,18.27 48.79,18.65 48.79,19.21 49.27,19.7 49.27,20.79 49.04,21.02 48.71,21.02 48.43,21.3 48.43,28.09 48.58,28.24 48.58,30.78 47.6,31.77 47.25,31.77 46.62,32.4 46.62,34.98 45.94,35.65 45.94,39.96 47.22,41.24 47.22,41.91 47.26,41.96 47.26,46.78 44.36,49.69 44.36,51.76 44.15,51.97 44.15,52.64 44.75,53.24 44.75,61.97 43.78,62.93 43.78,75.37 43.9,75.48 43.9,77.17 44.73,78 44.73,80.67 47.03,82.97 47.03,87.94 48.3,89.21 60.17,89.21 68.58,97.62 68.61,97.62 69.04,98.05 69.04,98.95 71.42,101.34 72.13,101.34 72.94,102.15 72.94,102.49 74.65,104.2 74.65,105.97 76.1,107.42 139.3,107.42 139.53,107.19 139.86,107.19 140.38,107.71 167.59,107.71 168.17,107.14 168.17,104.67 170.09,102.75 181.92,102.75 182.67,103.5 182.67,105.93 184.89,108.15 193.83,108.15 194.67,107.31 216.77,107.31 218.6,105.48 223.28,105.48 v1(224.24,106.44)
  BOTTOM w0.149: v1(224.24,106.44) 224.24,106.81 224.64,107.22 226.76,107.22 227.13,106.84 R6184.2
USB_MAX_JTAGSEL: length 55
  TOP w0.149: U38.15 18.13,16.18 18.14,16.17 18.14,15.76 18.3,15.59 19.48,15.59 22.29,18.4 23.88,18.4 24.03,18.55 24.03,19.12 24.31,19.4 24.84,19.4 24.99,19.55 24.99,21.07 25.31,21.39 25.69,21.39 26.02,21.72 26.02,22.1 26.32,22.39 27.73,22.39 27.98,22.65 27.98,27.18 28.21,27.41 33.01,27.41 v1(33.5,27.9)
  L03_SIG1 w0.081: v1(25.93,48.95) 25.93,48.08 26.16,47.85 26.16,42.38 26.15,42.37 26.15,38.46 29.15,35.46 29.15,34.06 29.61,33.6 32.32,33.6 33.12,32.8 33.12,28.33 33.5,27.95 v1(33.5,27.9)
  BOTTOM w0.149: SW8.3 24.44,51.23 24.87,50.8 24.87,49.28 25.2,48.95 v1(25.93,48.95)
USB_MAX_TCK: length 13.8
  TOP w0.149: U34.H3 25.98,25.41 25.98,23.61 25.75,23.38 25.25,23.38 25.03,23.15 25.03,22.71 24.69,22.37 24.26,22.37 23.99,22.1 23.99,21.65 23.77,21.43 23.31,21.43 22.3,20.41 21.29,20.41 21.06,20.18 21.06,18.6 19.68,17.23 19.47,17.23 19.33,17.37 18.82,17.37 U38.2
USB_MAX_TDI: length 12.6
  TOP w0.149: U38.7 17.73,19.86 18.71,20.85 20.88,20.85 21.04,21.02 21.43,21.02 21.99,21.57 21.99,22.11 23.3,23.42 23.71,23.42 23.98,23.69 23.98,26.41 U34.G1
USB_MAX_TDO: length 16.1
  TOP w0.149: U38.10 17.02,17.78 16.52,17.78 15.89,18.4 15.89,20.4 16.69,21.19 20.74,21.19 21.01,21.46 21.01,22.09 20.52,22.57 20.52,25.15 21.27,25.9 U34.H1
USB_MAX_TMS: length 11.8
  TOP w0.149: U38.5 18.53,19.43 19.59,20.5 20.96,20.5 21.17,20.71 22.02,20.71 22.9,21.59 22.9,22.09 23.24,22.42 23.81,22.42 24.01,22.63 24.01,23.12 24.28,23.39 24.7,23.39 25.01,23.7 25.01,25.39 U34.H2
USB_T_CLK: length 22.6
  TOP w0.149: U34.R10 31.97,19.42 v1(31.04,19.42)
  BOTTOM w0.149: v1(17.23,21.99) 17.23,21.54 17.89,20.88 18.1,20.88 18.64,21.41 18.87,21.41 19.07,21.21 19.07,21 18.52,20.46 18.52,20.25 19.45,19.32 19.45,18.75 20.06,18.14 22.14,18.14 24.09,16.19 29.45,16.19 31.03,17.77 31.03,19.42 v1(31.04,19.42)
VFB0: length 6.2
  TOP w0.149: v1(177.01,58.93) 177.12,59.04 177.53,59.04 177.83,59.34 177.97,59.34 177.98,59.34 U119.12 ; v1(175.51,58.29) 175.65,58.16 R5875.2
  BOTTOM w0.149: v1(175.51,58.29) 175.61,58.29 176.18,58.87 R5876.1 v1(177.01,58.93) 177.63,58.93 178.15,59.45 C7678.1
VOSNS0_0P8V: length 7.3
  L14_SIG5 w0.203: v1(72.57,73.17) 72.57,72.93
  L14_SIG5 w0.254: 70.82,73.56 70.82,72.98 71.13,72.67 72.32,72.67 72.57,72.93
  L14_SIG5 w0.305: v1(67.49,73.17) 67.66,73.17 68.31,73.82 70.57,73.82 70.82,73.56
  BOTTOM w0.381: v1(72.57,73.17) 72.57,73.5 R5925.2
VOSNS0_VCCR: length 0.7
  BOTTOM w0.381: R5835.2 192.58,78.83 v1(192,78.83)
  vias: v1(192,83.91)
VSENSE0+: length 103
  L07_SIG3 w0.203: v1(176.74,61.48) 176.5,61.72 176.3,61.72 175.99,61.41 175.99,60.71 175.53,60.25 171.51,60.25 163.16,68.6 163.16,82.21 171.8,90.85 171.8,93.68 172.55,94.42 172.55,96.53 172.26,96.81 168.58,96.81 168,96.23 156.2,96.23 155.4,95.43 155.4,92.14 153.08,89.81 133.52,89.81 128.4,84.69 128.4,84.67 128.37,84.64 128.37,84.4 v1(128.32,84.35)
  BOTTOM w0.254: R220.2 128.21,83.33 128.21,84.24 v1(128.32,84.35)
VSENSE0+_U119: length 5.2
  TOP w0.149: U119.7 177.83,61.34 v1(177.53,61.65) ; R6277.2 175.58,61.47 175.14,61.03 v1(174.9,61.03)
  BOTTOM w0.149: v1(174.9,61.03) 177.2,61.03 177.53,61.36 v1(177.53,61.65)
VSENSE0-: length 103.9
  L07_SIG3 w0.203: v1(176.6,62.33) 176.32,62.05 176.17,62.05 175.66,61.55 175.66,60.84 175.39,60.58 171.65,60.58 163.49,68.74 163.49,82.07 172.14,90.72 172.14,93.54 172.88,94.29 172.88,96.67 172.4,97.15 168.45,97.15 167.87,96.56 156.07,96.56 155.07,95.57 155.07,92.27 152.94,90.14 133.39,90.14 128.07,84.83 128.07,84.81 127.63,84.37 v1(127.48,84.37)
  BOTTOM w0.254: v1(127.48,84.37) 127.54,84.37 127.79,84.11 127.79,83.48 R221.2
VSENSE0-_U119: length 3.3
  TOP w0.149: R6278.2 176.9,63.26 177.05,63.11 177.05,62.31 177.22,62.13 177.66,62.13 178.05,61.74 U119.6
VTT_DDR4_CH1_EN: length 29.5
  TOP w0.149: v1(32.55,35.87) 32.55,35.67 32.2,35.32 R6246.1
  L07_SIG3 w0.089: v1(32.55,35.87) 32.29,35.61 32.29,34.87 32.61,34.55 32.61,33.76 31.96,33.11 31.96,30.76 32.44,30.28 32.65,30.28 32.87,30.06 32.87,29.85 33.44,29.28 33.65,29.28 33.87,29.06 33.87,28.85 34.23,28.49 34.58,28.49 35.08,27.99 35.08,27.64 35.44,27.28 35.65,27.28 35.87,27.06 35.87,25.88 36.23,25.53 39.44,25.53 41.39,23.58 41.92,23.58 41.93,23.59 42.54,23.59 42.98,23.15 42.98,22.5 v1(42.71,22.24)
  BOTTOM w0.149: v1(42.71,22.24) 42.89,22.42 47.35,22.42 47.49,22.56 47.49,23.45 R817.2
VTT_DDR4_CH2_EN: length 112.9
  TOP w0.149: v1(35.78,36.04) 35.78,35.63 R6247.1 ; R823.2 25.31,108.65 24.82,109.14 24.82,109.64 24.5,109.95 21.93,109.95 v1(21.62,109.64)
  L03_SIG1 w0.081: v1(35.78,36.04) 35.41,36.42 35.41,51.99 31.9,55.49 31.9,61.04 31.16,61.78 31.16,73.76 30.35,74.56 30.35,77.79 29.83,78.32 29.83,79.16 30.35,79.69 31.24,79.69 33.44,81.88 33.44,89.66 v1(33.25,89.85)
  L14_SIG5 w0.081: v1(21.62,109.64) 21.32,109.94 14.94,109.94 12.86,107.86 12.86,100.98 11.69,99.8 11.69,92.56 12.52,91.73 32.57,91.73 33.25,91.05 v1(33.25,89.85)
VTT_DDR4_CH3_EN: length 247.5
  L03_SIG1 w0.081: v1(35.13,35.94) 35.13,35.26 34.77,34.9 33.83,34.9 32.95,35.78 32.95,36.03 32.47,36.51 32.47,44.55 32.66,44.75 32.66,46.67 33.01,47.02 33.01,53.04 31.11,54.94 31.11,59.52 30.34,60.29 30.34,71.66 29.19,72.8 29.19,75.39 29.01,75.57 29.01,80.99 29.56,81.54 29.56,83.06 29.77,83.27 29.77,87.81 36.83,94.87 36.83,102.26 35.27,103.81 35.27,104.61 36.18,105.53 40.85,105.53 41.38,106.06 49.38,106.06 50.76,104.69 51.17,104.69 51.4,104.46 51.4,104.04 52.3,103.15 54.55,103.15 57.5,106.1 59.55,106.1 63.31,109.86 179.44,109.86 v1(181.46,107.83)
  BOTTOM w0.149: v1(35.13,35.94) 35.13,35.6 R6248.1 ; R2781.2 181.15,91.89 181.15,93.67 180.9,93.92 180.9,107.27 v1(181.46,107.83)
N17328275:
  vias: v1(195.71,98.55) v1(195.71,97.97) v1(195.87,94.72) v1(195.87,94.13)
N17329090:
  vias: v1(69.14,93.34)
N23628441: length 1.9
  BOTTOM w0.149: C196.1 166.53,23.29 R73.1 R74.1
N28015562: length 0.6
  BOTTOM w0.381: v1(95.74,24.94) 95.82,24.85 R1.1
N28022993: length 0.6
  BOTTOM w0.381: R2.1 116.18,24.82 v1(116.06,24.94)
N30715060: length 1
  BOTTOM w0.381: v1(85.58,24.94) 85.62,24.98 R7.1
N30715756: length 0.6
  BOTTOM w0.381: R8.1 105.97,25.01 v1(105.9,24.94)
N30729048:
  vias: v1(169.91,24.86)
N30732060:
  vias: v1(165.11,28.86)
N30732063:
  vias: v1(169.11,28.06)
N30732066:
  vias: v1(165.11,27.26)
N30732069: length 0.6
  BOTTOM w0.149: R54.2 v1(168.31,27.26)
N30732072: length 2
  BOTTOM w0.149: v1(164.31,27.26) 163.91,27.06 163.71,26.86 163.22,26.86 R55.2
N30732075:
  vias: v1(169.11,27.26)
N30732078:
  vias: v1(165.11,26.46)
N30732081: length 0.6
  BOTTOM w0.149: R58.2 168.28,26.44 v1(168.31,26.46)
N30732436:
  vias: v1(164.31,25.66)
N30732839: length 0.6
  BOTTOM w0.149: R60.2 167.78,28.06 168.3,28.06 v1(168.31,28.06)
N30732842: length 0.6
  BOTTOM w0.149: R61.2 167.81,28.86 v1(168.31,28.86)
N31250983: length 6.8
  TOP w0.149: J5.B11 55.51,4.25 55.51,9.79 R152.1
N31253147: length 0.9
  BOTTOM w0.149: R151.2 R155.1
N31253181: length 6.5
  TOP w0.149: J5.B9 53.65,10.48 R150.2
N31257069:
  vias: v4(54.24,8.33) v4(54.24,7.44) v4(54.87,8.33) v4(54.87,7.44)
N31314586: length 8.8
  TOP w0.203: U122.B5 231.35,65.66 227.57,65.66 227.03,65.13 227.03,64.37 226.65,63.99 225.89,63.99 225.65,64.22 TP8.1
N31314601: length 7.2
  TOP w0.203: U122.A5 227.87,65.13 227.49,64.75 227.49,64.06 226.88,63.45 225.85,63.45 225.65,63.25 TP9.1
N31314621: length 1.4
  BOTTOM w0.203: R580.2 v1(233.15,65.13) 233.62,64.66 C716.2
N31314744: length 1.2
  BOTTOM w0.254: R582.1 231.88,61.05 v1(231.88,61.32)
N31314754: length 1.7
  BOTTOM w0.203: C720.2 R581.1 230.28,59.72 v1(230.61,60.05)
N31314797: length 1.6
  BOTTOM w0.203: R583.1 232.54,64.63 R585.1 232.99,64.02 v1(233.15,63.86)
N31314853: length 0.7
  BOTTOM w0.203: R584.1 v1(230.61,63.86)
N31314899: length 0.8
  BOTTOM w0.203: v1(230.61,61.32) C726.2
N31314949: length 1.3
  BOTTOM w0.381: R589.1 230.7,62.5 v1(230.61,62.59) R587.1
N31314957:
  vias: v1(231.88,60.05)
N31352894: length 2.4
  BOTTOM w0.149: R317.2 3.63,57.17 4.45,57.99 SW4.5
N31352897: length 2.2
  BOTTOM w0.149: SW4.6 3.82,59.26 3.5,58.94 R318.2
N31352900: length 2.1
  BOTTOM w0.149: SW4.7 3.56,60.53 3.37,60.72 R319.2
N31388806:
  vias: v1(250.26,39.83)
N31388830:
  vias: v1(250.26,41.48)
N31388866: length 4.5
  BOTTOM w0.149: Q7.3 251.17,40.72 v1(251.68,41.23)
N31388880: length 4.5
  TOP w0.149: Q9.3 248.93,40.72 249.18,40.46 251.58,40.46 251.68,40.36 D7.C
N31388890:
  vias: v1(250.26,38.43)
N31388919: length 5
  BOTTOM w0.149: Q10.3 247.66,36.65 248.42,37.42 250.92,37.42 v1(251.68,38.18)
N31389008:
  vias: v1(250.26,36.53)
N31389082: length 4.8
  TOP w0.149: Q11.3 248.88,35.77 251.51,35.77 251.68,35.94 D10.C
N31389320:
  vias: v1(250.26,42.75)
N31389364: length 5.8
  TOP w0.149: Q12.3 248,43.56 248.32,43.23 248.95,43.23 249.21,43.49 251.58,43.49 251.68,43.39 D11.C
