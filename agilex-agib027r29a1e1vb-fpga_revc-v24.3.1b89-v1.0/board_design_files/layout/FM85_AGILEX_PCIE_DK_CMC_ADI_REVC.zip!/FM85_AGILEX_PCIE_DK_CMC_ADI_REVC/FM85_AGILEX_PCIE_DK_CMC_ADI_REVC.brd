# Allegro board FM85_AGILEX_PCIE_DK_CMC_ADI_REVC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_COMP_CH0_DQ29: length 45.5
  L12_SIG4 w0.089: v1(113.13,45.13) 114.18,45.13 114.72,44.58 115.02,44.58 115.48,44.12 115.78,44.12 116.07,43.83 116.36,43.83 116.99,43.2 117.27,43.2 117.49,42.98 117.49,37.86 116.65,37.03 116.65,35.7 116.57,35.61 116.08,35.61 116,35.53 116,35.36 116.08,35.27 116.26,35.27 116.35,35.18 116.35,34.96 116.26,34.87 115.36,34.87 115.27,34.79 115.27,34.62 115.36,34.53 117.4,34.53 117.49,34.44 117.49,33.81 117.4,33.72 116.83,33.72 116.74,33.63 116.74,33.46 116.83,33.38 117.51,33.38 117.6,33.29 117.6,33.12 117.51,33.03 116.83,33.03 116.74,32.94 116.74,32.78 116.83,32.69 117.4,32.69 117.49,32.6 117.49,32.25 117.4,32.16 116.15,32.16 115.84,32.47 115.84,34.04 115.7,34.18 115.17,34.18 115.04,34.05 115.04,33.65 115.13,33.56 115.36,33.56 115.45,33.47 115.45,33.29 115.36,33.2 115.13,33.2 115.04,33.11 115.04,32.32 114.95,32.24 114.78,32.24 114.67,32.35 114.67,33.08 114.58,33.17 113.76,33.17 113.61,33.01 113.61,31.97 113.76,31.81 116.99,31.81 117.1,31.7 117.1,31.42 117.01,31.33 116.38,31.33 116.29,31.24 116.29,31.1 116.41,30.99 117.01,30.99 117.1,30.9 117.1,30.73 117.01,30.64 116.58,30.64 116.49,30.55 116.49,30.39 116.58,30.3 117.01,30.3 117.1,30.21 117.1,30.05 117.01,29.96 116.45,29.96 116.36,29.87 116.36,29.7 116.45,29.61 116.69,29.61 116.81,29.5 116.81,28.33 116.19,27.71 115.37,27.71 115.26,27.6 v1(115.26,27.34)
DDR4_COMP_CH0_DQ30: length 43.2
  L12_SIG4 w0.089: v1(111.26,26.54) 111.66,26.94 111.66,27.51 111.44,27.74 109.51,27.74 108.94,27.17 108.94,26.07 107.39,24.52 104.18,24.52 103.12,25.58 103.12,29.95 105.67,32.5 106.94,32.5 107.61,33.17 109.61,33.17 111.16,34.72 111.88,34.72 113.56,36.4 113.56,40.68 113.16,41.07 112.98,41.07 112.52,41.53 112.18,41.53 111.72,41.99 111.38,41.99 110.92,42.45 110.59,42.45 110.32,42.72 110.32,43.44 110.1,43.66 110.09,43.66 109.92,43.83 109.59,43.83 109.3,44.12 109,44.12 108.65,44.47 108.65,44.85 108.8,45 108.8,45.41 108.69,45.52 108.69,45.77 109.15,46.23 v1(109.15,46.51)
DDR4_COMP_CH0_DQ31: length 43.8
  L12_SIG4 w0.089: v1(114.46,26.54) 115.5,26.54 115.99,27.03 116.68,27.03 116.9,27.25 117.49,28 117.49,29.07 117.6,29.17 117.9,29.17 118.21,29.48 118.21,29.84 118.31,29.94 118.71,29.94 118.81,30.05 118.81,30.2 118.72,30.29 118.3,30.29 118.21,30.38 118.21,30.53 118.31,30.63 119.01,30.63 119.1,30.72 119.1,30.73 119.1,30.88 119.01,30.97 118.3,30.97 118.21,31.06 118.21,31.21 118.31,31.32 118.64,31.32 118.72,31.4 118.72,34.39 118.81,34.47 119.31,34.47 119.4,34.56 119.4,34.72 119.29,34.83 118.81,34.83 118.72,34.92 118.72,35.1 118.83,35.21 119.73,35.21 119.85,35.33 119.85,35.54 119.74,35.66 118.84,35.66 118.75,35.75 118.75,35.92 118.84,36.01 119.84,36.01 119.93,36.11 119.93,36.28 119.84,36.37 118,36.37 117.85,36.22 117.85,35.44 117.76,35.34 117.47,35.34 117.38,35.43 117.38,36.72 117.69,37.03 118.3,37.03 118.61,36.72 119.84,36.72 119.93,36.81 119.93,37.03 119.83,37.13 118.76,37.13 118.66,37.23 118.66,37.52 118.76,37.62 118.99,37.62 119.13,37.75 119.13,44.09 118.93,44.29 118.51,44.29 118.05,44.75 117.56,44.75 117.27,45.04 117.01,45.04 116.37,45.67 116.07,45.67 115.61,46.13 115.37,46.13 115,46.5 114.67,46.5 114.11,47.05 113.76,47.05 113.13,46.43 v1(113.13,46.05)
DDR4_COMP_CH0_DQ32: length 67.6
  L14_SIG5 w0.081: v1(108.35,46.97) 107.95,46.28 107.95,46.27 arc(107.89,46.04) 107.95,45.82 arc(108.02,45.59) 107.96,45.36 107.95,45.35 arc(107.89,45.12) 107.95,44.9 arc(108.02,44.67) 107.96,44.44 107.95,44.43 arc(107.89,44.2) 107.95,43.98 arc(108.02,43.75) 107.96,43.52 107.95,43.51 arc(107.89,43.29) 107.95,43.06 arc(108.02,42.83) 107.96,42.6 107.95,42.58 arc(107.89,42.36) 107.95,42.14 arc(108.02,41.91) 107.96,41.69 107.95,41.67 arc(107.89,41.44) 107.95,41.22 arc(108.02,40.99) 107.96,40.76 107.95,40.75 arc(107.89,40.52) 107.95,40.3 arc(108.02,40.07) 107.96,39.84 107.95,39.83 arc(107.89,39.6) 107.95,39.38 arc(108.02,39.15) 107.96,38.92 107.95,38.91 arc(107.89,38.68) 107.95,38.46 107.96,38.45 arc(108.02,38.22) 107.95,38 107.61,37.65 107.61,36.31 107.61,36.31 107.61,34.38 107.29,34.06 106.41,34.06 106.33,33.98 106.33,32.81 106.15,32.62 105.39,32.62 105.31,32.54 105.31,32.37 105.39,32.29 106.15,32.29 106.23,32.21 106.23,32.03 106.15,31.95 105.39,31.95 105.31,31.87 105.31,31.7 105.39,31.62 106.15,31.62 106.23,31.54 106.23,31.36 106.15,31.28 105.39,31.28 105.31,31.2 105.31,31.03 105.39,30.95 106.15,30.95 106.23,30.87 106.23,30.34 106.15,30.26 104.84,30.26 104.76,30.34 104.76,30.74 104.68,30.82 104.51,30.82 104.43,30.74 104.43,30.34 104.35,30.26 102.97,30.26 102.49,29.78 94.93,29.78 94.62,30.09 94.62,31.42 94.54,31.5 93.6,31.5 93.49,31.38 93.49,30.38 93.29,30.18 88.66,30.18 88.44,29.96 88.44,24.05 86.56,22.17 84.9,22.17 84.9,22.17 84.59,22.17 84.59,22.17 83.53,22.17 83.44,22.26 83.44,24.74 83.26,24.92 83.05,24.92 82.97,25 82.97,25.18 83.05,25.26 83.26,25.26 83.34,25.34 83.34,25.51 83.26,25.59 83.05,25.59 82.97,25.67 82.97,25.85 83.05,25.93 83.26,25.93 83.34,26.01 83.34,26.52 83.23,26.63 82.23,26.63 80.96,25.37 79.88,25.37 79.61,25.09 79.61,24.51 v1(79.98,24.14)
DDR4_COMP_CH0_DQ33: length 69
  L14_SIG5 w0.081: v1(83.98,24.94) 83.98,25.18 84.12,25.32 86.8,25.32 87.02,25.55 87.02,30.73 89.64,33.35 90.63,33.35 90.72,33.43 90.72,34.3 90.8,34.38 90.97,34.38 91.05,34.3 91.05,33.43 91.13,33.35 91.31,33.35 91.39,33.43 91.39,34.3 91.47,34.38 91.64,34.38 91.72,34.3 91.72,33.43 91.8,33.35 91.98,33.35 92.06,33.43 92.06,34.3 92.14,34.38 92.31,34.38 92.39,34.3 92.39,33.43 92.47,33.35 92.65,33.35 92.73,33.43 92.73,34.3 92.81,34.38 92.98,34.38 93.06,34.3 93.06,33.43 93.14,33.35 93.32,33.35 93.4,33.43 93.4,34.3 93.48,34.38 93.65,34.38 93.73,34.3 93.73,33.43 93.81,33.35 93.99,33.35 94.07,33.43 94.07,34.3 94.15,34.38 94.32,34.38 94.4,34.3 94.4,33.43 94.49,33.35 94.66,33.35 94.74,33.43 94.74,34.3 94.82,34.38 94.99,34.38 95.07,34.3 95.07,33.43 95.16,33.35 95.33,33.35 95.41,33.43 95.41,34.3 95.49,34.38 95.66,34.38 95.75,34.3 95.75,33.43 95.83,33.35 96,33.35 96.08,33.43 96.08,34.3 96.16,34.38 96.33,34.38 96.42,34.3 96.42,33.43 96.5,33.35 96.67,33.35 96.75,33.43 96.75,34.3 96.83,34.38 97,34.38 97.09,34.3 97.09,33.43 97.17,33.35 97.34,33.35 97.42,33.43 97.42,34.3 97.5,34.38 97.68,34.38 97.76,34.3 97.76,33.43 97.84,33.35 98.01,33.35 98.09,33.43 98.09,34.3 98.17,34.38 98.35,34.38 98.43,34.3 98.43,33.43 98.51,33.35 98.68,33.35 98.76,33.43 98.76,34.3 98.84,34.38 99.02,34.38 99.1,34.3 99.1,33.43 99.18,33.35 99.35,33.35 99.43,33.43 99.43,34.3 99.51,34.38 99.69,34.38 99.77,34.3 99.77,33.43 99.85,33.35 100.02,33.35 100.1,33.43 100.1,34.3 100.19,34.38 100.36,34.38 100.44,34.3 100.44,33.43 100.52,33.35 101.19,33.35 101.3,33.45 101.3,33.85 101.43,33.98 103.35,33.98 103.68,34.31 103.68,37.28 103.99,37.59 103.99,42.97 104.21,43.2 104.45,43.2 104.77,43.52 arc(104.83,43.75) 104.77,43.98 arc(104.71,44.2) 104.76,44.43 104.77,44.44 arc(104.83,44.67) 104.77,44.9 arc(104.71,45.13) 104.77,45.36 104.77,45.36 arc(104.83,45.59) 104.77,45.82 arc(104.71,46.04) 104.76,46.27 104.77,46.28 arc(104.83,46.51) 104.77,46.74 v1(104.37,47.43)
DDR4_COMP_CH0_DQ34: length 69.6
  TOP w0.149: v1(81.31,23.08) 81.12,23.06 U3.H3
  L14_SIG5 w0.081: v1(81.31,23.08) 81.31,22.47 81.01,22.17 77.19,22.17 76.9,22.46 76.9,28.05 74.85,30.09 74.85,30.83 74.65,31.04 74.65,33.2 74.84,33.39 74.84,39.46 75.45,40.06 75.45,40.17 80.65,45.38 81.42,45.38 81.87,45.83 84.43,45.83 84.72,46.11 84.72,48.35 87.37,51.01 88.18,51.01 88.68,50.51 90.73,50.51 91.35,51.13 93.28,51.13 93.66,51.51 94.04,51.51 94.6,52.08 95.2,52.08 95.89,52.77 96.16,52.77 96.4,53.01 96.97,53.01 97.33,52.64 97.87,52.64 98.24,53.02 99.44,53.02 100.52,51.94 100.54,51.94 100.75,51.72 100.75,51.7 100.93,51.53 101.49,51.53 101.82,51.2 102.13,51.2 102.46,51.53 102.88,51.53 103.39,51.02 103.75,51.02 104.21,51.48 104.52,51.48 104.98,51.02 105.32,51.02 105.78,50.56 106.12,50.56 106.58,50.1 106.91,50.1 107.37,49.64 107.71,49.64 108.09,49.25 108.6,49.25 108.72,49.13 108.72,48.55 108.52,48.35 v1(107.56,48.35)
DDR4_COMP_CH0_DQ35: length 69.4
  L14_SIG5 w0.081: v1(83.98,23.34) 84.24,23.34 84.41,23.5 84.41,24.29 84.63,24.52 86.99,24.52 87.36,24.88 87.36,30.59 89.78,33.01 97.2,33.01 97.28,32.93 97.28,31.67 97.36,31.59 97.53,31.59 97.61,31.67 97.61,32.93 97.69,33.01 97.87,33.01 97.95,32.93 97.95,31.67 98.03,31.59 98.2,31.59 98.28,31.67 98.28,32.93 98.36,33.01 98.54,33.01 98.62,32.93 98.62,31.67 98.7,31.59 98.87,31.59 98.95,31.67 98.95,32.93 99.04,33.01 99.21,33.01 99.29,32.93 99.29,31.67 99.37,31.59 99.54,31.59 99.62,31.67 99.62,32.93 99.71,33.01 99.88,33.01 99.96,32.93 99.96,31.67 100.04,31.59 100.21,31.59 100.29,31.67 100.29,32.93 100.38,33.01 100.55,33.01 100.63,32.93 100.63,31.67 100.71,31.59 100.88,31.59 100.97,31.67 100.97,32.93 101.05,33.01 101.22,33.01 101.3,32.93 101.3,31.67 101.38,31.59 101.55,31.59 101.64,31.67 101.64,31.93 101.72,32.02 102.36,32.02 102.44,32.1 102.44,32.27 102.36,32.35 101.72,32.35 101.64,32.43 101.64,32.6 101.72,32.69 102.36,32.69 102.44,32.77 102.44,32.94 102.36,33.02 101.72,33.02 101.64,33.1 101.64,33.52 101.76,33.65 104.38,33.65 104.74,34.01 104.74,34.42 104.66,34.5 104.1,34.5 104.02,34.58 104.02,34.75 104.1,34.84 104.66,34.84 104.74,34.92 104.74,35.09 104.66,35.17 104.1,35.17 104.02,35.25 104.02,35.43 104.1,35.51 104.66,35.51 104.74,35.59 104.74,35.76 104.66,35.84 104.1,35.84 104.02,35.92 104.02,36.1 104.1,36.18 104.66,36.18 104.74,36.26 104.74,36.43 104.66,36.51 104.1,36.51 104.02,36.59 104.02,36.77 104.1,36.85 104.66,36.85 104.74,36.93 104.74,42.7 104.96,42.92 105.32,42.92 105.56,43.16 105.56,43.52 arc(105.5,43.75) 105.56,43.98 arc(105.63,44.2) 105.57,44.43 105.56,44.44 arc(105.5,44.67) 105.56,44.9 arc(105.63,45.13) 105.56,45.36 105.56,45.36 arc(105.5,45.59) 105.56,45.82 arc(105.63,46.04) 105.57,46.27 v1(105.17,46.97)
DDR4_COMP_CH0_DQ36: length 69.7
  L14_SIG5 w0.081: v1(108.35,48.81) 107.49,48.81 106.94,49.36 106.61,49.36 106.15,49.82 105.64,49.82 105.36,50.1 104.98,50.1 104.52,50.56 104.01,50.56 103.73,50.28 103.21,50.28 102.93,50.56 102.62,50.56 102.34,50.28 101.62,50.28 101.33,50.56 101,50.56 100.54,51.02 100.3,51.02 99.12,52.2 98.37,52.2 97.77,51.6 97.36,51.6 96.8,52.16 96.57,52.16 95.98,51.57 95.64,51.57 95.33,51.27 95.01,51.27 94.36,50.62 94.31,50.59 93.74,50.59 93.35,50.2 92.94,50.2 92.35,49.6 91.14,49.6 91.09,49.55 90.37,49.55 89.91,50.01 86.98,50.01 85.36,48.39 85.36,48.06 85.28,47.98 85.14,47.98 85.05,47.9 85.05,47.72 85.14,47.64 85.28,47.64 85.36,47.56 85.36,47.39 85.28,47.31 85.14,47.31 85.05,47.23 85.05,47.05 85.14,46.97 85.28,46.97 85.36,46.89 85.36,46.72 85.28,46.64 85.14,46.64 85.05,46.56 85.05,46.38 85.14,46.3 85.28,46.3 85.36,46.22 85.36,45.46 84.95,45.04 84.46,45.04 84.38,45.12 84.38,45.3 84.3,45.38 84.13,45.38 84.04,45.3 84.04,45.12 83.96,45.04 83.79,45.04 83.71,45.12 83.71,45.3 83.63,45.38 83.46,45.38 83.37,45.3 83.37,45.12 83.29,45.04 83.12,45.04 83.04,45.12 83.04,45.3 82.96,45.38 82.79,45.38 82.7,45.3 82.7,45.12 82.62,45.04 82.45,45.04 82.37,45.12 82.37,45.3 82.29,45.38 82.11,45.38 82.03,45.3 82.03,45.12 81.95,45.04 81.17,45.04 80.8,44.67 80.53,44.67 75.18,39.32 75.18,33.25 74.98,33.06 74.98,31.18 75.19,30.97 75.19,30.23 77.23,28.19 77.23,22.6 77.33,22.5 77.69,22.5 77.77,22.58 77.77,23.69 77.86,23.77 78.03,23.77 78.11,23.69 78.11,22.58 78.19,22.5 78.69,22.5 78.81,22.62 78.81,22.82 78.89,22.91 79.8,22.91 79.98,23.09 v1(79.98,23.34)
DDR4_COMP_CH0_DQ37: length 68.6
  L14_SIG5 w0.081: v1(84.78,23.34) 84.78,23.65 84.86,23.74 86.73,23.74 87.7,24.71 87.7,30.32 88.23,30.85 89.82,30.85 89.9,30.93 89.9,31.32 89.82,31.4 89.14,31.4 89.06,31.48 89.06,31.65 89.14,31.73 89.82,31.73 89.9,31.82 89.9,32.48 89.98,32.56 90.15,32.56 90.23,32.48 90.23,30.93 90.31,30.85 90.49,30.85 90.57,30.93 90.57,32.48 90.65,32.56 90.82,32.56 90.9,32.48 90.9,30.93 90.98,30.85 91.16,30.85 91.24,30.93 91.24,32.48 91.32,32.56 91.49,32.56 91.57,32.48 91.57,30.93 91.66,30.85 91.83,30.85 91.91,30.93 91.91,32.48 91.99,32.56 92.16,32.56 92.24,32.48 92.24,30.93 92.33,30.85 92.66,30.85 92.79,30.98 92.79,31.96 93,32.17 93.47,32.17 93.55,32.25 93.55,32.6 93.64,32.68 93.81,32.68 93.89,32.6 93.89,32.25 93.97,32.17 94.14,32.17 94.22,32.25 94.22,32.6 94.31,32.68 94.48,32.68 94.56,32.6 94.56,32.25 94.64,32.17 94.81,32.17 94.9,32.25 94.9,32.6 94.98,32.68 95.15,32.68 95.23,32.6 95.23,32.25 95.31,32.17 96.23,32.17 96.32,32.09 96.32,31.53 96.23,31.45 95.43,31.45 95.34,31.35 95.34,30.59 95.47,30.45 95.81,30.45 95.89,30.53 95.89,30.86 95.97,30.94 96.14,30.94 96.22,30.86 96.22,30.53 96.31,30.45 97.24,30.45 97.37,30.58 97.37,31.17 97.46,31.26 102.6,31.26 102.78,31.44 102.78,33.21 102.88,33.31 104.6,33.31 105.07,33.78 105.07,34.83 105.78,35.54 105.78,37.36 105.54,37.6 105.54,42.16 105.84,42.46 106.12,42.46 106.33,42.67 106.33,43.47 106.36,43.52 arc(106.42,43.75) 106.36,43.98 arc(106.3,44.2) 106.36,44.43 106.36,44.44 arc(106.42,44.67) 106.36,44.9 arc(106.3,45.12) 106.36,45.35 106.36,45.36 arc(106.42,45.59) 106.36,45.82 arc(106.3,46.04) 106.36,46.27 106.36,46.28 arc(106.42,46.51) 106.36,46.74 106.36,46.74 arc(106.19,46.91) 105.96,46.97 105.96,46.97 arc(105.73,47.03) 105.56,47.2 105.56,47.2 105.33,47.43 105.17,47.43 arc(104.94,47.49) 104.77,47.65 v1(104.37,48.35)
DDR4_COMP_CH0_DQ38: length 68.6
  L14_SIG5 w0.081: v1(80.78,22.54) 80.56,22.54 80.38,22.72 80.38,23.6 80.24,23.73 78.85,23.73 78.77,23.81 78.77,24.16 78.69,24.24 77.7,24.24 77.62,24.33 77.62,24.5 77.7,24.58 78.69,24.58 78.77,24.66 78.77,24.83 78.69,24.92 77.7,24.92 77.62,25 77.62,25.17 77.7,25.25 78.69,25.25 78.77,25.33 78.77,25.5 78.69,25.59 77.7,25.59 77.62,25.67 77.62,25.84 77.7,25.92 78.69,25.92 78.77,26 78.77,26.17 78.69,26.26 77.7,26.26 77.62,26.34 77.62,26.51 77.7,26.59 78.69,26.59 78.77,26.67 78.77,26.85 78.69,26.93 77.7,26.93 77.62,27.01 77.62,27.18 77.7,27.26 78.4,27.26 78.48,27.34 78.48,27.57 75.59,30.46 75.59,31.04 75.32,31.32 75.32,32.92 75.51,33.11 75.51,39.18 80.67,44.33 81.02,44.33 81.39,44.7 85.08,44.7 85.74,45.36 85.74,48.11 86.64,49.01 88.18,49.01 88.55,48.64 90.66,48.64 91.28,49.27 93.38,49.27 93.88,49.77 94.33,49.77 94.7,50.14 95.01,50.14 95.4,50.52 95.76,50.52 96.29,51.05 96.87,51.05 97.22,50.71 97.76,50.71 98.31,51.27 98.85,51.27 99.56,50.56 99.74,50.56 100.14,50.16 100.48,50.16 100.97,49.66 101.52,49.66 101.82,49.36 102.13,49.36 102.44,49.66 103.11,49.66 103.42,49.36 103.73,49.36 104.03,49.66 104.55,49.66 105.17,49.04 v1(105.17,48.81)
DDR4_COMP_CH0_DQ39: length 67.7
  L14_SIG5 w0.081: v1(107.56,47.43) 107.16,46.74 arc(107.1,46.51) 107.16,46.28 107.16,46.27 arc(107.22,46.04) 107.16,45.82 arc(107.1,45.59) 107.16,45.36 107.16,45.35 arc(107.22,45.12) 107.16,44.9 arc(107.1,44.67) 107.15,44.44 107.16,44.43 arc(107.22,44.2) 107.16,43.98 arc(107.1,43.75) 107.15,43.52 107.16,43.51 arc(107.22,43.29) 107.16,43.06 arc(107.1,42.83) 107.15,42.6 107.16,42.6 arc(107.22,42.37) 107.16,42.15 107.15,42.12 arc(107.1,41.9) 107.16,41.68 107.16,41.67 arc(107.22,41.44) 107.16,41.22 arc(107.1,40.99) 107.15,40.76 107.16,40.75 arc(107.22,40.52) 107.16,40.3 arc(107.1,40.07) 107.15,39.84 107.16,39.83 arc(107.22,39.6) 107.16,39.38 arc(107.1,39.15) 107.15,38.92 107.16,38.91 arc(107.22,38.68) 107.16,38.46 arc(107.1,38.23) 107.15,38.01 107.16,37.99 arc(107.22,37.76) 107.16,37.54 106.94,37.32 106.45,37.32 106.12,36.99 106.12,36.33 106.2,36.25 107.2,36.25 107.28,36.17 107.28,36 107.2,35.92 106.2,35.92 106.12,35.84 106.12,35.66 106.2,35.58 107.2,35.58 107.28,35.5 107.28,35.33 107.2,35.25 106.2,35.25 106.12,35.17 106.12,34.99 106.2,34.91 107.2,34.91 107.28,34.83 107.28,34.66 107.2,34.58 106.2,34.58 106.12,34.49 106.12,34.3 105.85,34.03 105.85,33.06 105.77,32.97 103.77,32.97 103.69,32.89 103.69,32.56 103.77,32.48 104.84,32.48 104.92,32.4 104.92,32.22 104.84,32.14 103.77,32.14 103.69,32.06 103.69,31.89 103.77,31.81 104.84,31.81 104.92,31.73 104.92,31.55 104.84,31.47 103.77,31.47 103.69,31.39 103.69,30.75 103.53,30.6 102.57,30.6 102.41,30.44 102.41,30.26 102.26,30.11 101.91,30.11 101.82,30.2 101.82,30.83 101.74,30.91 101.57,30.91 101.49,30.83 101.49,30.2 101.41,30.11 101.24,30.11 101.15,30.2 101.15,30.83 101.07,30.91 100.9,30.91 100.82,30.83 100.82,30.2 100.74,30.11 100.56,30.11 100.48,30.2 100.48,30.83 100.4,30.91 100.23,30.91 100.15,30.83 100.15,30.2 100.07,30.11 99.89,30.11 99.81,30.2 99.81,30.83 99.73,30.91 99.56,30.91 99.48,30.83 99.48,30.2 99.4,30.11 99.22,30.11 99.14,30.2 99.14,30.83 99.06,30.91 98.89,30.91 98.81,30.83 98.81,30.2 98.73,30.11 95.12,30.11 94.97,30.27 94.97,31.75 94.89,31.84 93.27,31.84 93.15,31.72 93.15,30.66 93.01,30.52 88.37,30.52 88.07,30.22 88.07,24.27 86.76,22.96 84.21,22.96 83.98,22.74 v1(83.98,22.6)
DDR4_COMP_CH0_DQ40: length 51.2
  L14_SIG5 w0.081: v1(80.78,28.94) 80.78,30.04 80.7,30.12 80.33,30.12 80.25,30.04 80.25,29.41 80.16,29.33 79.99,29.33 79.91,29.41 79.91,30.04 79.83,30.12 79.66,30.12 79.57,30.04 79.57,29.41 79.49,29.33 79.32,29.33 79.24,29.41 79.24,30.04 79.16,30.12 78.99,30.12 78.9,30.04 78.9,29.41 78.79,29.3 78.68,29.3 78.57,29.41 78.57,30.37 77.78,31.16 77.78,31.96 76.64,33.1 76.64,38.71 80.49,42.56 84.57,42.56 84.65,42.64 84.65,43.13 84.75,43.24 84.9,43.24 84.98,43.15 84.98,42.64 85.07,42.56 85.24,42.56 85.32,42.64 85.32,43.13 85.42,43.24 85.57,43.24 85.66,43.15 85.66,42.64 85.74,42.56 86.5,42.56 86.78,42.84 86.78,44.71 87.31,45.23 87.31,45.7 87.64,46.03 88.59,46.03 88.67,45.95 88.67,45.6 88.75,45.52 88.92,45.52 89.01,45.6 89.01,45.95 89.09,46.03 90.21,46.03 90.6,45.64 90.88,45.64 91.21,45.64 91.29,45.72 91.29,46.16 91.37,46.24 91.55,46.24 91.63,46.16 91.63,45.72 91.71,45.64 92.36,45.64 arc(92.61,45.7) 92.79,45.88 92.79,45.89 arc(92.98,46.07) 93.23,46.14 93.23,46.14 arc(93.48,46.21) 93.66,46.39 arc(93.84,46.57) 94.09,46.64 94.09,46.64 arc(94.34,46.7) 94.52,46.88 94.53,46.89 arc(94.71,47.07) 94.96,47.14 94.96,47.14 arc(95.21,47.21) 95.39,47.39 arc(95.57,47.57) 95.82,47.64 95.82,47.64 arc(96.07,47.7) 96.25,47.88 96.26,47.89 arc(96.44,48.07) 96.69,48.14 96.7,48.14 arc(96.94,48.07) 97.12,47.89 arc(97.3,47.71) 97.55,47.64 97.56,47.64 98.08,47.86 98.23,48.01 98.58,48.01 98.7,47.89 99.6,47.89 arc(99.82,47.82) 99.99,47.66 v1(100.38,46.97)
DDR4_COMP_CH0_DQ41: length 50.8
  L14_SIG5 w0.081: v1(100.38,46.05) 99.98,45.35 arc(99.82,45.19) 99.59,45.13 99.26,45.13 98.89,44.76 98.89,41.37 98.61,41.1 98.11,41.1 97.96,40.95 97.96,39.75 97.81,39.59 97.33,39.59 97.33,39.59 96.78,40.14 96.36,40.14 95.83,39.61 95.56,39.61 94.94,40.24 93.2,40.24 92.45,39.48 91.85,39.48 90.77,40.56 89.96,40.56 89.71,40.31 88.59,40.31 88.46,40.18 88.46,38.93 88.37,38.84 88.2,38.84 88.13,38.92 88.13,40.23 88.05,40.32 87.89,40.32 87.79,40.21 87.79,38.93 87.7,38.84 87.53,38.84 87.46,38.92 87.46,40.23 87.37,40.32 86.47,40.32 86.37,40.21 86.37,39.1 86.45,39.02 86.78,39.02 86.86,38.94 86.86,38.77 86.78,38.69 86.45,38.69 86.37,38.61 86.37,38.43 86.45,38.35 86.78,38.35 86.86,38.27 86.86,38.1 86.78,38.02 86.45,38.02 86.37,37.93 86.37,37.76 86.45,37.68 86.78,37.68 86.86,37.6 86.86,37.43 86.78,37.35 86.45,37.35 86.37,37.26 86.37,37.09 86.45,37.01 86.78,37.01 86.86,36.93 86.86,36.76 86.78,36.67 86.45,36.67 86.37,36.59 86.37,36.42 86.45,36.34 86.78,36.34 86.86,36.26 86.86,36.09 86.78,36 86.45,36 86.37,35.92 86.37,35.75 86.45,35.67 86.78,35.67 86.86,35.59 86.86,35.41 86.78,35.33 86.45,35.33 86.37,35.25 86.37,35.08 86.45,35 86.78,35 86.86,34.92 86.86,34.74 86.78,34.66 86.45,34.66 86.37,34.58 86.37,34.41 86.45,34.33 86.78,34.33 86.86,34.25 86.86,34.07 86.78,33.99 86.45,33.99 86.37,33.91 86.37,32.87 85.96,32.46 84.4,32.46 84.31,32.37 84.31,31.85 84.4,31.77 84.79,31.77 84.87,31.69 84.87,31.51 84.79,31.43 84.4,31.43 84.31,31.35 84.31,31.18 84.4,31.1 84.79,31.1 84.87,31.02 84.87,30.84 84.79,30.76 84.4,30.76 84.31,30.68 84.31,30.51 84.4,30.43 84.79,30.43 84.87,30.34 84.87,30.17 84.79,30.09 84.4,30.09 84.31,30.01 84.31,29.84 84.4,29.76 84.79,29.76 84.87,29.67 84.87,29.5 84.79,29.42 84.4,29.42 84.31,29.34 84.31,28.25 84.43,28.14 v1(84.78,28.14)
DDR4_COMP_CH0_DQ42: length 50.9
  L14_SIG5 w0.081: v1(80.78,27.34) 81.88,27.34 81.96,27.42 81.96,27.85 82.04,27.93 82.21,27.93 82.3,27.85 82.3,27.42 82.38,27.34 83.19,27.34 83.31,27.46 83.31,28.2 83.11,28.4 81.43,28.4 81.18,28.65 81.18,30.32 80.99,30.51 79.86,30.51 79.71,30.51 79.25,30.96 79.08,30.96 78.82,30.7 78.71,30.7 78.59,30.83 78.59,30.94 78.87,31.23 78.87,31.34 78.75,31.46 78.63,31.46 78.35,31.18 78.23,31.18 78.11,31.3 78.11,31.42 78.4,31.7 78.4,32.09 76.98,33.51 76.98,38.57 80.62,42.21 86.97,42.21 87.27,42.51 87.27,42.99 87.12,43.14 87.12,43.32 87.27,43.48 87.27,43.66 87.12,43.81 87.12,43.99 87.27,44.15 87.27,44.48 87.49,44.7 87.87,44.7 87.96,44.78 87.96,45.16 88.04,45.24 88.21,45.24 88.29,45.16 88.29,44.78 88.37,44.7 89.36,44.7 89.44,44.78 89.44,45.18 89.52,45.26 89.69,45.26 89.78,45.18 89.78,44.78 89.86,44.7 90.75,44.7 91.18,44.27 91.83,44.27 91.85,44.28 arc(91.89,44.33) 91.93,44.39 arc(92.11,44.57) 92.36,44.64 92.37,44.64 arc(92.61,44.71) 92.79,44.89 arc(92.97,45.07) 93.21,45.14 93.23,45.14 arc(93.48,45.21) 93.66,45.39 arc(93.84,45.57) 94.08,45.64 94.09,45.64 arc(94.34,45.7) 94.52,45.88 94.53,45.89 arc(94.71,46.07) 94.96,46.14 arc(95.21,46.2) 95.39,46.39 arc(95.57,46.57) 95.82,46.64 95.82,46.64 arc(96.07,46.7) 96.25,46.88 96.26,46.89 arc(96.44,47.07) 96.69,47.14 96.7,47.14 arc(96.94,47.07) 97.12,46.89 arc(97.3,46.71) 97.55,46.64 97.56,46.64 arc(97.8,46.7) 97.99,46.88 97.99,46.89 arc(98.17,47.07) 98.42,47.14 99.24,47.42 v1(99.59,47.43)
DDR4_COMP_CH0_DQ43: length 50.5
  L14_SIG5 w0.081: v1(99.59,45.59) 99.06,45.59 98.76,45.29 98.42,45.14 arc(98.18,45.07) 97.99,44.89 97.98,44.88 arc(97.8,44.7) 97.56,44.64 97.55,44.64 arc(97.3,44.57) 97.12,44.39 arc(96.94,44.21) 96.7,44.14 96.69,44.14 arc(96.44,44.07) 96.26,43.89 96.26,43.88 arc(96.07,43.7) 95.82,43.64 95.81,43.64 arc(95.57,43.57) 95.39,43.39 arc(95.21,43.2) 94.96,43.14 94.96,43.14 arc(94.71,43.07) 94.53,42.89 94.52,42.88 arc(94.34,42.7) 94.09,42.64 94.09,42.64 arc(93.9,42.6) 93.74,42.49 93.44,42.19 93.07,42.19 92.38,41.51 90.24,41.51 89.39,40.66 84.78,40.66 84.6,40.47 80.44,40.47 78.09,38.11 78.09,33.97 79.4,32.65 79.88,32.65 79.96,32.57 79.96,31.85 80.04,31.77 80.22,31.77 80.3,31.85 80.3,32.57 80.38,32.65 80.55,32.65 80.63,32.57 80.63,31.85 80.71,31.77 80.89,31.77 80.97,31.85 80.97,32.57 81.05,32.65 81.97,32.65 82.26,32.36 82.26,30.28 82.34,30.2 82.52,30.2 82.6,30.28 82.6,31.96 82.68,32.04 82.85,32.04 82.93,31.96 82.93,30.28 83.01,30.2 83.19,30.2 83.27,30.28 83.27,32.06 83.39,32.18 83.84,32.18 83.98,32.05 v1(83.98,27.34)
DDR4_COMP_CH0_DQ44: length 51.8
  L14_SIG5 w0.081: v1(79.98,27.34) 79.55,27.77 78.69,27.77 76.06,30.4 76.06,31.23 75.78,31.51 75.78,32.73 75.97,32.92 75.97,38.99 80.86,43.87 84.17,43.87 84.53,44.23 85.92,44.23 86.1,44.41 86.1,45.06 86.2,45.17 86.2,47.82 86.49,48.11 86.91,48.11 86.99,48.03 86.99,47.66 87.07,47.58 87.25,47.58 87.33,47.66 87.33,48.03 87.41,48.11 88.49,48.11 88.57,48.03 88.57,47.74 88.67,47.64 88.82,47.64 88.91,47.72 88.91,48.08 89.05,48.22 90.01,48.22 90.6,47.64 92.36,47.64 92.36,47.64 arc(92.61,47.71) 92.79,47.89 92.79,47.89 arc(92.98,48.07) 93.23,48.14 93.23,48.14 arc(93.48,48.21) 93.66,48.39 arc(93.84,48.57) 94.08,48.64 94.09,48.64 arc(94.34,48.71) 94.52,48.89 94.53,48.89 arc(94.71,49.07) 94.96,49.14 94.96,49.14 arc(95.21,49.21) 95.39,49.39 arc(95.57,49.57) 95.82,49.64 95.82,49.64 arc(96.07,49.7) 96.25,49.88 96.26,49.89 arc(96.44,50.07) 96.69,50.14 96.81,50.14 97.22,49.72 97.88,49.72 98.31,50.15 arc(98.37,50.14) 98.42,50.14 98.79,50.19 98.79,50.19 arc(99.02,50.13) 99.19,49.96 arc(99.36,49.79) 99.59,49.73 99.59,49.73 arc(99.82,49.67) 99.98,49.5 99.99,49.5 arc(100.15,49.33) 100.38,49.27 100.39,49.27 arc(100.62,49.2) 100.78,49.04 arc(100.95,48.87) 101.18,48.81 101.18,48.81 arc(101.41,48.75) 101.58,48.58 arc(101.74,48.41) 101.97,48.35 101.99,48.35 arc(102.21,48.28) 102.38,48.12 arc(102.54,47.95) 102.77,47.89 102.78,47.89 arc(103.01,47.82) 103.17,47.66 v1(103.57,46.97)
DDR4_COMP_CH0_DQ45: length 49.1
  L14_SIG5 w0.081: v1(102.77,45.59) 102.38,44.9 arc(102.21,44.73) 101.99,44.67 101.98,44.67 arc(101.75,44.6) 101.58,44.44 arc(101.41,44.27) 101.18,44.21 101.17,44.21 arc(100.95,44.14) 100.78,43.98 arc(100.72,43.75) 100.78,43.52 100.78,43.51 arc(100.84,43.29) 100.78,43.06 100.59,41.89 arc(100.65,41.64) 100.59,41.39 100.59,41.39 arc(100.52,41.14) 100.59,40.89 100.59,40.88 arc(100.65,40.63) 100.59,40.39 100.58,40.38 arc(100.52,40.13) 100.59,39.89 arc(100.65,39.64) 100.59,39.39 100.59,39.39 arc(100.52,39.14) 100.59,38.89 arc(100.65,38.64) 100.59,38.39 100.59,38.39 arc(100.4,38.2) 100.15,38.14 arc(99.9,38.07) 99.72,37.89 99.72,37.89 arc(99.54,37.7) 99.29,37.64 99.27,37.64 arc(99.04,37.57) 98.87,37.41 98.86,37.39 98.84,37.38 arc(98.65,37.25) 98.42,37.2 94.22,37.2 94.14,37.12 94.14,36.64 94.06,36.56 93.88,36.56 93.8,36.64 93.8,37.12 93.72,37.2 93.55,37.2 93.47,37.12 93.47,36.64 93.39,36.56 93.21,36.56 93.13,36.64 93.13,37.18 93.05,37.26 92.88,37.26 92.8,37.18 92.8,36.64 92.72,36.56 92.54,36.56 92.46,36.64 92.46,37.52 92.38,37.6 92.24,37.6 92.13,37.49 92.13,36.64 92.04,36.56 91.87,36.56 91.79,36.64 91.79,37.12 91.71,37.2 91.54,37.2 91.46,37.12 91.46,36.64 91.37,36.56 91.2,36.56 91.12,36.64 91.12,37.5 91.03,37.59 90.87,37.59 90.78,37.51 90.78,36.64 90.7,36.56 90.53,36.56 90.45,36.64 90.45,37.5 90.36,37.59 90.2,37.59 90.11,37.51 90.11,36.64 90.03,36.56 89.86,36.56 89.78,36.64 89.78,37.12 89.7,37.2 88.34,37.2 88.26,37.12 88.26,36.59 88.34,36.51 89.29,36.51 89.37,36.43 89.37,36.26 89.29,36.18 88.34,36.18 88.26,36.1 88.26,35.92 88.34,35.84 89.29,35.84 89.37,35.76 89.37,35.59 89.29,35.51 88.34,35.51 88.26,35.43 88.26,35.25 88.34,35.17 89.29,35.17 89.37,35.09 89.37,34.92 89.29,34.84 88.34,34.84 88.26,34.76 88.26,33.8 85.84,31.37 85.84,30.13 85.97,30.01 85.97,28 85.71,27.75 85.44,27.75 85.03,27.34 v1(84.78,27.34)
DDR4_COMP_CH0_DQ46: length 51.3
  L14_SIG5 w0.081: v1(80.78,26.54) 80.5,26.54 80.41,26.63 80.41,28.42 80.32,28.51 78.42,28.51 76.85,30.08 76.85,31.74 76.56,32.03 76.35,32.03 76.12,32.26 76.12,32.59 76.31,32.78 76.31,38.85 80.99,43.53 84.31,43.53 84.53,43.75 86.18,43.75 86.45,44.02 86.45,44.85 86.84,45.24 86.84,46.26 87.79,47.21 87.79,47.23 88.4,47.23 88.52,47.11 88.52,46.49 88.65,46.36 89.19,46.36 89.27,46.45 89.27,47.25 89.39,47.37 89.51,47.37 89.61,47.26 89.61,46.51 89.76,46.36 90.02,46.36 90.15,46.49 90.15,46.65 90.25,46.76 90.89,46.76 91.27,47.14 93.23,47.14 arc(93.48,47.21) 93.66,47.39 arc(93.84,47.57) 94.09,47.64 94.09,47.64 arc(94.34,47.7) 94.52,47.88 94.53,47.89 arc(94.71,48.07) 94.96,48.14 94.96,48.14 arc(95.21,48.21) 95.39,48.39 arc(95.57,48.57) 95.81,48.64 95.82,48.64 arc(96.07,48.7) 96.26,48.88 96.26,48.89 arc(96.44,49.07) 96.69,49.14 96.69,49.14 arc(96.94,49.07) 97.12,48.89 arc(97.3,48.71) 97.55,48.64 97.56,48.64 97.92,48.67 98.26,49.01 98.58,49.01 98.78,48.81 99.59,48.81 arc(99.82,48.75) 99.99,48.58 arc(100.15,48.41) 100.38,48.35 100.39,48.35 arc(100.62,48.28) 100.78,48.12 arc(100.95,47.95) 101.18,47.89 101.19,47.89 arc(101.41,47.82) 101.58,47.66 101.58,47.65 arc(101.75,47.49) 101.98,47.43 v1(102.77,47.43)
DDR4_COMP_CH0_DQ47: length 49
  L14_SIG5 w0.081: v1(83.98,26.54) 84.23,26.54 84.65,26.96 86.05,26.96 86.32,27.23 86.32,30.13 86.18,30.27 86.18,31.17 89.7,34.69 89.7,36.06 89.86,36.21 90.19,36.21 90.28,36.13 90.28,35.31 90.37,35.22 90.53,35.22 90.61,35.3 90.61,36.13 90.69,36.21 90.87,36.21 90.95,36.13 90.95,35.31 91.04,35.22 91.2,35.22 91.28,35.3 91.28,36.13 91.36,36.21 95.12,36.21 95.2,36.29 95.2,36.76 95.28,36.84 95.46,36.84 95.54,36.76 95.54,36.29 95.62,36.21 95.79,36.21 95.87,36.29 95.87,36.76 95.95,36.84 96.13,36.84 96.21,36.76 96.21,36.29 96.29,36.21 97.16,36.21 97.24,36.29 97.24,36.78 97.32,36.87 97.5,36.87 97.58,36.78 97.58,36.29 97.66,36.21 98.48,36.21 98.69,36.43 99.03,36.43 99.12,36.51 99.12,37.16 99.2,37.24 99.37,37.24 99.45,37.16 99.45,36.5 99.53,36.42 99.7,36.42 99.79,36.5 99.79,37.16 99.87,37.24 100.04,37.24 100.12,37.16 100.12,36.31 100.21,36.23 100.38,36.23 100.46,36.31 100.46,37.4 100.54,37.49 100.71,37.49 100.79,37.41 100.79,36.51 100.87,36.43 101.73,36.43 101.89,36.59 101.89,37.3 101.73,37.47 101.21,37.47 101.13,37.55 101.13,37.72 101.21,37.8 101.44,37.8 101.52,37.88 101.52,43.29 arc(101.53,43.41) 101.58,43.52 101.58,43.52 arc(101.75,43.69) 101.98,43.75 101.98,43.75 arc(102.21,43.81) 102.38,43.98 arc(102.54,44.14) 102.77,44.21 102.78,44.21 arc(103.01,44.27) 103.17,44.44 103.18,44.44 arc(103.23,44.67) 103.17,44.9 arc(103.11,45.12) 103.17,45.35 103.17,45.36 v1(103.57,46.05)
DDR4_COMP_CH0_DQ48: length 33.3
  L07_SIG3 w0.089: v1(100.3,24.14) 99.92,23.76 99.26,23.76 99.08,23.94 99.08,24.29 98.98,24.39 98.25,24.39 98.15,24.49 98.15,24.63 98.25,24.73 98.98,24.73 99.08,24.83 99.08,24.97 98.98,25.07 98.25,25.07 98.15,25.18 98.15,25.32 98.25,25.42 98.98,25.42 99.08,25.52 99.08,25.86 98.99,25.95 98.86,25.95 98.77,26.04 98.77,26.2 98.86,26.29 98.99,26.29 99.08,26.38 99.08,26.55 98.99,26.64 98.86,26.64 98.77,26.72 98.77,26.89 98.86,26.98 98.99,26.98 99.08,27.07 99.08,27.23 98.99,27.32 98.86,27.32 98.77,27.41 98.77,28.32 98.88,28.42 99.03,28.42 99.13,28.52 99.13,28.66 99.03,28.76 98.88,28.76 98.77,28.86 98.77,29 98.88,29.1 99.03,29.1 99.13,29.2 99.13,29.35 99.03,29.45 98.88,29.45 98.77,29.55 98.77,29.89 99.15,30.26 99.15,31.29 99.31,31.45 103.87,31.45 107.9,35.47 108.43,35.47 109.49,36.53 109.49,37.77 arc(109.5,37.89) 109.55,38 arc(109.61,38.22) 109.55,38.45 109.55,38.46 arc(109.49,38.68) 109.55,38.91 109.55,38.92 arc(109.61,39.15) 109.55,39.38 arc(109.49,39.6) 109.54,39.83 109.55,39.84 arc(109.61,40.07) 109.55,40.3 arc(109.49,40.52) 109.54,40.75 109.55,40.76 arc(109.61,40.99) 109.55,41.22 arc(109.49,41.44) 109.54,41.67 109.56,41.69 arc(109.61,41.91) 109.55,42.14 v1(109.15,42.83)
DDR4_COMP_CH0_DQ49: length 31.1
  L07_SIG3 w0.089: v1(113.13,44.21) 113.94,44.21 arc(114.16,44.14) 114.33,43.98 114.33,43.97 arc(114.5,43.81) 114.73,43.75 114.73,43.75 arc(114.96,43.68) 115.13,43.52 arc(115.29,43.35) 115.52,43.29 115.53,43.29 arc(115.75,43.22) 115.92,43.06 arc(115.98,42.83) 115.93,42.6 115.91,42.58 arc(115.86,42.36) 115.92,42.14 arc(115.98,41.91) 115.93,41.69 115.92,41.67 arc(115.86,41.44) 115.92,41.22 arc(115.98,40.99) 115.93,40.76 115.92,40.75 arc(115.86,40.52) 115.92,40.3 arc(115.98,40.07) 115.92,39.84 115.92,39.83 arc(115.86,39.6) 115.92,39.38 arc(115.98,39.15) 115.92,38.92 115.92,38.91 arc(115.86,38.68) 115.92,38.46 115.92,38.45 arc(115.98,38.22) 115.92,38 115.58,37.65 115.58,37.21 115.67,37.12 116.23,37.12 116.32,37.03 116.32,36.86 116.23,36.78 115.67,36.78 115.58,36.69 115.58,36.52 115.67,36.43 116.23,36.43 116.32,36.34 116.32,36.18 116.23,36.09 115.67,36.09 115.58,36 115.58,35.86 115.05,35.33 115.05,35.2 115.37,34.88 115.37,34.75 115.25,34.64 115.13,34.64 114.87,34.9 114.74,34.9 113.85,34 113.85,33.24 113.46,32.85 113.46,32.61 110.51,29.66 109.33,29.66 106.97,27.29 106.97,26.94 106.14,26.11 105.74,26.11 105.52,25.89 105.52,25.63 105.21,25.31 104.94,25.31 104.57,24.94 v1(104.3,24.94)
DDR4_COMP_CH0_DQ50: length 34.7
  L07_SIG3 w0.089: v1(101.1,23.34) 101.56,23.34 101.65,23.25 101.65,22.65 101.78,22.51 102.18,22.51 102.3,22.64 102.3,23.63 102.21,23.72 101.84,23.72 101.75,23.81 101.75,23.98 101.84,24.07 102.21,24.07 102.3,24.15 102.3,26.61 102.39,26.7 102.8,26.7 102.89,26.79 102.89,26.96 102.8,27.04 102.39,27.04 102.3,27.13 102.3,27.48 102.52,27.69 103.58,27.69 104.27,28.38 104.27,29.18 104.5,29.41 105.25,29.41 105.49,29.65 105.49,29.77 105.25,30.01 105.25,30.14 105.37,30.26 105.5,30.26 105.73,30.02 105.86,30.02 105.98,30.13 105.98,30.26 105.88,30.36 105.88,30.49 107.88,32.49 107.88,33.37 108.17,33.66 110.06,33.66 111.12,34.72 111.6,34.72 112.11,35.23 arc(112.2,35.37) 112.23,35.53 112.23,37.45 arc(112.22,37.49) 112.21,37.53 111.93,38.01 arc(111.88,38.23) 111.94,38.46 arc(112,38.68) 111.94,38.91 111.94,38.92 arc(111.88,39.15) 111.94,39.38 arc(112,39.6) 111.94,39.83 111.94,39.84 arc(111.88,40.07) 111.94,40.3 arc(112,40.52) 111.94,40.75 111.93,40.76 arc(111.88,40.99) 111.94,41.22 arc(112,41.44) 111.94,41.67 111.94,41.68 arc(111.88,41.9) 111.93,42.12 111.95,42.15 arc(112,42.37) 111.94,42.6 arc(111.77,42.76) 111.54,42.83 111.54,42.83 arc(111.31,42.89) 111.14,43.06 arc(110.97,43.22) 110.74,43.29 arc(110.51,43.35) 110.35,43.52 110.34,43.52 arc(110.18,43.68) 109.95,43.75 v1(109.15,43.75)
DDR4_COMP_CH0_DQ51: length 34.7
  L07_SIG3 w0.089: v1(109.95,44.21) 110.86,44.21 111.28,44.63 111.67,44.63 112.12,44.17 112.5,44.17 112.96,44.63 113.27,44.63 113.72,45.09 114.1,45.09 114.48,44.71 114.79,44.71 115.25,44.25 115.63,44.25 116.09,43.79 116.47,43.79 116.72,43.54 116.72,41.59 116.73,41.59 116.73,41.28 116.72,41.28 116.72,38.39 116.72,38.38 116.72,38.07 116.72,38.07 116.72,36.47 116.66,36.41 116.66,35.62 116.34,35.3 116.34,35.01 114.3,32.96 114.05,32.96 113.8,32.71 113.8,32.47 110.65,29.32 109.48,29.32 107.31,27.15 107.31,26.61 106.02,25.31 105.74,25.31 105.52,25.09 105.52,24.83 105.2,24.51 104.94,24.51 104.72,24.29 104.72,23.76 v1(104.3,23.34)
DDR4_COMP_CH0_DQ52: length 33.3
  L07_SIG3 w0.089: v1(109.95,42.37) 110.35,41.67 arc(110.41,41.44) 110.34,41.22 arc(110.28,40.99) 110.34,40.76 110.35,40.75 arc(110.41,40.52) 110.34,40.3 arc(110.28,40.07) 110.34,39.84 110.35,39.83 arc(110.41,39.6) 110.34,39.38 arc(110.28,39.15) 110.34,38.92 110.35,38.91 arc(110.41,38.68) 110.34,38.46 arc(110.28,38.23) 110.34,38.01 110.34,38 arc(110.39,37.89) 110.41,37.77 110.41,36.09 109.3,34.98 107.89,34.98 104.01,31.1 100.34,31.1 100.25,31.01 100.25,30.57 100.16,30.48 99.99,30.48 99.91,30.57 99.91,31.01 99.82,31.1 99.66,31.1 99.53,30.97 99.53,30.11 99.62,30.02 100.38,30.02 100.47,29.93 100.47,29.77 100.38,29.68 99.97,29.68 99.88,29.59 99.88,28.75 100.07,28.56 100.56,28.56 100.69,28.43 100.69,27.85 100.6,27.76 99.97,27.76 99.88,27.67 99.88,27.06 100.01,26.93 100.59,26.93 100.71,26.81 100.71,26.25 100.6,26.14 99.99,26.14 99.88,26.03 99.88,24.71 100.02,24.56 100.59,24.56 100.7,24.46 100.7,23.43 100.61,23.34 v1(100.3,23.34)
DDR4_COMP_CH0_DQ53: length 31.5
  L07_SIG3 w0.089: v1(112.34,43.75) 113.14,43.75 arc(113.37,43.68) 113.53,43.52 113.53,43.52 arc(113.7,43.35) 113.93,43.29 113.93,43.29 arc(114.16,43.22) 114.33,43.06 arc(114.5,42.89) 114.73,42.83 114.73,42.83 arc(114.96,42.76) 115.13,42.6 arc(115.19,42.37) 115.13,42.15 115.12,42.12 arc(115.06,41.9) 115.13,41.68 115.13,41.67 arc(115.19,41.44) 115.13,41.22 arc(115.06,40.99) 115.12,40.76 115.13,40.75 arc(115.19,40.52) 115.13,40.3 arc(115.06,40.07) 115.12,39.84 115.13,39.83 arc(115.19,39.6) 115.13,39.38 arc(115.06,39.15) 115.12,38.92 115.13,38.91 arc(115.19,38.68) 115.13,38.46 arc(115.06,38.23) 115.12,38.01 115.13,38 arc(115.17,37.89) 115.19,37.77 115.19,35.99 111.91,32.71 111.91,31.6 110.32,30 109.19,30 107.88,28.69 107.76,28.69 107.66,28.79 107.54,28.79 107.42,28.67 107.42,28.55 107.52,28.45 107.52,28.33 106.63,27.44 106.63,27.08 106.51,26.96 105.75,26.96 105.47,26.69 105.47,26.38 105.25,26.16 104.95,26.16 104.67,25.89 104.67,25.58 104.45,25.36 104.01,25.36 103.92,25.28 103.92,23.02 103.99,22.95 105.22,22.95 105.3,23.04 105.3,23.21 105.18,23.34 v1(105.1,23.34)
DDR4_COMP_CH0_DQ54: length 31.8
  L07_SIG3 w0.089: v1(112.34,42.83) 112.73,42.14 arc(112.8,41.91) 112.74,41.69 112.73,41.67 arc(112.67,41.44) 112.73,41.22 arc(112.8,40.99) 112.74,40.76 112.73,40.75 arc(112.67,40.52) 112.73,40.3 arc(112.8,40.07) 112.74,39.84 112.73,39.83 arc(112.67,39.6) 112.73,39.38 arc(112.8,39.15) 112.74,38.92 112.73,38.91 arc(112.67,38.68) 112.73,38.46 112.74,38.45 arc(112.8,38.22) 112.73,38 arc(112.69,37.89) 112.67,37.77 112.67,34.98 110.99,33.3 110.96,33.3 110.96,33.3 110.6,33.3 110.6,33.3 110.31,33.3 110.31,33.3 109.63,33.3 108.52,32.19 108.39,32.19 108.29,32.29 108.16,32.29 108.05,32.17 108.05,32.04 108.15,31.94 108.15,31.82 108.03,31.7 107.9,31.7 107.8,31.8 107.68,31.8 107.56,31.69 107.56,31.56 107.66,31.46 107.66,31.33 107.55,31.22 107.42,31.22 107.32,31.32 107.19,31.32 107.08,31.2 107.08,31.07 107.18,30.97 107.18,30.85 107.06,30.73 106.93,30.73 106.83,30.83 106.71,30.83 106.59,30.72 106.59,30.59 106.69,30.49 106.69,30.36 105.47,29.14 105.47,28.78 105.25,28.56 104.94,28.56 103.23,26.86 103.23,24.78 103.14,24.7 102.73,24.7 102.64,24.61 102.64,24.44 102.73,24.35 103.14,24.35 103.23,24.26 103.23,24.1 103.14,24.01 102.73,24.01 102.64,23.92 102.64,23.76 102.73,23.67 103.14,23.67 103.23,23.58 103.23,22.25 103.14,22.15 101.48,22.15 v1(101.1,22.54)
DDR4_COMP_CH0_DQ55: length 32.7
  L07_SIG3 w0.089: v1(113.13,42.37) 113.3,42.08 113.53,41.67 arc(113.59,41.44) 113.53,41.22 arc(113.47,40.99) 113.53,40.76 113.53,40.75 arc(113.59,40.52) 113.53,40.3 arc(113.47,40.07) 113.53,39.84 113.53,39.83 arc(113.59,39.6) 113.53,39.38 arc(113.47,39.15) 113.53,38.92 113.53,38.91 arc(113.59,38.68) 113.53,38.46 arc(113.47,38.23) 113.53,38.01 113.53,38 arc(113.58,37.89) 113.59,37.77 113.59,37.19 113.49,37.09 113.12,37.09 113.02,36.99 113.02,36.85 113.12,36.75 113.49,36.75 113.59,36.65 113.59,36.09 113.02,35.51 113.02,34.8 111.18,32.96 111.18,32.39 111.17,32.38 111.17,32.36 110.78,31.97 110.13,31.97 109.52,32.58 109.39,32.58 109.27,32.46 109.27,32.34 109.49,32.12 109.49,32 109.37,31.88 109.25,31.88 109.03,32.09 108.91,32.09 108.79,31.98 108.79,31.85 109,31.64 109,31.51 108.89,31.39 108.76,31.39 108.55,31.61 108.42,31.61 108.3,31.49 108.3,31.37 108.52,31.15 108.52,31.03 108.4,30.91 108.28,30.91 108.06,31.12 107.94,31.12 107.82,31.01 107.82,30.88 108.03,30.67 108.03,30.54 107.3,29.81 107.17,29.81 106.96,30.02 106.83,30.02 106.72,29.9 106.72,29.78 106.93,29.56 106.93,29.44 106.81,29.32 106.69,29.32 106.47,29.53 106.35,29.53 106.23,29.42 106.23,29.29 106.44,29.08 106.44,28.95 106.01,28.51 105.74,28.51 105.52,28.29 105.52,28.03 105.21,27.71 104.94,27.71 104.72,27.49 104.72,27.23 104.46,26.96 103.82,26.96 103.58,26.72 103.58,26.37 103.68,26.27 103.81,26.27 103.91,26.17 103.91,26.03 103.81,25.93 103.68,25.93 103.58,25.83 103.58,22.6 103.74,22.44 104.2,22.44 v1(104.3,22.54)
DDR4_COMP_CH0_DQ56: length 41.3
  L05_SIG2 w0.081: v1(113.93,43.75) 113.92,43.74 112.99,43.74 112.51,43.26 112.22,43.26 111.95,42.99 111.95,37.15 112.32,36.78 112.32,36.2 112.21,36.09 111.98,36.09 111.9,36.01 111.9,35.83 111.98,35.75 112.24,35.75 112.32,35.67 112.32,34.95 112.22,34.85 111.8,34.85 111.71,34.94 111.71,35.15 111.63,35.24 111.46,35.24 111.38,35.15 111.38,34.94 111.3,34.85 110.92,34.85 110.79,34.98 110.79,35.77 110.71,35.85 110.39,35.85 110.32,35.78 110.32,34.57 110.24,34.49 109.14,34.49 109.06,34.41 109.06,34.23 109.14,34.15 110.24,34.15 110.35,34.04 110.35,33.93 110.24,33.82 109.14,33.82 109.06,33.74 109.06,33.56 109.14,33.48 110.45,33.48 110.54,33.4 110.54,33.23 110.45,33.15 109.14,33.15 109.06,33.07 109.06,32.89 109.14,32.81 110.24,32.81 110.32,32.73 110.32,32.39 110.19,32.26 107.89,32.26 107.4,31.77 104.24,31.77 103.66,31.19 101.32,31.19 101.1,30.97 101.1,30.63 101.02,30.55 100.1,30.55 100.02,30.47 100.02,30.3 100.1,30.22 101.02,30.22 101.1,30.14 101.1,29.96 101.02,29.88 100.1,29.88 100.02,29.8 100.02,29.63 100.1,29.55 101.02,29.55 101.1,29.47 v1(101.1,28.94)
DDR4_COMP_CH0_DQ57: length 39.5
  L05_SIG2 w0.081: v1(117.12,42.83) 117.22,42.72 117.22,42.35 117.15,42.28 116.88,42.28 116.71,42.11 116.71,33.91 116.72,33.9 116.72,33.57 116.71,33.57 116.71,32.73 116.72,32.72 116.72,32.4 116.71,32.39 116.71,32.05 116.63,31.97 116.35,31.97 116.27,31.89 116.27,31.72 116.35,31.63 116.66,31.63 116.74,31.55 116.74,31.38 116.66,31.3 116.35,31.3 116.27,31.22 116.27,31.05 116.35,30.96 116.66,30.96 116.74,30.88 116.74,30.71 116.66,30.63 116.35,30.63 116.27,30.55 116.27,30.37 116.35,30.29 116.66,30.29 116.74,30.21 116.74,29.68 116.66,29.6 116.28,29.6 116.2,29.52 116.2,29.35 116.28,29.27 116.66,29.27 116.74,29.19 116.74,27.03 116.65,26.94 108.83,26.94 108.74,27.02 108.74,27.82 108.66,27.9 108.49,27.9 108.41,27.82 108.41,26.87 108.32,26.78 108.16,26.78 108.07,26.87 108.07,27.82 107.99,27.9 107.82,27.9 107.74,27.82 107.74,26.87 107.66,26.79 107.49,26.79 107.4,26.88 107.4,27.82 107.32,27.9 107.15,27.9 107.07,27.82 107.07,26.95 106.99,26.87 106.81,26.87 106.73,26.95 106.73,27.82 106.65,27.9 106.48,27.9 106.4,27.82 106.4,27.02 106.32,26.94 105.75,26.94 105.52,27.17 105.52,27.71 v1(105.1,28.14)
DDR4_COMP_CH0_DQ58: length 40.2
  L05_SIG2 w0.081: v1(113.93,42.83) 113.91,42.8 113,42.8 112.76,42.56 112.76,37.45 112.84,37.37 113.12,37.37 113.2,37.29 113.2,37.12 113.12,37.04 112.75,37.04 112.66,36.95 112.66,36.78 112.74,36.7 113.12,36.7 113.2,36.62 113.2,36.45 113.12,36.37 112.75,36.37 112.66,36.28 112.66,36.11 112.74,36.03 113.12,36.03 113.2,35.95 113.2,35.78 113.12,35.7 112.75,35.7 112.67,35.61 112.67,35.46 112.76,35.36 113.12,35.36 113.2,35.28 113.2,35.11 113.12,35.03 112.75,35.03 112.67,34.94 112.67,34.79 112.76,34.69 113.12,34.69 113.2,34.61 113.2,34.44 113.12,34.35 112.8,34.35 112.71,34.26 112.71,34.1 112.79,34.02 113.12,34.02 113.2,33.94 113.2,33.77 113.12,33.68 112.84,33.68 112.76,33.6 112.76,33.43 112.84,33.35 113.12,33.35 113.2,33.27 113.2,33.09 113.12,33.01 112.84,33.01 112.76,32.93 112.76,32.07 112.65,31.96 111.67,31.96 111.59,32.04 111.59,32.92 111.67,33.01 112.17,33.01 112.25,33.09 112.25,33.26 112.17,33.34 111.67,33.34 111.59,33.42 111.59,33.59 111.67,33.68 112.19,33.68 112.28,33.76 112.28,33.93 112.19,34.01 111.67,34.01 111.59,34.09 111.59,34.43 111.51,34.51 111.34,34.51 111.26,34.43 111.26,32.04 111.14,31.93 108.03,31.93 107.54,31.43 104.38,31.43 103.8,30.85 101.97,30.85 101.76,30.64 101.76,27.43 101.66,27.34 v1(101.1,27.34)
DDR4_COMP_CH0_DQ59: length 38.7
  L05_SIG2 w0.081: v1(104.3,27.34) 103.86,27.34 103.63,27.11 103.63,26.64 103.48,26.49 103.13,26.49 102.98,26.64 102.98,27.6 103.06,27.68 103.8,27.68 103.89,27.77 103.89,27.93 103.8,28.02 103.06,28.02 102.98,28.1 102.98,29.56 103.21,29.79 104.16,29.79 104.68,30.31 106.19,30.31 106.7,29.8 107.95,29.8 108.37,30.22 114.95,30.22 115.16,30.42 115.16,34.78 115.04,34.9 114.62,34.9 114.53,34.99 114.53,35.14 114.62,35.23 115.04,35.23 115.12,35.31 115.12,35.49 115.04,35.57 114.62,35.57 114.54,35.65 114.54,35.82 114.62,35.9 115.04,35.9 115.12,35.98 115.12,36.16 115.04,36.24 114.62,36.24 114.54,36.32 114.54,36.49 114.62,36.57 115.04,36.57 115.12,36.65 115.12,36.83 115.04,36.91 114.62,36.91 114.54,36.99 114.54,37.16 114.62,37.24 115.04,37.24 115.12,37.32 115.12,43.11 115.23,43.22 115.82,43.22 116.12,42.92 116.16,42.92 116.17,42.92 116.47,42.92 116.48,42.92 116.53,42.92 116.79,43.17 v1(117.12,43.75)
DDR4_COMP_CH0_DQ60: length 41.4
  L05_SIG2 w0.081: v1(114.73,44.21) 113.84,44.21 113.36,44.69 112.98,44.69 112.59,44.3 112.2,44.3 111.74,43.84 111.32,43.84 111.17,43.68 111.17,42.52 111.17,42.52 111.17,38.53 111.17,36.36 110.99,36.19 107.87,36.19 107.72,36.04 107.72,35.59 107.8,35.5 108.7,35.5 108.8,35.4 108.8,35.25 108.72,35.17 107.8,35.17 107.72,35.09 107.72,34.92 107.8,34.83 108.44,34.83 108.53,34.75 108.53,34.58 108.44,34.5 107.8,34.5 107.72,34.42 107.72,34.24 107.8,34.16 108.53,34.16 108.62,34.08 108.62,33.91 108.54,33.83 107.8,33.83 107.72,33.75 107.72,33.57 107.8,33.49 108.56,33.49 108.65,33.4 108.65,33.24 108.57,33.16 107.8,33.16 107.72,33.08 107.72,32.57 107.26,32.1 104.1,32.1 103.52,31.52 99.54,31.52 99.13,31.11 99.13,29.1 99.13,29.09 99.13,26.24 99.22,26.15 99.83,26.15 99.92,26.24 99.92,26.96 v1(100.3,27.34)
DDR4_COMP_CH0_DQ61: length 39.5
  L05_SIG2 w0.081: v1(105.1,27.34) 105.1,27.1 105.5,26.7 105.5,26.24 105.59,26.15 117.27,26.15 117.49,26.36 117.49,27.82 117.41,27.9 117.19,27.9 117.11,27.98 117.11,28.15 117.19,28.23 117.63,28.23 117.72,28.31 117.72,28.47 117.62,28.57 117.19,28.57 117.11,28.65 117.11,28.82 117.19,28.9 117.63,28.9 117.72,28.98 117.72,29.14 117.62,29.24 117.19,29.24 117.11,29.32 117.11,29.49 117.19,29.57 117.7,29.57 117.78,29.65 117.78,29.82 117.69,29.91 117.19,29.91 117.11,29.99 117.11,30.16 117.19,30.24 117.41,30.24 117.49,30.32 117.49,30.5 117.41,30.58 117.19,30.58 117.11,30.66 117.11,30.83 117.19,30.91 117.41,30.91 117.49,31 117.49,31.17 117.41,31.25 117.19,31.25 117.11,31.33 117.11,31.5 117.19,31.58 117.41,31.58 117.49,31.67 117.49,31.84 117.41,31.92 117.19,31.92 117.11,32 117.11,32.17 117.19,32.26 117.41,32.26 117.49,32.34 117.49,32.51 117.41,32.59 117.19,32.59 117.11,32.67 117.11,32.84 117.19,32.93 117.41,32.93 117.49,33.01 117.49,33.18 117.41,33.26 117.19,33.26 117.11,33.34 117.11,33.51 117.19,33.6 117.41,33.6 117.49,33.68 117.49,33.85 117.41,33.93 117.19,33.93 117.11,34.01 117.11,34.19 117.19,34.27 117.41,34.27 117.49,34.35 117.49,34.52 117.41,34.6 117.19,34.6 117.11,34.68 117.11,34.86 117.19,34.94 117.55,34.94 117.63,35.02 117.63,35.19 117.55,35.27 117.19,35.27 117.11,35.35 117.11,35.53 117.19,35.61 117.55,35.61 117.63,35.69 117.63,35.86 117.55,35.94 117.19,35.94 117.11,36.02 117.11,36.2 117.19,36.28 117.41,36.28 117.49,36.36 117.49,36.53 117.41,36.61 117.19,36.61 117.11,36.7 117.11,36.87 117.19,36.95 117.41,36.95 117.5,37.05 117.5,41.7 117.91,42.12 v1(117.91,42.37)
DDR4_COMP_CH0_DQ62: length 40.1
  L05_SIG2 w0.081: v1(101.1,26.54) 101.12,26.51 102.35,26.51 102.5,26.66 102.5,27.67 102.64,27.81 102.64,28 102.5,28.14 102.5,28.32 102.64,28.46 102.64,28.65 102.5,28.79 102.5,28.97 102.64,29.11 102.64,29.3 102.5,29.44 102.5,30.01 102.62,30.12 104.02,30.12 104.54,30.65 106.33,30.65 106.84,30.14 107.81,30.14 108.23,30.56 109.03,30.56 109.11,30.64 109.11,31.17 109.19,31.25 109.36,31.25 109.45,31.17 109.45,30.64 109.53,30.56 109.7,30.56 109.78,30.64 109.78,31.17 109.86,31.25 110.03,31.25 110.12,31.17 110.12,30.64 110.2,30.56 110.37,30.56 110.45,30.64 110.45,31.17 110.53,31.25 110.71,31.25 110.79,31.17 110.79,30.64 110.87,30.56 111.04,30.56 111.12,30.64 111.12,31.17 111.2,31.25 111.38,31.25 111.46,31.17 111.46,30.64 111.54,30.56 111.71,30.56 111.79,30.64 111.79,31.17 111.87,31.25 112.05,31.25 112.13,31.17 112.13,30.64 112.21,30.56 112.55,30.56 112.63,30.64 112.63,31.16 112.72,31.24 112.89,31.24 112.97,31.16 112.97,30.64 113.05,30.56 113.22,30.56 113.31,30.64 113.31,31.16 113.39,31.24 113.56,31.24 113.64,31.16 113.64,30.64 113.72,30.56 114.68,30.56 114.82,30.7 114.82,31.34 114.74,31.42 114.18,31.42 114.1,31.5 114.1,31.67 114.18,31.75 114.74,31.75 114.82,31.84 114.82,33.81 114.19,34.44 arc(114.17,34.47) 114.16,34.51 114.16,37.6 arc(114.16,37.64) 114.17,37.68 arc(114.25,37.84) 114.33,38 arc(114.39,38.22) 114.33,38.45 114.33,38.46 arc(114.27,38.68) 114.33,38.91 114.33,38.92 arc(114.39,39.15) 114.33,39.38 arc(114.27,39.6) 114.33,39.83 114.33,39.84 arc(114.39,40.07) 114.33,40.3 arc(114.27,40.52) 114.32,40.75 114.33,40.76 arc(114.39,40.99) 114.33,41.22 arc(114.27,41.44) 114.33,41.67 v1(114.73,42.37)
DDR4_COMP_CH0_DQ63: length 38.7
  L05_SIG2 w0.081: v1(117.91,44.21) 117.91,44.22 117.48,44.22 arc(117.48,44.22) 117.48,44.22 117.26,44.22 arc(117.03,44.17) 116.83,44.04 116.58,43.8 arc(116.52,43.75) 116.45,43.74 arc(116.36,43.73) 116.28,43.71 116.09,43.71 115.68,44.12 115.37,44.12 115.07,43.81 114.73,43.81 114.35,43.43 114.35,42.62 114.06,42.33 113.77,42.33 113.53,42.09 113.53,34.18 113.62,34.1 113.83,34.1 113.91,34.01 113.91,33.84 113.83,33.76 113.62,33.76 113.53,33.68 113.53,33.51 113.62,33.42 113.83,33.42 113.91,33.34 113.91,33.17 113.83,33.09 113.62,33.09 113.53,33.01 113.53,31.76 113.37,31.59 108.17,31.59 107.68,31.1 104.52,31.1 103.94,30.52 102.3,30.52 102.09,30.31 102.09,27.15 101.92,26.97 100.85,26.97 100.67,26.79 100.67,26.34 100.87,26.15 104.2,26.15 104.3,26.25 v1(104.3,26.54)
DDR4_COMP_CH0_DQ64: length 67.1
  L12_SIG4 w0.089: v1(69.79,24.13) 69.71,24.05 69.49,24.05 69.4,24.13 69.4,26.06 69.49,26.15 70.09,26.15 70.18,26.24 70.18,30.42 70.27,30.51 70.61,30.51 70.7,30.42 70.7,29.53 70.8,29.43 70.95,29.43 71.04,29.52 71.04,30.42 71.13,30.51 71.89,30.51 71.98,30.42 71.98,30.08 72.07,29.99 72.22,29.99 72.33,30.1 72.33,30.42 72.41,30.51 72.58,30.51 72.67,30.42 72.67,30.08 72.76,29.99 72.9,29.99 73.01,30.1 73.01,30.42 73.1,30.51 73.56,30.51 73.65,30.42 73.65,30.06 73.74,29.97 73.9,29.97 73.99,30.06 73.99,30.42 74.08,30.51 75.16,30.51 75.66,30.02 76.96,30.02 78.47,31.52 82.41,31.52 82.5,31.44 82.5,30.15 82.58,30.06 82.76,30.06 82.84,30.15 82.84,31.41 82.93,31.5 83.1,31.5 83.19,31.41 83.19,30.06 83.3,29.95 83.42,29.95 83.53,30.06 83.53,30.55 83.62,30.64 83.89,30.64 83.98,30.73 83.98,30.89 83.89,30.98 83.62,30.98 83.53,31.07 83.53,31.43 83.63,31.52 84.22,31.52 84.32,31.43 84.32,30.96 84.42,30.86 85.15,30.86 85.32,31.03 85.32,32.04 89.81,36.53 89.81,36.66 89.5,36.96 89.5,37.09 89.62,37.2 89.75,37.2 90.05,36.9 90.17,36.9 90.78,37.51 90.79,37.51 91.06,37.89 arc(91.24,38.07) 91.49,38.14 91.49,38.14 arc(91.74,38.2) 91.92,38.38 91.93,38.39 91.93,39.39 arc(92.11,39.57) 92.35,39.64 92.37,39.64 arc(92.61,39.71) 92.79,39.89 92.79,39.89 arc(92.98,40.07) 93.23,40.14 arc(93.47,40.2) 93.66,40.38 arc(93.69,40.41) 93.73,40.43 93.87,40.43 arc(93.91,40.43) 93.95,40.46 94.24,40.75 94.36,40.75 94.61,40.51 94.61,40.38 94.12,39.89 94.12,39.77 94.23,39.65 94.36,39.65 94.85,40.15 94.98,40.15 95.17,39.95 95.29,39.95 95.45,40.11 95.45,40.38 94.78,41.05 94.78,41.17 94.87,41.26 95.11,41.26 95.43,41.58 95.82,41.64 arc(96.07,41.7) 96.25,41.88 96.26,41.89 arc(96.44,42.07) 96.69,42.14 96.7,42.14 arc(96.94,42.07) 97.12,41.89 97.25,41.76 97.71,41.76 98.14,42.19 98.67,42.19 98.79,42.31 98.8,42.31 99.36,42.87 99.41,43.04 99.49,43.08 99.72,43.31 99.72,43.32 100.23,43.83 100.54,43.83 101,44.29 101.34,44.29 101.46,44.41 101.6,44.41 101.93,44.75 102.31,44.75 102.77,45.21 102.93,45.21 103.15,45.43 103.15,45.59 103.23,45.67 103.24,45.67 103.73,45.67 103.97,45.92 104.36,46.05 v1(105.17,46.05)
DDR4_COMP_CH0_DQ65: length 66.1
  L12_SIG4 w0.089: v1(73.79,24.93) 73.79,25.2 74.18,25.58 74.18,26.06 74.09,26.15 73.45,26.15 73.29,25.99 73.29,25.71 72.91,25.33 72.34,25.33 72.2,25.47 72.2,26.48 72.29,26.57 73.18,26.57 73.27,26.66 73.27,26.81 73.17,26.91 72.29,26.91 72.2,27 72.2,27.34 72.29,27.43 72.73,27.43 72.82,27.52 72.82,27.68 72.73,27.77 72.29,27.77 72.2,27.86 72.2,28.03 72.29,28.12 72.73,28.12 72.82,28.2 72.82,28.37 72.73,28.46 72.29,28.46 72.2,28.55 72.2,28.89 72.43,29.11 73.11,29.11 73.26,28.96 73.26,28.62 73.37,28.51 74.09,28.51 74.18,28.42 74.18,27.1 74.37,26.91 74.91,26.91 75,27 75,28.42 75.09,28.51 75.67,28.51 75.8,28.38 75.8,27.23 76.32,26.72 78.03,26.72 78.39,27.07 78.39,30.07 78.7,30.38 81.42,30.38 81.51,30.29 81.51,26.71 81.73,26.5 83.37,26.5 83.79,26.91 85.9,26.91 85.99,27 85.99,30.11 86.45,30.56 86.45,31.32 91.62,36.5 93,36.5 93.64,37.14 94.96,37.14 94.97,37.14 arc(95.21,37.21) 95.39,37.39 arc(95.57,37.57) 95.81,37.64 95.83,37.64 arc(96.08,37.71) 96.26,37.89 arc(96.44,38.07) 96.69,38.14 96.69,38.14 arc(96.94,38.2) 97.12,38.38 97.12,38.39 arc(97.3,38.57) 97.55,38.64 97.56,38.64 arc(97.8,38.7) 97.99,38.88 97.99,38.89 arc(98.06,39.14) 97.99,39.39 97.99,39.71 arc(98,39.82) 98.05,39.91 98.07,39.93 arc(98.16,39.99) 98.27,40.01 98.58,40.01 98.58,40.01 98.68,40.01 98.93,40.26 98.96,40.31 99,40.38 99.11,40.49 arc(99.24,40.59) 99.4,40.65 arc(99.59,40.74) 99.72,40.89 99.72,40.89 arc(99.9,41.07) 100.15,41.14 arc(100.31,41.17) 100.44,41.25 100.54,41.36 arc(100.61,41.45) 100.63,41.56 100.63,42.29 100.85,42.51 101.28,42.51 101.39,42.61 101.58,42.6 arc(101.74,42.76) 101.97,42.83 101.99,42.83 arc(102.21,42.89) 102.38,43.06 arc(102.54,43.22) 102.77,43.29 102.77,43.29 arc(103,43.35) 103.17,43.51 103.17,43.52 arc(103.3,43.64) 103.46,43.68 103.61,43.68 arc(103.84,43.75) 104.01,43.91 104.3,44.41 v1(104.37,44.67)
