# Allegro board FM85_AGILEX_PCIE_DK_CMC_ADI_REVC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
0P9V_VCCL_HPS: length 21
  TOP w0.381: U67.A4 v1(201.28,45.35) ; U67.A2 v1(201.01,43.42)
  BOTTOM w0.203: R973.2 127.01,37.35 127.01,37.91 127.15,38.06 127.15,38.38 127.03,38.5 127.03,38.87 127.03,38.87 127.1,38.94 127.1,38.96 127.11,38.97 127.11,39.33 127.1,39.34 127.1,39.37 127.04,39.43 127.04,39.79 127.1,39.84 127.1,39.88 127.11,39.89 127.11,40.25 127.1,40.26 127.1,40.27 127,40.37 127,40.66 127.14,40.81 127.14,41.17 127.03,41.27 127.03,41.63 127.12,41.72 127.12,42.09 127.03,42.18 127.03,42.55 127.12,42.64 127.12,43.01 127.03,43.1 127.03,43.47 127.12,43.56 127.12,43.93 127.02,44.03 127.02,44.39 127.12,44.49 127.12,44.87 127.05,44.95 127.05,45.33 127.16,45.45 127.16,45.73 127.03,45.86 127.03,46.23 127.12,46.32 127.12,46.69 127.03,46.78 127.03,47.15 127.03,47.15 127.12,47.24 127.12,47.61 127.03,47.7 127.03,48.07 127.12,48.16 127.12,48.53 127.03,48.62 127.03,48.99 127.15,49.11 127.15,49.35 127.08,49.51 126.95,49.64 126.73,49.73 126.53,49.73 126.35,49.84 126.21,50.08 126.02,50.19 125.75,50.19 125.55,50.31 125.42,50.53 125.3,50.65 v1(124.29,50.65)
  BOTTOM w0.381: FB1.1 148.72,49.29 C1266.1
  vias: v1(122.7,51.57) v1(122.7,50.65) v1(122.7,49.73) v1(124.29,51.57) v1(144.4,47.1) v1(148.7,48.03) v1(149.77,51.06) v1(150.32,50.55) v1(197.77,44.91) v1(198.15,44.42) v1(198.43,44.91) v1(201.71,45.77) v1(201.7,44.24) v1(201.7,42.64) v1(203.26,41.73) v1(205.7,44.24) v1(206.5,44.24) v1(206.5,43.44) v1(206.5,42.64) v3(149.61,67.64)
0P9V_VOSNS2+_U135: length 30.2
  TOP w0.149: R6199.2 177.31,46.9 178.32,47.91 179.51,47.91 v1(180.04,47.37)
  L14_SIG5 w0.081: v1(180.04,33.4) 179.61,33.4 179.52,33.49 179.52,33.84 179.65,33.96 182.89,33.96 183.46,34.53 183.46,34.84 183.69,35.07 184,35.07 184.73,35.8 184.73,36.11 184.96,36.34 185.27,36.34 185.89,36.96 185.89,46.39 185.47,46.81 179.84,46.81 179.52,47.13 179.52,47.29 179.61,47.37 v1(180.04,47.37)
0P9V_VOSNS2-_U135: length 28.8
  TOP w0.149: v1(178.77,47.37) 177.65,46.25 176.93,46.25 176.78,46.1 ST34.2
  L14_SIG5 w0.081: v1(178.77,47.37) 179.21,47.37 179.29,47.29 179.29,47.03 179.74,46.58 185.37,46.58 185.66,46.29 185.66,37.05 185.17,36.57 184.86,36.57 184.49,36.2 184.49,35.89 183.9,35.3 183.59,35.3 183.22,34.93 183.22,34.62 182.8,34.19 179.55,34.19 179.29,33.93 179.29,33.49 179.21,33.4 v1(178.77,33.4)
1P0V_VCCCLK_GXR: length 11.2
  TOP w0.381: v1(57.5,13.8) 56.85,13.14 U17.5
  L16_SIG6 w0.508: v5(140.06,30.12) 140.06,30.73 140.03,30.75 v5(140.03,33.24)
  BOTTOM w0.381: 56.47,13.04 C353.2 ; 56.47,13.04 56.52,13.09 57.41,13.09 R183.2 57.47,13.77 v1(57.5,13.8) ; 56.47,13.04 R6324.1 ; v5(140.03,33.24) 140.15,33.37 R927.2 140.15,35.67 v1(140.09,35.74) 139.24,35.74 v1(139.22,35.73) R195.2
  vias: v1(98.94,56.9) v1(104.37,56.63) v1(104.37,55.71) v1(128.27,53.87) v1(128.27,52.95) v1(176.74,68.25) v1(178.7,69.9) v1(178.84,67.86) v1(178.87,67.26) v1(180.02,69.62) v1(180.93,69.62) v1(184.54,70.23) v5(125.85,67.04)
1P0V_VCCERT_FGT_GXF: length 22.5
  BOTTOM w0.203: v1(103.62,64.43) 102.67,64.43 arc(102.64,64.44) 102.62,64.45 102.47,64.54 arc(102.46,64.54) 102.45,64.55 102.32,64.77 arc(102.32,64.78) 102.32,64.79 102.32,65.02 arc(102.32,65.04) 102.32,65.05 102.42,65.21 arc(102.42,65.22) 102.42,65.23 102.42,65.5 arc(102.42,65.52) 102.42,65.53 102.25,65.82 arc(102.24,65.83) 102.24,65.85 102.24,66.74 arc(102.24,66.75) 102.24,66.76 101.52,68 arc(101.51,68.01) 101.5,68.02 101.33,68.12 arc(101.32,68.13) 101.31,68.13 101.07,68.13 arc(101.06,68.13) 101.04,68.13 100.86,68.24 arc(100.85,68.25) 100.84,68.26 100.72,68.47 arc(100.71,68.48) 100.7,68.49 100.52,68.59 arc(100.51,68.59) 100.5,68.6 100.26,68.6 arc(100.24,68.6) 100.23,68.6 100.06,68.7 arc(100.05,68.71) 100.04,68.72 99.93,68.91 arc(99.93,68.92) 99.92,68.93 99.73,69.03 arc(99.72,69.04) 99.71,69.04 99.2,69.04 arc(99.19,69.04) 99.18,69.05 98.97,69.25 arc(98.97,69.26) 98.97,69.27 98.97,75.76 arc(98.96,75.77) 98.96,75.78 98.62,76.12 arc(98.61,76.12) 98.6,76.13 98.35,76.13 arc(98.33,76.13) 98.32,76.13 97.86,76.32 arc(97.85,76.33) 97.84,76.33 96.41,77.29 arc(96.4,77.3) 96.39,77.31 96.18,77.51 arc(96.17,77.52) 96.17,77.54 96.17,77.84 arc(96.17,77.85) 96.18,77.86 96.26,77.95 arc(96.27,77.96) 96.27,77.97 96.27,79.34 arc(96.27,79.35) 96.26,79.36 96.16,79.47 arc(96.15,79.48) 96.15,79.49 96.15,79.75 arc(96.15,79.76) 96.16,79.77 96.29,79.9 arc(96.3,79.91) 96.3,79.92 96.3,80.28 arc(96.3,80.29) 96.29,80.3 96.18,80.41 arc(96.17,80.42) 96.17,80.43 96.17,80.84 arc(96.17,80.85) 96.18,80.86 96.39,81.07 arc(96.4,81.08) 96.4,81.09 96.4,81.66 arc(96.4,81.68) 96.39,81.69 R666.1
  vias: v1(38.49,92.26) v1(76.33,91.9) v1(77.22,91.9) v1(83.77,66.27) v1(83.89,75.27) v1(83.89,72.89) v1(83.89,71.39) v1(88.03,77.64) v1(88.03,76.64) v1(88.03,75.64) v1(88.03,74.64) v1(88.03,73.64) v1(88.03,72.64) v1(102.73,64.01) v1(102.76,62.15) v1(103.57,63.53) v1(103.61,61.69) v1(103.57,60.77) v1(104.37,63.99) v1(104.37,62.15) v4(35.21,93.88) v4(35.21,92.53) v4(36.48,93.88) v4(36.48,92.53) v4(37.75,93.88) v4(37.75,92.53) v4(39.02,93.88) v4(39.08,92.53) v4(40.29,93.88) v4(40.29,92.53) v4(41.56,93.88) v4(41.56,92.53) v4(42.83,93.88) v4(42.83,92.53) v4(44.1,93.88) v4(44.1,92.53)
1P0V_VCCFUSE_GXR: length 2.6
  L16_SIG6 w0.254: v1(129.07,53.41) 129.07,53.68 129.26,53.87 v1(129.87,53.87) 129.87,53.38
  L16_SIG6 w0.508: v1(103.57,56.17) 103.11,55.71 v1(102.78,55.71)
  vias: v1(195.05,70.49) v1(195.05,69.98) v1(195.56,70.49) v1(195.56,69.98)
1P0V_VCCFUSE_GXR_EN: length 289.3
  TOP w0.149: U131.4 198.21,65.75 198.38,65.59 198.38,64.67 198.3,64.59 198.3,63.83 198.08,63.6 197.31,63.6 197.16,63.75 197.16,64.56 196.69,65.02 196.12,65.02 195.71,65.43 191.81,65.43 191.46,65.78 U130.4 191.87,66.17 v1(191.87,66.17)
  L03_SIG1 w0.081: v1(136.17,12.23) 136.75,12.23 138.65,14.12 175.63,14.12 176.73,15.22 178.69,15.22 179.02,15.55 180.4,15.55 181.79,14.15 186.59,14.15 187.53,15.1 191.66,15.1 193.09,13.67 197.75,13.67 198.55,14.47 199.45,14.47 200.5,13.42 214.22,13.42 v1(214.73,13.94) ; v1(217.48,21.27) 217.48,31.96 217.86,32.34 217.86,36.09 217.48,36.47 217.48,49.64 217.3,49.82 217.3,50.15 217.48,50.32 217.48,60.04 217.2,60.32 214.8,60.32 214.24,60.88 214.24,67.07 214.53,67.37 214.53,68.05 214.08,68.5 211.26,68.5 209.99,67.22 209.67,67.22 209.11,66.67 207.99,66.67 206.63,65.32 204.27,65.32 202.98,66.61 202.39,66.85 201.72,67.52 201.2,67.52 200.82,67.9 199.42,67.9 198.28,66.75 198.22,66.73 196.19,66.73 195.91,67 195.91,67.59 195.08,68.42 193.91,68.42 193.62,68.12 192.73,68.12 192.5,67.9 192.18,67.9 191.87,67.59 v1(191.87,66.17)
  L07_SIG3 w0.089: v1(214.73,13.94) 215.32,14.52 215.32,16.19 215.54,16.42 215.54,19.33 v1(217.48,21.27)
  L14_SIG5 w0.081: v1(40.91,32.04) 42.69,30.26 43.2,30.26 45.43,28.02 45.43,27.47 45.67,27.24 45.99,27.24 46.13,27.37 48.45,27.37 48.76,27.69 50.33,27.69 50.77,27.24 52.03,27.24 52.07,27.21 52.39,27.21 52.67,27.49 52.9,27.49 52.9,27.48 52.9,27.47 54,26.38 54.02,26.38 57.65,22.75 57.65,22.31 59.71,20.25 61.34,20.25 63.7,17.89 63.7,15.76 66.65,12.81 69.22,12.81 69.95,12.08 78.92,12.08 79.12,11.88 117.06,11.88 117.8,12.62 119.59,12.62 121.1,14.14 126.37,14.14 127.84,12.66 129.66,12.66 130.25,13.26 135.14,13.26 v1(136.17,12.23)
1P0V_VCCRT_GXR: length 26.9
  BOTTOM w0.203: R678.1 102.65,37.54 103.03,37.76 103.26,38.14 103.43,38.24 103.75,38.24 104.02,38.5 104.02,38.87 103.92,38.96 103.92,39.33 104.18,39.59 104.52,39.59 104.68,39.68 104.84,39.96 105.03,40.07 105.31,40.07 105.49,40.18 105.64,40.42 105.81,40.52 106.08,40.52 106.3,40.64 106.41,40.84 106.64,40.97 106.89,40.97 107.08,41.09 107.22,41.32 107.41,41.43 107.7,41.43 107.87,41.53 108,41.76 108,42.09 107.91,42.18 107.91,42.55 108,42.64 108,43.01 107.9,43.12 107.9,43.46 108,43.57 108.01,43.57 108.01,43.92 107.91,44.03 107.91,44.39 108,44.48 108,44.85 107.85,45.01 107.85,45.25 108,45.4 108,45.77 107.91,45.86 107.91,46.23 108.01,46.33 108.01,46.68 107.91,46.78 107.91,47.15 108.01,47.25 108.01,47.6 107.91,47.7 107.91,48.07 108.03,48.2 108.03,48.5 107.91,48.62 107.91,48.99 108.13,49.21 108.22,49.27 108.49,49.27 108.68,49.38 108.82,49.61 109.02,49.73 109.28,49.73 109.48,49.84 109.61,50.07 109.81,50.19 110.08,50.19 110.28,50.3 110.41,50.53 110.61,50.65 110.88,50.65 111.07,50.76 111.21,50.99 111.41,51.11 111.67,51.11 111.87,51.22 112.01,51.45 112.2,51.57 112.47,51.57 112.67,51.68 112.8,51.91 113,52.03 113.27,52.03 113.47,52.14 113.6,52.37 113.8,52.49 114.06,52.49 114.26,52.6 114.4,52.83 114.59,52.95 114.86,52.95 115.06,53.06 115.19,53.3 115.19,53.57 115.08,53.68 115.08,53.98 v1(114.73,54.33)
  vias: v1(101.98,55.25) v1(101.98,54.33) v1(101.98,53.41) v1(101.98,52.49) v1(102.78,54.79) v1(102.77,53.87) v1(102.77,52.95) v1(103.57,54.33) v1(103.57,53.41) v1(129.07,56.17) v1(129.07,55.25) v1(129.87,56.63) v1(129.87,55.71) v1(129.87,54.79) v1(130.66,57.09) v1(130.66,56.17) v1(130.66,55.25) v1(130.66,54.33) v1(146.44,69.17) v1(147.2,69.17) v1(149.51,55.58) v1(149.52,53.61) v1(150.27,55.58) v1(150.28,53.61) v4(196.4,32.21) v4(196.4,31.45) v4(196.4,30.69) v4(196.4,29.92) v4(196.75,37.16) v4(196.86,35.26) v4(196.92,33.73) v4(197.01,32.21) v4(197.01,31.45) v4(197.01,30.69) v4(197.01,29.92)
1P2V_DDR4_CH01: length 80
  TOP w0.254: v1(75.39,16.93) 75.86,16.93 76.04,16.75 C7747.1
  TOP w0.305: v1(68.99,20.93) 68.99,20.94 C7744.1 ; v1(163.51,24.06) 163.28,23.84 C7728.1 ; v1(75.39,20.93) 75.4,20.94 C7751.1 ; R6217.1 v1(46.36,20.32) ; v1(75.39,28.13) 75.41,28.15 C7749.1 ; v1(30.87,101.17) 30.53,100.84 U28.1 ; v1(24.39,101.3) 23.67,100.58 U31.1 ; v1(136.83,36.22) 136.81,36.22 136.61,36.02 C7399.1 ; C7748.1 67.98,26.53 v1(68.99,26.53) ; v1(12.92,93.17) U32.8 ; C7729.1 163.45,17.72 v1(163.51,17.66) ; v1(19.31,92.92) 19.77,93.38 U31.8 ; v1(17.53,101.3) 16.82,100.58 U32.1 ; C7732.1 169.91,20.87 U11.L9 ; v1(163.51,26.46) 163.4,26.36 C7730.1 ; C1217.1 v1(114.25,33.58) ; v1(169.91,16.86) 169.72,16.67 C7726.1 ; C7743.1 68.77,23.91 v1(68.99,24.13) ; C7731.1 163.5,20.87 v1(163.51,20.86) ; v1(169.91,28.06) 169.93,28.08 C7727.1 ; v1(169.91,24.06) 169.93,24.04 C7733.1 ; C7750.1 75.41,24.11 v1(75.39,24.13) ; C7745.1 68.94,17.79 v1(68.99,17.73) ; C1222.1 v1(119.51,33.58) ; U84.2 41.63,27.63 v1(41.43,27.43)
  TOP w0.381: v1(105.9,22.54) v1(105.1,22.54) ; v1(133.03,22.46) v5(133.83,22.46) ; U4.J2 v1(99.5,22.54) ; U9.J2 v1(143.19,22.46) ; v1(153.35,22.5) U10.J2 ; U11.J2 v1(163.51,22.46) ; v1(79.18,22.54) U3.J2 ; U2.J2 v1(109.66,22.54) ; U1.J2 v1(89.34,22.54)
  L03_SIG1 w0.305: v5(133.83,22.46) v1(133.03,22.46)
  BOTTOM w0.305: C127.1 129.46,23.87 v1(129.27,24.06) ; R457.1 v1(250.07,57.67) ; v1(244.55,53.42) 246.27,53.42 246.65,53.8 U42.2 ; v1(95.74,24.14) 95.92,23.96 C28.1 ; R337.1 v1(15.06,61.67) ; C75.1 105.93,24.11 v1(105.9,24.14) ; v1(85.58,24.14) 85.81,23.91 C74.1 ; v3(36.08,60.72) 36.08,60.66 36.85,59.88 U40.2 ; v1(70.59,28.13) 70.69,28.23 C7758.1 71.59,28.15 R22.1 ; v1(139.43,24.06) 139.62,23.87 C126.1 ; R332.2 v1(20.33,98.88) ; v1(66.48,16.82) 66.49,16.83 R29.1 ; C7746.1 73.35,24.13 v1(73.79,24.13) ; v1(75.39,16.93) 75.78,16.93 76.01,16.71 R28.1 ; v1(116.06,24.14) 116.27,23.92 C29.1 ; v1(149.59,24.06) 149.78,23.87 C173.1 ; v1(133.75,29.8) 134.24,30.29 137.81,30.29 138.21,30.69 138.21,30.95 R2707.1 ; R323.2 29.98,99.39 v1(29.47,98.88) 28.96,99.39 R322.2 ; U105.2 v1(136.83,36.22) ; v1(68.99,22.53) 68.75,22.77 C7757.1 ; R31.1 v1(77.91,19.3) ; U18.8 v1(205.6,93.57) ; v1(46.15,24.18) 46.15,22.93 v1(46.09,22.86)
  BOTTOM w0.381: C118.1 133.07,20.91 v1(133.03,20.86) ; U18.1 198.5,88.86 v1(198.26,88.63)
  vias: v1(35.06,61.61) v1(37.09,61.61) v1(38.11,61.61) v1(39.12,61.61) v1(40.14,61.61) v1(40.65,28.13) v1(41.16,61.61) v1(41.97,32.32) v1(42.05,31.68) v1(42.17,61.61) v1(43.45,22.88) v1(47.01,22.84) v1(47.2,20.34) v1(68.99,28.93) v1(68.99,27.33) v1(69.79,24.93) v1(69.79,22.53) v1(74.59,24.93) v1(74.59,22.53) v1(75.39,28.93) v1(75.39,26.53) v1(75.39,22.53) v1(79.18,28.94) v1(79.18,27.34) v1(79.18,26.54) v1(79.18,24.14) v1(79.18,20.94) v1(79.18,17.74) v1(79.98,24.94) v1(80.78,28.14) v1(82.35,23.29) v1(82.35,22.68) v1(83.98,24.14) v1(84.78,24.94) v1(84.77,22.56) v1(85.54,22.56) v1(85.58,28.94) v1(85.58,28.14) v1(85.58,26.54) v1(85.58,20.94) v1(85.58,16.94) v1(89.34,28.94) v1(89.34,27.34) v1(89.34,26.54) v1(89.34,24.14) v1(89.34,20.94) v1(89.34,17.74) v1(90.14,24.94) v1(90.94,28.14) v1(92.51,23.29) v1(92.51,22.68) v1(94.14,24.14) v1(94.94,24.94) v1(94.94,22.54) v1(95.74,28.94) v1(95.74,28.14) v1(95.74,26.54) v1(95.74,22.54) v1(95.74,20.94) v1(95.74,16.94) v1(99.5,28.94) v1(99.5,27.34) v1(99.5,26.54) v1(99.5,24.14) v1(99.5,20.94) v1(99.5,17.74) v1(100.3,24.94) v1(101.1,28.14) v1(102.67,23.29) v1(102.67,22.68) v1(104.3,24.14) v1(105.1,24.94) v1(105.9,28.94) v1(105.9,28.14) v1(105.9,26.54) v1(105.9,20.94) v1(105.9,16.94) v1(109.15,67.67) v1(109.66,28.94) v1(109.66,27.34) v1(109.66,26.54) v1(109.66,24.14) v1(109.66,20.94) v1(109.66,17.74) v1(109.95,48.81) v1(109.95,47.89) v1(110.46,24.94) v1(111.26,28.14) v1(111.54,48.81) v1(111.54,47.89) v1(112.81,23.29) v1(112.81,22.68) v1(113.13,48.81) v1(113.13,47.89) v1(114.46,24.14) v1(114.73,48.81) v1(114.73,47.89) v1(115.26,24.94) v1(115.26,22.54) v1(116.06,28.94) v1(116.06,28.14) v1(116.06,26.54) v1(116.06,22.54) v1(116.06,20.94) v1(116.06,16.94) v1(116.32,48.81) v1(116.32,47.89) v1(117.91,48.81) v1(117.91,47.89) v1(119.51,48.81) v1(119.51,47.89) v1(121.1,48.81) v1(121.1,47.89) v1(122.87,28.86) v1(122.87,27.26) v1(122.87,26.46) v1(122.87,24.06) v1(122.87,22.46) v1(122.87,20.86) v1(122.87,17.66) v1(123.67,24.86) v1(123.67,22.46) v1(124.47,28.06) v1(126.11,23.19) v1(126.11,22.68) v1(126.87,16.86) v1(127.67,24.06) v1(128.47,24.86) v1(128.47,22.46) v1(129.27,28.86) v1(129.27,28.06) v1(129.27,26.46) v1(129.27,22.46) v1(129.27,20.86) v1(129.27,16.86) v1(133.03,28.86) v1(133.03,27.26) v1(133.03,26.46) v1(133.03,24.06) v1(133.03,17.66) v1(133.83,24.86) v1(134.63,28.06) v1(136.24,23.19) v1(136.24,22.68) v1(137.03,16.86) v1(137.16,33.9) v1(137.83,24.06) v1(138.63,24.86) v1(138.63,22.46) v1(139.43,28.86) v1(139.43,28.06) v1(139.43,26.46) v1(139.43,22.46) v1(139.43,20.86) v1(139.43,16.86) v1(143.19,28.86) v1(143.19,27.26) v1(143.19,26.46) v1(143.19,24.06) v1(143.19,20.86) v1(143.19,17.66) v1(143.99,24.86) v1(144.79,28.06) v1(146.4,23.19) v1(146.4,22.68) v1(147.19,16.86) v1(147.99,24.06) v1(148.79,24.86) v1(148.79,22.46) v1(149.59,28.86) v1(149.59,28.06) v1(149.59,26.46) v1(149.59,22.46) v1(149.59,20.86) v1(149.59,16.86) v1(153.35,28.9) v1(153.35,27.3) v1(153.35,26.5) v1(153.35,24.1) v1(153.35,20.9) v1(153.35,17.66) v1(154.15,24.9) v1(154.95,28.1) v1(156.56,23.23) v1(156.56,22.72) v1(157.35,16.9) v1(158.15,24.1) v1(158.95,24.9) v1(158.95,22.5) v1(159.75,28.9) v1(159.75,28.1) v1(159.75,26.5) v1(159.75,24.1) v1(159.75,22.5) v1(159.75,20.9) v1(159.75,16.9) v1(161.81,28.1) v1(163.51,28.86) v1(163.51,27.26) v1(164.31,24.86) v1(165.11,28.06) v1(166.89,28.06) v1(168.31,24.06) v1(169.11,24.86) v1(169.11,22.46) v1(169.91,28.86) v1(169.91,26.46) v1(169.92,22.46) v1(169.92,20.86) v1(170.66,16.78) v1(171.34,20.06) v1(171.33,19.26) v1(172.57,17.66) v1(172.86,19.26) v1(181.13,20.02) v1(181.13,18.75) v1(181.13,17.48) v1(183.67,17.48) v1(184.94,18.75) v1(184.94,17.48) v1(187.48,17.48) v1(188.75,18.75) v1(188.75,17.48) v1(191.29,17.48) v1(192.56,18.75) v5(46.03,13.45)
1P2V_DDR4_CH01_AGND: length 2.2
  BOTTOM w0.203: ST25.1 v1(187.48,25.1)
  BOTTOM w0.381: R6081.1 v1(183.01,25.83) ; C1966.1 v1(184.27,25.64)
1P2V_DDR4_CH1_EN: length 180
  TOP w0.149: R6244.1 33.51,35.57 33.51,35.82 v1(33.43,35.9)
  L07_SIG3 w0.089: v1(180.25,25.5) 180.25,24.52 180.1,24.37 180.1,24.35 179.68,23.92 179.68,23.89 177.7,21.92 177.16,21.92 174.14,18.9 174.14,14.94 173.63,14.43 137.74,14.43 137.46,14.71 133.78,14.71 131.21,12.14 130.89,12.14 128.97,10.21 128.95,10.21 128.73,9.99 128.3,9.56 128.27,9.52 127.56,8.81 127.52,8.81 127.52,8.8 62.08,8.8 59.47,11.42 58.45,11.42 55.95,13.92 55.47,13.92 53.48,15.91 49.23,15.91 48.94,15.62 47.97,15.62 47.43,15.09 46.5,15.09 44.04,17.55 44.04,18.19 44.68,18.84 44.68,19.36 44.12,19.92 44.12,22.04 43.89,22.26 43.89,23.1 42.42,24.58 42.27,24.58 41.56,25.29 41.11,25.29 39.79,26.61 38.74,26.61 38.07,27.28 37.34,27.28 37.12,27.06 37.12,26.75 36.9,26.53 36.31,26.53 36.08,26.75 36.08,27.85 35.65,28.28 35.37,28.28 34.87,28.78 34.87,29.06 34.65,29.28 34.56,29.28 33.87,29.97 33.87,30.06 33.65,30.28 33.56,30.28 32.97,30.86 32.97,34.26 33.51,34.8 33.51,35.82 v1(33.43,35.9)
  BOTTOM w0.149: R6080.2 180.38,25.18 arc(180.28,25.33) v1(180.25,25.5)
1P2V_DDR4_CH01_PG: length 172.6
  TOP w0.127: v1(183.67,20.02) 183.41,20.02 182.75,19.36 182.11,19.36 181.76,19.72 181.76,20.27 181.38,20.65 179.14,20.65 177.59,19.09 v1(177.59,18.72)
  L03_SIG1 w0.127: v2(32.5,28.9) 32.9,28.5 32.9,23.73 33.33,23.3 33.66,23.3 33.89,23.07 33.89,22.74 34.14,22.49 34.75,22.49 35.1,22.14 35.1,19.71 36.3,18.51 38.67,18.51 39.2,19.04 40.91,19.04 42.02,20.15 43.3,20.15 44.26,19.2 v1(44.28,19.2)
  L05_SIG2 w0.127: v1(44.28,19.2) 43.71,18.62 43.71,17.48 44.59,16.6 46.37,16.6 47,17.24 47.4,17.24 47.81,17.64 52.72,17.64 56.98,13.38 61.57,13.38 61.84,13.11 115.31,13.11 117.37,15.18 130.67,15.18 130.93,14.92 162.64,14.92 163.29,15.57 165.25,15.57 165.97,16.29 165.98,16.29 166.32,16.62 166.32,16.63 167.19,17.5 167.28,17.5 167.51,17.27 167.83,17.27 168.39,17.83 168.71,17.83 168.71,17.5 168.94,17.27 170.07,17.27 170.3,17.5 170.3,18.04 170.32,18.06 176.93,18.06 v1(177.59,18.72)
  BOTTOM w0.127: R6045.1 v1(183.67,20.02)
1P2V_DDR4_CH2: length 58
  TOP w0.254: v1(25.06,103.29) 25.2,103.42 U85.2
  TOP w0.381: C1256.2 C1255.2 ; J1.217 134.59,93.14 134.2,92.75 132.44,92.75 132.04,93.14 J1.220 ; v1(114.01,103.3) 113.91,103.3 113.34,102.73 J2.236
  BOTTOM w0.381: C202.1 123.27,97.98 v3(123.54,98.26) ; v1(132.06,98.63) 132.04,98.61 C209.1 ; U13.8 v1(98.49,104.59) ; C259.1 143.94,102.1 v1(143.94,102.05) ; v3(123.54,105.88) 123.37,105.7 C239.1 ; v3(96.43,32.59) 96.43,32.89 96.81,33.27 R157.1 ; C258.1 122.28,102.48 v3(121.84,102.05) ; v1(94.26,95.76) 94.27,95.77 94.27,97.45 U12.1 ; C200.1 113.32,94.45 v3(113.34,94.43) ; v3(119.29,105.88) 119.12,105.7 C242.1 C256.1 116.74,105.71 v3(116.74,105.88) ; U13.1 102.39,96.64 102.46,96.58 102.46,96.23 102.39,96.16 102.39,95.96 C233.1 101.56,95.94 v1(101.53,95.91) ; v3(142.24,98.41) 142.39,98.26 C208.1 144.81,98.26 v3(144.84,98.23) ; v3(137.14,98.26) 137.14,98.26 C207.1 139.69,98.26 v3(139.69,98.26) ; v1(110.34,104.74) C252.2 ; v3(96.79,31.93) 96.85,31.93 97.28,32.35 R999.1 ; C222.1 C211.1 115.07,98.03 v3(115.13,98.08) ; v3(146.48,105.9) 146.49,105.89 C241.1 ; U15.1 98.15,30.55 C309.1 ; v1(136.29,101.92) 136.3,101.93 C235.1 ; v3(137.14,105.88) 137.05,105.79 v1(134.59,105.79) 134.59,107.24 134.32,107.51 132.33,107.51 132.06,107.24 v1(132.06,106.25) ; U12.8 v1(90.36,104.72) ; v3(119.29,102.05) 118.86,102.48 C238.1 ; C243.1 114.87,105.7 v3(115.04,105.88) ; R2783.2 v1(189.58,97.25) ; v3(121.84,94.43) 121.87,94.45 C210.1 ; R1049.2 141.35,102.09 C245.1 ; C244.1 145.64,102.12 v1(145.64,102.05)
  BOTTOM w0.508: C241.1 147.37,105.7 C254.1 148.04,104.93 C253.2 ; C216.2 148.34,96.89 147.52,96.07 C218.1 146.76,95.17 v3(145.64,94.04)
  vias: v1(20.75,108.33) v1(21.43,104.53) v1(22.75,104.53) v1(56.27,98.12) v1(57.7,98.11) v1(90.7,95.76) v1(93.26,95.76) v1(93.91,91.65) v1(93.91,91.04) v1(110.18,96.8) v1(110.18,96.22) v1(110.15,95.69) v1(111.54,70.89) v1(111.54,69.99) v1(113.12,85.39) v1(113.13,70.9) v1(113.09,69.98) v1(114.73,70.92) v1(114.73,69.99) v1(115.89,102.05) v1(116.31,70.93) v1(116.32,69.97) v1(117.93,70.01) v1(117.95,70.95) v1(119.51,70.93) v1(119.51,69.98) v1(121.11,70.92) v1(121.1,69.97) v1(122.69,70.91) v1(122.7,69.98) v1(132.04,101.66) v1(134.6,101.93) v1(134.59,98.64) v1(138.84,102.05) v1(141.39,102.05) v1(146.49,98.26) v1(205.63,102.53) v1(206.51,104.38) v1(206.51,103.11) v1(206.51,101.84) v1(206.62,94.85) v1(209.04,104.48) v1(209.7,104.1) v1(210.32,104.38) v1(210.32,103.11) v1(212.86,104.38) v1(213.51,104.13) v1(214.13,104.38) v1(214.13,103.11) v1(216.67,104.38) v1(217.32,104.18) v1(217.94,104.38) v1(217.94,103.11) v3(98.25,30.56) v3(105.59,34.45) v3(108.61,85.15) v3(109.23,35.51) v3(110.07,91.26) v3(113.34,105.88) v3(113.34,98.13) v3(114.72,85.2) v3(115.89,94.43) v3(116.74,98.26) v3(117.59,102.05) v3(117.59,94.43) v3(117.91,85.2) v3(119.29,98.26) v3(119.29,94.43) v3(120.99,105.88) v3(120.99,98.26) v3(121.11,85.2) v3(124.39,101.96) v3(124.39,94.69) v3(134.59,94.43) v3(136.29,94.38) v3(138.83,94.35) v3(139.69,105.88) v3(141.36,94.44) v3(142.24,105.89) v3(143.94,94.3) v3(144.79,105.89)
1P2V_DDR4_CH2_AGND: length 3.8
  TOP w0.203: C7722.2 211.67,96.02 ST26.1 212.93,96.02 213.41,96.49 R6086.1 213.26,96.76 v1(212.86,96.76) 212.47,96.76 C7614.1
1P2V_DDR4_CH2_EN: length 287.7
  L03_SIG1 w0.081: v1(34.61,35.27) 34.63,35.29 34.63,37.2 34.53,37.29 34.53,45.83 35,46.3 35,52.07 31.67,55.4 31.67,60.94 30.93,61.68 30.93,73.65 30.08,74.49 30.08,77.66 29.59,78.14 29.59,79.25 30.83,80.49 31.17,80.49 33.17,82.49 33.17,88.94 32.79,89.31 32.79,89.99 33.38,90.57 33.88,90.57 37.06,93.76 37.06,102.35 35.5,103.91 35.5,104.52 36.28,105.29 40.94,105.29 41.46,105.81 49.28,105.81 50.54,104.55 50.54,103.06 52.07,101.54 53.74,101.54 53.97,101.77 53.97,102.05 55.96,104.04 59.02,104.04 59.02,104.04 60.26,104.04 65.84,109.62 179.15,109.62 181.31,107.46 181.68,107.46 184.08,109.87 194.54,109.87 195.36,109.05 219.35,109.05 v1(221.43,106.97)
  L12_SIG4 w0.089: v1(221.43,106.97) 221.43,102.04 222.73,100.74 222.73,99.06 222,98.34 222,96.36 221.51,95.88 v1(217.94,95.88)
1P2V_DDR4_CH2_PG: length 334.5
  TOP w0.149: v1(209.62,101.39) 209.55,101.39 209.13,101.82 R6090.1
  L03_SIG1 w0.081: v1(187.76,14.35) 187.76,14.1 187.34,13.69 179.4,13.69 178.47,14.62 177.82,14.62 176.86,13.66 139.02,13.66 135.63,10.26 v1(131.62,10.26) ; v1(209.62,101.39) 209.55,101.39 209.55,101.78 209.8,102.02 209.8,103.19 208.99,103.99 208.89,103.99 208.86,104.02 207.97,104.02 207.94,103.99 206.27,103.99 203.21,100.92 202.63,100.92 202.63,100.93 199.42,100.93 198.6,100.1 198.6,98.33 199.17,97.76 199.17,92.65 197.91,91.39 197.91,90.39 197.54,90.03 197.54,88.64 200.37,85.82 201.68,85.82 206.31,81.19 206.31,71.34 208.05,69.59 210.39,69.59 211.55,70.75 219.37,70.75 220.74,69.38 v1(220.74,67.56) ; v1(51.13,8.69) 46.46,13.35 44.78,13.35 44.48,13.66 42.91,13.66 42.77,13.63 41.77,13.63 41.55,13.41 41.23,13.41 35.32,13.41 35.07,13.66 28.99,13.66 27.7,14.94 26.57,14.94 23.9,17.62 23.9,18.3 v1(24.49,18.9)
  L12_SIG4 w0.089: v1(51.13,8.69) 51.52,9.08 126.18,9.08 127.36,10.26 v1(131.62,10.26)
  L16_SIG6 w0.081: v1(220.74,67.56) 222.6,67.56 222.89,67.27 222.89,63.21 222.62,62.94 222.62,62.44 222.9,62.15 222.9,52.46 222.58,52.14 222.58,51.51 223.03,51.05 223.03,45.28 222.51,44.75 222.51,44.25 222.85,43.91 222.85,23.67 222.24,23.06 222.24,21.31 222.85,20.7 222.85,16.29 222.52,15.96 221.8,15.96 219.96,14.12 216.07,14.12 214.32,15.87 208.86,15.87 208.41,15.42 205.01,15.42 204.68,15.1 202.84,15.1 202.31,14.57 201.98,14.57 201.46,15.1 196.29,15.1 195.97,15.42 195.97,15.57 195.6,15.93 195.08,15.93 194.52,15.38 188.78,15.38 v1(187.76,14.35)
  BOTTOM w0.149: v1(209.62,101.39) 209.55,101.39 U139.C3
1P2V_PRE: length 4.8
  TOP w0.381: v1(30.5,23.9) v1(30.5,24.9)
  BOTTOM w0.254: 29.48,26.9 L14.1
  BOTTOM w0.305: v1(32.5,25.9) 32.65,26.06 C514.1
  BOTTOM w0.381: v1(29.5,24.9) 29.62,25.02 30.15,25.02 30.28,24.9 v1(30.5,24.9) ; v1(31.5,25.9) 31.71,25.69 C520.1 ; C522.1 28.49,26 29.39,26.9 29.48,26.9 ; C518.1 v1(31.5,26.9)
  vias: v1(22.05,62.18) v1(23.3,65.28) v1(23.32,62.18) v1(23.32,60.91) v1(24.59,62.18) v1(24.59,60.91) v1(25.09,65.28) v1(27.54,60.01) v1(29.5,26.9) v1(30.5,25.9) v1(31.5,24.9) v1(32.5,23.9) v3(19.64,35.33) v3(19.82,34.75) v3(20.91,33.35) v3(21.04,32.71)
1P8V: length 1.4
  BOTTOM w0.305: v1(117.12,51.11) 117.17,51.06 C1238.2
  BOTTOM w0.508: v1(64.38,54.42) 64.36,54.4 C7717.1
  vias: v1(64.38,55.69) v1(64.38,53.15) v1(66.92,53.15) v1(68.19,54.42) v1(68.19,53.15) v1(70.73,53.15) v1(72,54.42) v1(72,53.15) v1(74.54,53.15) v1(75.81,54.42) v1(75.81,53.15) v1(81.26,59.17) v1(82.89,70.29) v1(82.89,53.14) v1(82.97,52.01) v1(83.89,52.01) v1(84,61.01) v1(83.95,57.92) v1(84.79,70.29) v1(85.77,70.29) v1(88.03,68.64) v1(88.03,45.64) v1(113.93,67.67) v1(113.93,51.11) v1(115.52,67.67) v1(115.52,51.11) v1(117.12,67.67) v1(118.71,67.67) v1(118.71,51.11) v4(77.27,47.85) v4(77.27,47.22) v4(77.9,47.85) v4(77.9,47.22) v4(79.46,47.81) v4(79.46,47.17) v4(80.04,47.81) v4(80.04,47.17) v4(80.65,47.81) v4(80.65,47.17)
1P8V_AGND: length 3.3
  BOTTOM w0.203: v1(70.73,60.77) ST18.1
  BOTTOM w0.254: C7624.1 67.34,60.98 R6093.1 66.05,61.23 65.28,61.23 C7720.2
  vias: v1(66.29,60.98)
1P8V_EN: length 51.8
  L07_SIG3 w0.127: v1(67.55,57.89) 67.28,57.62 64.2,57.62 63.74,57.16 63.74,52.03 58.59,46.88 58.59,46.44 57.4,45.26 51.12,45.26 50.79,44.93 45.51,44.93 45.31,45.13 44.96,45.13 44.82,44.99 42.32,44.99 42.26,44.93 41.32,44.93 40.23,43.84 40.23,41.12 41.24,40.1 41.24,36.12 40.85,35.73 40.85,34.73 41.13,34.45 41.13,32.43 41.42,32.15 41.42,30.09 41,29.67 v1(41,29.57)
1P8V_FLTR:
  vias: v1(86.89,72.89) v1(87,71.45) v1(87.04,70.29) v1(106.76,70.89) v1(106.76,69.97) v1(106.76,69.05) v1(106.76,68.13) v1(122.7,47.89) v1(123.49,47.43) v4(84.97,40.21)
1P8V_MAIN_I2C_SCL: length 142.9
  TOP w0.149: R6057.1 43.66,14.81 U141.2 43.76,16.09 43.76,18.19 44.3,18.73 44.77,18.73 v1(45.38,19.34)
  L03_SIG1 w0.081: v2(36.49,24.9) 37.12,24.27 37.12,22.67 36.82,22.36 36.43,22.36 36.07,22 36.07,19.79 36.36,19.5 39.43,19.5 40.12,20.19 40.12,20.47 40.36,20.7 44.01,20.7 v1(45.38,19.34)
  L12_SIG4 w0.089: v1(137.04,40.53) 136.62,40.1 136.62,36.56 136.43,36.38 136.43,35.96 136.66,35.73 136.66,34.76 136.64,34.74 136.64,33 137.44,32.2 137.44,29.57 137.9,29.11 137.9,27.72 138.2,27.42 138.2,27.11 137.98,26.89 137.67,26.89 137.44,26.66 137.44,20.47 137.69,20.22 137.69,19.11 137.47,18.89 136.89,18.89 135.29,17.29 134.78,17.29 132.51,15.01 128.71,15.01 128.49,15.24 113.52,15.24 113.28,15 69.31,15 64.44,19.86 61.4,19.86 61.04,20.21 58.76,20.21 57.94,21.03 55.34,21.03 54.92,20.61 54.9,20.61 54.07,19.79 47.97,19.79 47.6,19.42 46.15,19.42 46.07,19.34 v1(45.38,19.34)
1P8V_MAIN_I2C_SDA: length 149.8
  TOP w0.149: v1(44.18,14.6) 44.31,14.73 U141.3 44.19,16.11 44.19,18.19 44.42,18.43 45.11,18.43 45.82,19.13 45.82,20.64 46.6,21.42 46.6,21.75 46.68,21.83 v1(46.68,21.82)
  L03_SIG1 w0.081: v2(34.5,24.9) 34.02,24.43 34.02,23.45 34.1,23.37 34.25,23.37 34.34,23.27 34.65,23.27 34.87,23.06 34.87,22.77 35.37,22.27 35.65,22.27 35.87,22.06 35.87,19.71 36.26,19.31 40.08,19.31 41.2,20.43 43.71,20.43 45.18,18.97 45.53,18.97 45.75,19.18 45.75,19.19 45.96,19.4 45.96,21.11 46.68,21.83 v1(46.68,21.82)
  L12_SIG4 w0.089: v1(46.68,21.82) 49,21.82 50.41,23.22 51.21,23.22 51.4,23.03 57.68,23.03 57.88,23.23 58.21,23.23 58.41,23.03 58.86,23.03 60.37,21.52 63.84,21.52 69.41,15.95 129.98,15.95 132.87,18.84 133.13,18.84 133.45,19.16 133.45,19.42 133.72,19.69 135.54,19.69 136.64,20.79 136.64,31.96 135.66,32.94 135.66,35.17 134.44,36.39 134.44,37.59 134.25,37.78 134.25,42 133.4,42.86 v1(133.08,42.86)
  BOTTOM w0.149: R6058.1 v1(44.18,14.6)
1P8V_PG: length 60.2
  TOP w0.127: v1(63.41,45.89) 63.41,46.35 62.55,47.2 58.39,47.2 56.93,45.75 50.66,45.75 49.21,44.29 43.43,44.29 43.23,44.09 43.23,43.46 41.58,41.82 40.22,41.82 36.37,37.97 36.37,35.72 36.7,35.39 36.7,34.85 35.76,33.91 33.88,33.91 33.05,33.09 33.05,31.59 32.81,31.35 31.94,31.35 U34.C9
  L14_SIG5 w0.127: v1(63.41,45.89) 63.41,46.28 63.47,46.34 63.47,57.32 63.84,57.69 66.06,57.69 66.52,57.23 66.52,56.09 v1(66.92,55.69)
  BOTTOM w0.127: R6097.1 66.95,55.68 arc(66.94,55.68) v1(66.92,55.69)
1P8V_PRE: length 15.6
  TOP w0.203: v1(15.35,20.21) 15.21,20.21 14.83,19.83 14.83,19.01 14.6,18.78 R2653.1
  TOP w0.254: 1.35,19.55 1.36,19.56 v1(2.24,19.56) ; v1(38.97,29.31) 39.53,28.75 39.9,28.75 arc(40,28.73) R6192.1
  TOP w0.381: 1.35,19.55 0.82,19.03 0.82,14.53 v1(1.03,14.32) ; U36.B4 4.75,20.07 v1(5.22,20.55) ; v1(17.18,20.55) R2654.1 ; v1(12.36,16.19) 12.41,16.14 C7395.1 C7394.1
  BOTTOM w0.381: R2699.2 v1(6.65,17.67) ; v1(2.24,19.56) 2.73,19.07 U104.B4 ; U103.B4 v1(15.35,20.21) ; v1(12.36,16.19) 12.36,16.22 U103.D1 ; U103.E4 v1(11.35,20.21)
  vias: v1(4.54,22.9) v1(5.36,22.48) v1(5.6,24.88) v1(6.39,24) v1(6.77,22.5) v1(9.74,42.73) v1(9.74,41.46) v1(11.01,42.73) v1(11.01,41.46) v1(11.01,40.19) v1(32.5,20.9) v1(33.19,16.41) v1(33.5,20.9) v1(33.62,15.98) v1(35.5,27.9) v1(35.5,26.9) v1(35.5,21.9) v2(35.5,25.9) v2(35.5,24.9) v2(35.5,23.9) v2(35.5,22.9)
1P8V_SI52204: length 4.8
  TOP w0.203: U23.6 44.85,37.81 v1(44.71,37.67) ; U23.5 v1(44.76,38.31)
  TOP w0.254: U23.24 v1(51.06,40.31) ; U23.31 v3(46.64,41.73) ; U23.19 v3(51.06,37.81) ; U23.15 v3(49.14,35.38) ; U23.29 v3(47.64,41.73)
  vias: v4(42.81,41.99) v4(43.7,41.99)
1P8V_VCCCLK_GXF: length 8.3
  BOTTOM w0.216: 102.78,67.96 103.4,68.59 103.74,68.59 104.19,68.14 104.55,68.14 105,68.59 105.35,68.59 105.52,68.76 105.92,69.37 R856.1
  BOTTOM w0.229: R145.2 102.03,68.71 102.42,68.31 102.42,68.31 102.78,67.96
  BOTTOM w0.254: C1273.2 v1(101.98,65.37)
  BOTTOM w0.305: 102.78,67.96 v1(102.78,65.83)
  vias: v1(85.6,62.57) v1(86.75,64.29) v1(86.68,62.52)
1P8V_VCCH_GXR:
  vias: v1(83.85,51.34) v1(83.89,49.14) v1(86.8,48.53) v1(86.8,47.27) v1(86.89,51.14) v1(101.98,51.57) v1(101.98,50.65) v1(101.98,49.73) v1(102.77,51.11) v1(102.77,50.19) v1(103.57,51.57) v1(103.57,49.73) v1(129.07,59.85) v1(129.07,58.01) v1(129.87,59.39) v1(129.87,58.47) v1(130.66,59.85) v1(130.66,58.93) v1(130.66,58.01)
2P5V: length 72.4
  TOP w0.381: v1(118.4,92.53) 117.2,91.33 114.84,91.33 114.47,91.7 111.23,91.7 110.51,92.42 103.75,92.42 103.34,92.01 97.62,92.01 97.05,92.58 72.94,92.58 72.53,92.98 72.53,94.04 J1.284
  BOTTOM w0.254: R293.2 v1(218.64,65.1) ; U29.8 59.61,30.84 v1(60.08,30.36) ; R291.2 216.8,62.44 v1(217.43,63.07) 216.8,63.71 R303.2 ; R292.2 v1(217.43,61.42)
  BOTTOM w0.305: 64.61,34.74 64.88,35 65.44,35 ; 65.44,35 C483.1 ; 65.44,35 v1(65.64,34.8) ; R329.2 v1(66.49,33.99)
  BOTTOM w0.381: R994.2 204.85,66.59 v1(205.22,66.22) ; R94.1 70.64,94.5 v1(70.84,94.69) ; R83.2 94.51,104.51 94.26,104.26 U12.14 95.12,103.36 95.33,103.57 95.63,103.57 v1(95.65,103.55) ; v1(161.42,25.81) 161.58,25.96 162.13,25.96 C193.2 ; R1069.2 71.67,97.91 71.97,97.61 R1068.2 72.59,97.04 v1(72.17,96.62) ; C96.2 67.13,26.24 v1(67.11,26.22) ; R99.2 102.69,104.4 102.39,104.1 U13.14 102.75,103.23 103.45,103.93 v1(103.92,103.93) v1(104.81,103.93) ; 64.61,34.74 U29.1
  vias: v1(59.95,22.76) v1(67.04,106.19) v1(67.42,101.32) v1(67.62,106.19) v1(67.7,98.35) v1(68,98.96) v1(68.15,106.16) v1(68.31,98.35) v1(68.99,28.13) v1(69.99,102.31) v1(69.99,94.69) v1(70.84,102.31) v1(72.17,95.72) v1(72.45,104.57) v1(72.45,103.67) v1(75.39,17.73) v1(77.17,82.23) v1(79.18,28.14) v1(82.38,25.68) v1(82.38,25.15) v1(85.58,17.74) v1(89.34,28.14) v1(92.54,25.68) v1(92.54,25.15) v1(95.74,17.74) v1(96.54,103.58) v1(99.5,28.14) v1(100.12,104.88) v1(102.67,25.73) v1(102.67,25.12) v1(105.9,17.74) v1(109.66,28.14) v1(112.88,25.66) v1(112.88,25.12) v1(116.06,17.74) v1(122.87,28.06) v1(126.11,25.65) v1(126.11,25.14) v1(129.27,17.66) v1(133.03,28.06) v1(136.24,25.65) v1(136.24,25.14) v1(139.43,17.66) v1(143.19,28.06) v1(146.4,25.65) v1(146.4,25.14) v1(149.59,17.66) v1(153.35,28.1) v1(156.56,25.69) v1(156.56,25.18) v1(159.75,17.7) v1(163.51,28.06) v1(169.91,17.66) v1(205.98,16.94) v1(207.25,18.21) v1(207.25,16.94) v1(207.86,16.11) v1(208.52,18.21) v1(208.52,16.94) v1(213.3,68.02) v1(214,68.02) v3(69.99,105.88) v3(69.98,98.73) v3(70.84,105.88) v3(70.78,99.34) v3(70.84,98.26) v3(72.54,102.31) v3(72.54,94.69)
2P5V_AGND: length 0.7
  TOP w0.203: ST27.1 205.68,14.05 v1(205.68,14.05)
  vias: v1(202.15,14.96)
2P5V_EN: length 198.8
  TOP w0.127: v1(202.72,17.81) 202.79,17.75 202.79,14.71 202.32,14.24 v1(200.93,14.24)
  L16_SIG6 w0.127: v1(200.93,14.24) 200.57,14.61 195,14.61 194.72,14.89 189.22,14.89 188.06,13.73 140.51,13.73 139.99,13.62 139.9,13.59 138.69,13.59 135.3,10.19 132.92,10.19 132.91,10.2 132.57,10.2 132.57,10.19 132.15,10.19 131.8,9.85 129.9,9.85 126.96,6.91 60.56,6.91 58.31,9.15 56.73,9.15 56.6,9.02 51.38,9.02 50.31,10.09 49.73,10.09 48.72,11.1 46.08,11.1 45.62,11.55 45.48,12.25 45.09,12.64 45.07,12.64 42.52,15.19 42.27,15.19 39.79,17.67 39.79,21.71 39.9,21.83 39.9,22.44 39.74,22.59 39.74,30.21 38.51,31.45 36,31.45 34.91,32.54 34.91,33.04 34.64,33.32 34.06,33.32 31.89,35.49 v1(31.89,35.88)
  BOTTOM w0.127: R6241.1 32.22,35.58 31.91,35.88 31.91,35.88 v1(31.89,35.88)
2P5V_PG: length 199.1
  L03_SIG1 w0.127: v2(30.5,22.9) 31.1,22.3 31.66,22.3 32.89,21.07 32.89,19.95 34.44,18.4 34.44,17.2 35.37,16.27 35.89,16.27 35.99,16.37 36.29,16.37 36.34,16.32 39.43,16.32 39.86,16.75 41.47,16.75 41.59,16.63 42.41,16.63 42.85,17.06 43.63,17.06 v1(44.59,18.02)
  L14_SIG5 w0.127: v1(134.38,11.61) 134.19,11.42 132.5,11.42 132.2,11.12 130.54,11.12 126.11,6.7 64.68,6.7 61.06,10.32 61.06,11.41 61.5,11.86 61.5,12.44 61.24,12.7 61.24,14.48 59,16.73 55.68,16.73 52.87,19.53 51.92,19.53 49.9,21.54 48.43,21.54 47.66,20.77 47.66,19.52 46.14,18 44.61,18 44.61,18.02 v1(44.59,18.02)
  L16_SIG6 w0.127: v1(205.98,18.18) 205.94,18.21 205.35,18.21 202.54,15.4 199.3,15.4 198.5,16.21 194.99,16.21 194.42,15.63 188.43,15.63 187.11,14.31 179.4,14.31 178.34,15.38 176.84,15.38 175.7,14.24 140.46,14.24 139.84,14.11 139.83,14.11 136.2,14.11 134.38,12.29 v1(134.38,11.61)
  BOTTOM w0.254: R2788.1 205.79,18.37 v1(205.98,18.18)
2P5V_PRE: length 3.6
  BOTTOM w0.381: v1(20.92,35.08) v1(20.92,35.72)
  BOTTOM w0.508: v1(20.92,35.08) 20.92,34.64 21.44,34.11 21.6,34.11 21.98,33.73 L12.1
  vias: v1(27.13,35.54) v1(32.87,43) v1(32.87,41.73) v1(34.14,43) v1(34.14,41.73) v1(34.14,40.46) v1(34.93,41.02) v1(36.29,44.62)
2P5V_SI53254_2: length 8.4
  BOTTOM w0.203: 206.86,64.57 206.9,64.6 U25.18
  BOTTOM w0.254: v1(214,59.77) 213.41,60.36 U25.1 ; U25.4 v1(211.34,59.49) ; 206.94,63.1 U25.15 ; U25.9 v1(208.84,59.34)
  BOTTOM w0.305: C1395.1 205.7,62.18 206.62,63.1 206.94,63.1
  BOTTOM w0.381: v1(205.3,64.77) 206.28,64.77 206.48,64.57 206.86,64.57
  vias: v1(211.46,68.02) v1(212.16,68.02) v3(205.32,62.23)
3P3V: length 56.7
  TOP w0.203: U129.A3 182.64,68.57 v1(182.24,68.96) 182.46,69.18 v1(182.68,69.18) ; U84.10 45.54,28.13 45.6,28.19 46.06,28.19 46.06,28.18 46.09,28.18
  TOP w0.254: 46.09,28.18 46.19,28.08 R816.1 46.51,28.14 C977.2 46.83,29.67 v1(47.11,29.67) 47.42,29.37 R815.1
  TOP w0.381: R6089.2 v1(212.26,102.71) ; R5877.2 v1(176.31,57.47) ; v1(176.95,43.94) 176.81,43.8 176.81,43.52 R5957.1 ; R6290.1 238.21,20.7 v1(238.19,20.72) R6289.1 ; v1(194.53,63.74) 193.59,62.79 R6292.2 ; R853.1 v1(178.58,54.05) ; v4(40.55,84.69) v4(40.55,85.4) 40.55,85.42 40.52,85.45 40.52,86.03 v4(40.55,86.06) ; v1(190.24,55.47) 190.24,55.52 189.55,56.21 R5878.2 ; v1(208.38,102.6) 208.49,102.71 R6090.2 ; R6084.2 v1(209.65,97.12) ; v4(41.74,86.06) 41.71,86.03 41.71,85.45 41.74,85.42 v4(41.74,85.4) v4(41.74,84.69) ; v1(176.93,53.83) R6024.2
  BOTTOM w0.203: R6147.2 69.22,69.7 68.91,70.01 R5929.2 ; R6176.1 26.43,16.71 27.53,16.71 27.86,17.05 v1(27.86,17.2)
  BOTTOM w0.254: R5845.2 186.23,83.09 186.23,82.4 186.22,82.39 v1(186.22,82.21)
  BOTTOM w0.305: R6164.1 180.99,37.82 v1(180.72,38.1) 180.45,37.84 180.45,37.62 180.67,37.41 R5958.1 ; R6147.2 R5934.2
  BOTTOM w0.381: v1(69.82,57.57) 69.82,57.54 70.11,57.26 R6096.2 ; R6166.2 65.42,35.87 64.8,35.87 63.65,35.87 63.35,36.17 R6145.2 ; R6025.2 176.93,54.53 v1(176.93,53.83) ; v1(60.65,35.3) 60.81,35.46 62.3,35.46 62.73,35.89 R6145.2 ; v1(202.77,21.35) 202.72,21.3 R6171.1 ; R6036.2 176.31,57.35 v1(176.31,57.47) ; R838.2 31.06,82.37 30.97,82.46 v1(30.97,82.48) ; R5930.2 75.72,70.01 v1(75.72,70.01) ; R6145.2 62.73,41.97 62.48,42.22 62.48,46.05 63.37,46.94 R918.2 R920.2 ; v1(176.95,43.94) R6163.1 177.11,43.92 R5956.1 R6283.2 ; v1(69.44,68.87) 69.41,68.87 R5934.2 ; v1(70.65,66.35) 70.66,66.35 R5931.2 ; R6045.2 184.31,21.01 184.32,21.02 184.32,21.56 184.31,21.57 v1(184.31,21.97) ; R6044.2 v1(185.6,19.36)
  vias: v1(23.35,109.39) v1(23.46,108.33) v1(25.39,109.59) v1(29.52,17.06) v1(66.11,58.83) v1(66.86,67.49) v1(67.6,87.37) v1(67.6,56.56) v1(184.89,82.04) v1(185.36,92.53) v1(185.96,92.79) v1(186.27,84.84) v1(187.76,66.78) v1(188.2,66.45) v1(188.65,66.2) v1(188.83,81.98) v1(190.08,79.48) v1(194.5,67.01) v1(200.25,99.26) v1(200.25,98.75) v1(200.76,99.26) v1(200.76,98.75) v1(201.26,99.26) v1(201.26,98.75) v1(201.77,99.26) v1(201.77,98.75) v1(230.17,36.96) v4(36.96,84.74) v4(36.96,83.72) v4(37.73,84.74) v4(37.73,83.72) v4(38.49,84.74) v4(38.49,83.72) v4(55.38,109.15) v4(55.38,108.51) v4(56.01,109.15) v4(56.01,108.51) v4(56.65,109.15) v4(56.65,108.51) v4(57.28,109.15) v4(57.28,108.51) v4(57.92,109.15) v4(57.92,108.51) v4(58.55,109.15) v4(58.55,108.51) v4(229.32,51.95) v4(229.34,50.9) v4(229.32,49.58) v4(229.67,55.45) v4(229.67,54.43) v4(229.67,53.42) v4(231.43,54.94) v4(231.43,53.93) v4(231.43,52.91) v4(231.43,51.89) v4(232.44,54.94) v4(232.44,53.93) v4(232.44,52.91) v4(232.44,51.89) v4(233.46,54.94) v4(233.46,53.93) v4(233.46,52.91) v4(233.46,51.89) v4(234.47,54.94) v4(234.47,53.93) v4(234.47,52.91) v4(234.47,51.89) v4(235.49,54.94) v4(235.49,53.93) v4(235.49,52.91) v4(235.49,51.89) v4(237.06,55.19) v4(237.07,54.43) v4(237.07,53.42) v4(237.22,52.02) v4(237.24,51.08) v4(237.4,49.81)
3P3V_AGND: length 1
  TOP w0.203: ST3.1 236.25,36.83 236.06,36.64 v7(236.06,36.55)
  vias: v7(235.21,36.58) v7(235.27,37.42) v7(236.15,37.37)
3P3V_EN: length 257.5
  TOP w0.203: U137.2 236.03,41.98 236.59,41.42 v1(236.71,41.42) R6267.2
  L12_SIG4 w0.127: v1(136.21,12.91) 136.21,13.23 136.96,13.99 177.22,13.99 177.89,14.66 178.24,14.66 179.03,13.87 189.52,13.87 190.53,14.89 191.92,14.89 193.32,13.49 241,13.49 243.42,15.91 243.42,29.09 238.1,34.41 238.1,39.62 237.94,39.78 237.94,40.19 v1(236.71,41.42)
  L14_SIG5 w0.127: v1(39.38,33.24) 41.79,33.24 42.66,32.36 42.66,31.58 46.61,27.63 48.34,27.63 48.66,27.94 50.65,27.94 50.76,28.05 53.65,28.05 55.54,26.16 55.54,25.76 56.17,25.13 56.79,25.13 57.53,24.39 58.03,24.39 58.6,23.83 58.6,22.71 60.8,20.51 61.44,20.51 63.96,17.99 63.96,15.92 66.8,13.07 119.66,13.07 120.96,14.38 120.98,14.38 121,14.39 126.47,14.39 127.94,12.92 129.56,12.92 130.15,13.51 135.6,13.51 v1(136.21,12.91)
  BOTTOM w0.127: R6228.2 33.73,33.91 35.84,33.91 35.9,33.98 37.44,33.98 38.17,33.24 v1(39.38,33.24)
3P3V_PG: length 269.7
  TOP w0.127: U137.26 233.68,40.05 234.14,39.59 v1(234.14,39.08) ; v1(137.56,10.92) 137.56,12.64 138.73,13.82 186.29,13.82 187.27,14.8 190.37,14.8 v1(190.71,14.47)
  L05_SIG2 w0.127: v1(190.71,14.47) 190.86,14.63 193.87,14.63 195.05,13.45 233.15,13.45 v1(235.12,15.42)
  L14_SIG5 w0.127: v1(137.56,10.92) 135.8,10.92 135.17,10.29 132.19,10.29 131.69,10.78 130.88,10.78 126.51,6.42 64.57,6.42 60.78,10.2 60.78,11.53 61.23,11.98 61.23,12.32 60.96,12.58 60.96,14.37 58.89,16.45 55.55,16.45 52.75,19.25 51.8,19.25 49.78,21.27 48.55,21.27 47.99,20.7 47.99,19.45 46.25,17.72 45.79,17.72 45.11,17.05 44.77,17.05 44.53,17.29 44.53,17.34 44.2,17.67 44.2,18.43 44.7,18.93 44.7,19.73 44.19,20.24 42.17,20.24 38.09,24.32 33.18,24.32 32.89,24.61 32.89,27.65 33.1,27.86 33.1,28.07 33.33,28.3 33.54,28.3 34.1,28.86 34.1,29.07 34.33,29.3 34.54,29.3 34.89,29.65 34.89,31.07 34.64,31.32 27.08,31.32 v1(25.5,32.9)
  L16_SIG6 w0.127: v1(234.14,39.08) 233.95,39.08 233.29,38.42 233.29,19.2 234.13,18.36 234.13,16.4 v1(235.12,15.42)
3P3V_STBY: length 254
  TOP w0.203: v1(17.73,15.48) U38.14
  TOP w0.254: EU1.1 70.98,81.49 v1(70.96,81.51) ; v1(50.95,11.45) R148.2 49.19,11.45 49.14,11.39 v1(49.14,11.39)
  TOP w0.381: R498.2 242.2,72.41 v1(242.2,71.58) ; v1(48.88,20.63) 49.18,20.32 R171.2 ; v1(42.19,18.41) 41.8,18.01 41.32,18.01 40.94,17.63 R384.2 ; v1(41.1,14.35) C500.1 40.18,14.57 C501.1 Y4.4 ; v1(128.28,36.2) 128.53,35.94 C7400.1 ; R170.2 48.85,15.1 v1(49.66,15.1) ; v1(43.2,19.19) 43.01,19.39 U141.8 42.92,20.52 C7575.2 40.68,20.52 C7402.1 ; v1(73.77,11.45) 73.07,12.15 63.27,12.15 59.52,15.89 v1(58.68,15.89)
  L12_SIG4 w0.254: v1(50.22,28.82) 50.22,29.47 50.92,30.17 58.81,30.17 59.48,30.84 60.88,30.84 62.29,29.44 v1(62.29,29.43)
  L12_SIG4 w0.508: v1(14.62,108.06) 12.05,108.06 10.62,106.64 10.62,96.75 1.49,87.62 1.49,74.56 1.87,74.18 4.92,74.18 5.46,74.72 14.14,74.72 v1(14.8,75.39)
  L14_SIG5 w0.508: v4(248.67,43.77) 249.34,43.1 249.34,37.15 249.33,37.14 248.84,37.14 247.87,36.18 247.87,35.32 245.51,32.96 v1(244.86,32.96)
  L16_SIG6 w0.508: v1(244.86,32.96) v1(244.02,32.96)
  BOTTOM w0.203: R6059.2 46.04,21.74 45.55,21.24 45.33,21.24
  BOTTOM w0.254: v1(77.28,78.72) 77.31,78.69 77.31,78.33 76.87,77.89 R453.2 ; 44.33,21.68 R6060.2 ; 44.33,21.68 43.2,20.55 v1(43.2,19.19) ; 44.33,21.68 44.33,21.65 44.73,21.24 45.33,21.24 ; EU2.1 168.53,90.14 168.21,89.82 ; U107.21 200.71,19.67 v1(201.07,20.04)
  BOTTOM w0.305: v4(248.67,43.77) 249.12,43.77 R362.2 ; 94.93,31.68 95.48,31.14 95.48,30.52 96.5,29.49 102.41,29.49 102.76,29.84 109.36,29.84 109.37,29.85 ; v1(56.71,15.7) 56.01,15.7 55.76,15.95 U16.8
  BOTTOM w0.381: v3(36.9,50.88) 36.85,50.93 U40.19 ; R6211.1 R6210.1 v1(3.07,34.89) ; v1(14.62,108.06) R2741.2 ; v1(58.68,15.89) 59.81,15.89 60.81,16.89 60.81,24.05 62.78,26.03 62.78,27.03 62.84,27.09 62.84,28.88 v1(62.29,29.43) 62.59,29.43 62.82,29.66 66.67,29.66 66.86,29.85 76.87,29.85 77.64,30.62 91.34,30.62 92.77,32.06 94.55,32.06 94.93,31.68 ; R465.2 174.68,92.03 175.25,91.46 v1(175.25,91.39) ; C540.1 29.5,29.91 v1(29.5,30.9) ; v1(50.95,11.45) 50.95,11.45 R147.2 ; v1(200.84,16.06) 200.55,15.76 v1(197.16,15.76) ; C529.1 v1(26.5,24.9) R6215.1 ; v1(70.96,81.51) 70.96,79.92 C565.1 ; v1(40.52,20.31) 40.53,20.32 U106.19 ; C555.1 21.34,22.68 ; v1(50.22,28.82) 50.01,28.6 50.01,23.68 48.48,22.15 48.48,21.02 v1(48.88,20.63) ; C535.1 v1(21.46,21.61) ; U105.19 128.3,36.22 v1(128.28,36.2) 128.28,35.81 127.44,34.97 127.44,34.53 126.21,33.3 126.21,32.67 126.89,31.99 R6191.2 111.25,31.73 109.37,29.85 ; v1(167.89,89.06) 167.89,89.5 168.21,89.82 ; v1(227.13,105.5) 226.7,105.06 J10.4 ; R367.2 v1(245.94,63.32) ; R2727.1 v4(231.99,96.6)
  vias: v1(7.9,26.66) v1(8.13,26.22) v1(14.82,51.2) v1(14.8,49.15) v1(14.93,54.49) v1(14.93,53.22) v1(14.93,51.95) v1(20.99,42.9) v1(20.99,41.63) v1(21.46,20.01) v1(21.46,19.21) v1(22.13,45.24) v1(22.26,42.9) v1(22.26,41.63) v1(22.26,40.36) v1(26.14,35.2) v1(26.5,26.9) v1(26.5,25.9) v1(26.5,23.9) v1(26.5,22.9) v1(26.79,50.52) v1(26.79,49.74) v1(27.65,49.74) v1(27.77,34.81) v1(28.5,20.9) v1(28.76,35.07) v1(29.5,29.9) v1(29.5,20.9) v1(29.6,35.05) v1(30.5,29.9) v1(30.5,20.9) v1(31.27,35.03) v1(32.5,29.9) v1(33.5,29.9) v1(37.85,44.14) v1(47.89,12.58) v1(52.66,13.79) v1(53.79,12.4) v1(201.4,19.17) v1(211.59,85.23) v1(228.2,105.53) v1(229.37,106.42) v1(230.51,106.45) v1(233.05,106.45) v1(238.89,72.66) v1(241.31,79.77) v1(246.01,56.97) v1(246.13,65.1) v1(250.43,33.81) v1(250.65,33.35) v1(250.96,33.81) v3(21.02,22.86) v3(21.63,22.86) v3(35.9,50.41)
3P3V_USBPHY: length 15.1
  TOP w0.229: v1(16.62,24.28) 16.11,24.8 U143.11
  TOP w0.254: v1(19.12,26.75) 19.01,26.86 U143.17 ; U143.43 v1(9.79,32.36) ; U143.7 14.11,24.67 v1(13.77,24.34) ; U143.32 16.11,33.64 v3(16.12,33.66) ; v1(9.66,26.49) 9.79,26.36 U143.55 ; U143.27 v1(19.06,31.86)
  TOP w0.381: v1(12.07,24.21) 12.11,24.25 U143.3
  BOTTOM w0.381: v1(36.76,35.88) C495.2 37.38,35.88 38.01,36.51 U33.4 ; v1(19.12,26.75) C505.1 ; v1(9.79,32.36) 9.79,32.36 C509.1 ; C507.1 C506.1 ; v1(13.77,24.34) 13.98,24.54 C504.1 ; C508.1 v3(16.12,33.66) ; C502.1 v1(12.07,24.21) ; C503.1 16.62,25.01 v1(16.62,24.28)
  vias: v1(6.88,33.12) v1(18.14,21.99) v1(19.04,21.99)
24M_XTALIN: length 5
  TOP w0.149: Y3.1 C497.1 12.19,22.5 13.11,23.42 U143.5
24M_XTALOUT: length 10.6
  TOP w0.149: U143.4 12.61,23.91 11.92,23.22 8.26,23.22 7.86,22.81 7.86,20.88 8.35,20.39 C7676.1 8.8,21.31 Y3.3
6301_AGND: length 10.9
  L03_SIG1 w0.254: v1(184.92,66.89) 184.66,66.64 183.33,66.64 182.48,67.49 181.2,67.49 180.31,68.38 178.6,68.38 177.77,67.55 177.77,67.19 v1(177.81,67.15)
  BOTTOM w0.203: ST28.2 185.43,66.5 185.43,66.69 185.22,66.89 v1(184.92,66.89)
  BOTTOM w0.381: v1(184.92,66.89) 184.53,66.89 184.39,66.75 C7718.2
ADC_VREF: length 9.9
  TOP w0.203: v1(26.5,28.9) 26.01,29.39 26.01,31.37 v1(26.02,31.37) 25.98,31.41 23.07,31.41
  TOP w0.254: 23.07,31.41 21.52,32.96 TP1.1
  BOTTOM w0.381: C7405.1 26.25,31.14 v1(26.02,31.37)
AVST8_CLK: length 112.5
  L07_SIG3 w0.089: v1(102.78,79.63) 102.78,79.98 102.09,80.67 101.84,80.67 101.64,80.87 101.64,81.5 99.63,83.51 89.67,83.51 84.27,78.11 73.91,78.11 73.73,78.29 72.52,78.29 72.22,77.99 63.93,77.99 52.47,66.52 45.54,66.52 42.98,63.97 42.98,60.61 37.43,55.06 37.43,53.04 37.95,52.52 37.95,51.64 37.36,51.06 37.36,49.73 35.42,47.79 35.42,45.57 35.09,45.23 35.09,42.81 35.38,42.52 35.38,36.89 35.76,36.51 35.88,36.51 36.18,36.21 36.18,35.62 35.18,34.63 v1(35.18,33.49)
  BOTTOM w0.149: R391.2 36,31.19 35.74,31.45 33.29,31.45 33.09,31.65 33.09,32.07 33.33,32.31 33.55,32.31 33.94,32.7 33.94,33.19 34.23,33.49 v1(35.18,33.49)
AVST8_CLK_R:
  vias: v1(36.49,29.9)
AVST8_DATA0: length 116.1
  L07_SIG3 w0.089: v1(104.37,76.87) 104.37,77.16 103.94,77.59 103.94,78.09 103.95,78.09 103.95,78.4 103.73,78.62 103.42,78.62 103.13,78.33 102.43,78.33 102.14,78.62 100.99,78.62 100.31,79.3 98.28,79.3 98.03,79.55 97.08,79.55 96.83,79.3 96.55,79.3 96.05,79.8 93.56,79.8 93.39,79.98 92.67,79.98 92.5,79.8 92.22,79.8 92.05,79.98 90.94,79.98 90.77,79.8 90.49,79.8 90.31,79.98 89.21,79.98 89.03,79.8 88.76,79.8 88.65,79.91 87.22,79.91 84.76,77.45 74.59,77.45 73.74,76.6 72.52,76.6 71.98,77.15 64.05,77.15 55.75,68.85 55.75,68.72 56.06,68.41 56.06,68.29 55.93,68.16 55.81,68.16 55.5,68.47 55.37,68.47 55.25,68.34 55.25,68.22 55.56,67.91 55.56,67.78 55.43,67.66 55.31,67.66 54.99,67.97 54.87,67.97 54.74,67.84 54.74,67.72 55.05,67.41 55.05,67.28 54.93,67.15 54.8,67.15 54.49,67.46 54.37,67.46 54.24,67.34 54.24,67.21 54.55,66.9 54.55,66.78 54.43,66.65 54.3,66.65 53.99,66.96 53.86,66.96 53.74,66.84 53.74,66.71 54.05,66.4 54.05,66.27 53.92,66.15 53.8,66.15 53.49,66.46 53.36,66.46 52.76,65.86 45.87,65.86 44.04,64.03 44.04,59.69 39.06,54.71 39.06,53.84 39.85,53.05 39.85,51.79 38.26,50.2 38.26,48.58 38.4,48.43 38.4,47.27 37.58,46.45 37.24,46.45 35.78,44.98 35.78,43.84 36.22,43.4 36.22,43.07 36.11,42.95 36.11,39.32 36.7,38.72 36.7,36.97 37.49,36.18 37.49,35.26 37.28,35.04 37.28,34.38 37.23,34.34 37.23,33.91 36.6,33.28 36.34,33.28 36.09,33.03 36.09,30.77 36.34,30.53 37.06,30.53 37.44,30.9 v1(37.5,30.9)
AVST8_DATA1: length 116.8
  L07_SIG3 w0.089: v1(103.57,73.65) 103.73,73.65 103.95,73.43 103.95,72.57 103.59,72.21 103.25,72.21 102.93,71.89 102.62,71.89 102.25,72.26 101.66,72.26 101.32,72.61 101.04,72.61 100.65,72.21 100.37,72.21 99.77,72.81 99.43,72.81 99.2,73.05 98.12,73.05 97.7,73.48 97.42,73.48 97.21,73.26 96.53,73.26 96.16,73.64 96.16,74.28 95.96,74.48 95.68,74.48 95.4,74.2 95.14,74.2 95.05,74.22 94.94,74.23 94.48,74.23 94.23,74.48 93.95,74.48 93.67,74.2 92.95,74.2 92.62,73.86 92.56,73.82 92.49,73.79 92.42,73.77 92.35,73.76 92.27,73.77 92.2,73.8 91.53,74.19 91.06,74.19 90.77,74.48 90.49,74.48 90.24,74.23 89.28,74.23 89.03,74.48 88.76,74.48 88.5,74.22 87.68,74.22 87.67,74.23 87.55,74.23 87.18,73.87 85.82,73.87 84.63,72.67 84.63,72.47 84.21,72.05 79.81,72.05 78.98,71.23 78.98,70.29 79.39,69.89 79.39,64.1 77.71,62.42 64.05,62.42 62.9,61.27 62.9,52.23 57.9,47.23 57.9,46.73 57.12,45.94 54.86,45.94 54.77,46.03 54.77,46.18 54.68,46.27 54.52,46.27 54.43,46.18 54.43,46.03 54.34,45.94 54,45.94 53.91,46.03 53.91,46.45 53.82,46.54 53.64,46.54 53.55,46.45 53.55,46.03 53.46,45.94 53.29,45.94 53.2,46.03 53.2,46.45 53.11,46.54 52.93,46.54 52.84,46.45 52.84,46.03 52.75,45.94 52.58,45.94 52.49,46.03 52.49,46.45 52.4,46.54 52.22,46.54 52.13,46.45 52.13,46.03 52.04,45.94 51.86,45.94 51.78,46.03 51.78,46.45 51.69,46.54 51.51,46.54 51.42,46.45 51.42,46.03 51.33,45.94 44.96,45.94 44.94,45.93 44.26,45.93 44.24,45.94 42.12,45.94 41.41,46.66 40.8,46.66 39.27,45.12 39.27,43.99 38.61,43.33 38.61,39.9 39.48,39.02 39.48,38.34 40.21,37.61 40.21,37.01 39.87,36.67 39.87,35.71 40.13,35.45 40.13,34.48 40.45,34.16 40.45,33.1 40.13,32.79 40.13,31.5 38.95,30.32 38.33,30.32 38.12,30.11 38.12,28.68 38.5,28.31 v1(38.5,27.9)
AVST8_DATA2: length 113.3
  L07_SIG3 w0.089: v1(103.58,77.33) 103.58,76.96 104.04,76.49 104.41,76.49 104.74,76.16 104.74,74.87 104.74,74.87 104.74,72.11 104.52,71.89 104.35,71.89 103.72,71.26 103.42,71.26 103.17,71.01 102.58,71.01 102.12,71.47 101.59,71.47 101.34,71.72 100.83,71.72 100.54,71.43 100.01,71.43 99.55,71.89 99.43,71.89 99.3,72.03 98.01,72.03 97.72,71.74 97.06,71.74 96.83,71.98 96.49,71.98 95.49,72.98 94.56,72.98 94.25,72.8 94.18,72.77 94.1,72.76 94.03,72.77 93.96,72.79 93.89,72.82 93.83,72.86 93.4,73.3 92.67,73.3 92.5,73.48 91.81,73.48 91.63,73.3 90.94,73.3 90.66,73.59 90.35,73.59 90.02,73.91 89.96,73.96 89.89,73.99 89.82,74.01 89.75,74.02 89.68,74.01 89.61,73.98 88.92,73.59 88.51,73.59 88.18,73.26 87.55,73.26 87.29,73.52 85.94,73.52 84.96,72.53 84.96,71.88 84.07,70.99 82.73,70.99 82,71.72 79.94,71.72 79.31,71.09 79.31,70.43 79.72,70.03 79.72,63.96 77.84,62.08 64.19,62.08 63.23,61.13 63.23,52.09 63.09,51.95 63.09,51.88 58.23,47.03 58.23,46.59 57.25,45.61 50.97,45.61 50.96,45.6 41.53,45.6 41.21,45.28 41.18,45.28 39.88,43.98 39.88,40.92 39.74,40.78 39.74,39.71 40.89,38.56 40.89,36.27 40.47,35.84 40.47,34.62 40.78,34.3 40.78,33.14 40.47,32.82 40.47,31.36 39.01,29.9 v1(38.5,29.9)
AVST8_DATA3: length 114.4
  TOP w0.149: U34.D15 37.18,29.79 36.8,29.42 v1(36.12,29.42)
  L07_SIG3 w0.089: v1(102.78,78.71) 103.24,79.17 103.24,80.64 99.93,83.95 89.64,83.95 88.84,83.15 88.71,83.15 88.53,83.33 88.41,83.33 88.28,83.21 88.28,83.08 88.46,82.9 88.46,82.77 84.14,78.45 78.11,78.45 77.44,79.12 77.11,79.12 76.62,78.62 72.39,78.62 72.08,78.32 63.8,78.32 52.33,66.86 45.29,66.86 42.65,64.21 42.65,60.75 37.1,55.2 37.1,51.68 36.48,51.06 36.48,49.99 35.09,48.6 35.09,45.78 34.53,45.22 34.53,40.85 34.73,40.65 34.73,35.78 35.01,35.49 35.01,35.1 34.75,34.85 34.75,33.21 34.94,33.02 34.94,30.89 35.33,30.5 35.89,30.5 36.12,30.28 v1(36.12,29.42)
AVST8_DATA4: length 115.3
  L07_SIG3 w0.089: v1(103.58,78.25) 103.11,77.79 103.11,77.65 102.92,77.45 102.64,77.45 102.22,77.87 101.76,77.87 101.69,77.8 100.88,77.8 100.43,78.25 99.76,78.25 98.94,79.07 97.97,79.07 97.7,78.8 96.64,78.8 95.85,79.59 93.65,79.59 93.36,79.3 93.09,79.3 92.8,79.59 91.92,79.59 91.63,79.3 91.35,79.3 91.06,79.59 90.19,79.59 89.9,79.3 89.62,79.3 89.35,79.58 88.18,79.58 85.72,77.11 77.25,77.11 76.4,76.27 72.39,76.27 72.13,76.52 65.08,76.52 61.38,72.82 61.25,72.82 60.88,73.19 60.76,73.19 60.63,73.07 60.63,72.94 61,72.57 61,72.45 60.87,72.32 60.75,72.32 60.38,72.69 60.25,72.69 60.13,72.56 60.13,72.44 60.5,72.07 60.5,71.94 60.37,71.82 60.24,71.82 59.88,72.19 59.75,72.19 59.63,72.06 59.63,71.93 59.99,71.57 59.99,71.44 59.87,71.31 59.74,71.31 59.37,71.68 59.25,71.68 59.12,71.56 59.12,71.43 59.49,71.06 59.49,70.94 59.36,70.81 59.24,70.81 58.87,71.18 58.75,71.18 58.62,71.05 58.62,70.93 58.99,70.56 58.99,70.43 58.86,70.31 58.74,70.31 58.37,70.68 58.24,70.68 58.12,70.55 58.12,70.42 58.48,70.06 58.48,69.93 58.36,69.81 58.23,69.81 57.86,70.17 57.74,70.17 57.61,70.05 57.61,69.92 57.98,69.55 57.98,69.43 57.86,69.3 57.73,69.3 57.36,69.67 57.24,69.67 57.11,69.54 57.11,69.42 57.48,69.05 57.48,68.92 57.35,68.8 57.23,68.8 56.86,69.17 56.73,69.17 56.61,69.04 56.61,68.92 56.98,68.55 56.98,68.42 54.08,65.52 46.01,65.52 44.38,63.89 44.38,59.56 40.5,55.68 40.5,53.25 40.18,52.94 40.18,51.65 38.59,50.06 38.59,48.72 38.74,48.57 38.74,47.13 37.72,46.12 37.6,46.12 36.78,45.3 36.78,42.9 36.91,42.78 36.91,39.06 37.04,38.92 37.04,37.11 38.08,36.07 38.08,34.71 37.56,34.2 37.56,33.54 37.12,33.09 37.12,32.28 v1(37.5,31.9)
