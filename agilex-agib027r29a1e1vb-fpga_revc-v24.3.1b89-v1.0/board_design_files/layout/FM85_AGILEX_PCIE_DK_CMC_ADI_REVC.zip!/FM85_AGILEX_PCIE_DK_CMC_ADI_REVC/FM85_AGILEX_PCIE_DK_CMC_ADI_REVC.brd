# Allegro board FM85_AGILEX_PCIE_DK_CMC_ADI_REVC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GXR_AGND: length 3.6
  TOP w0.254: v1(208.92,32.64) C823.2
  TOP w0.381: C821.2 209.53,36.21 v1(209.87,36.55) R670.2
  BOTTOM w0.254: ST10.2 209.18,34.24
HPS_JTAG_TCK: length 139.2
  L12_SIG4 w0.089: v1(129.87,47.43) 130.93,47.43 131.31,47.05 131.81,47.05 132.1,47.34 132.54,47.34 133,46.88 133.69,46.88 134.53,46.04 134.53,41.75 135.05,41.23 135.05,36.39 135.98,35.46 135.98,32.98 136.88,32.08 136.88,30.36 136.85,30.33 136.85,28 137.01,27.84 137.01,20.71 135.51,19.21 135.51,19.11 135.29,18.89 134.92,18.89 134.07,18.04 133.67,18.04 133.45,17.82 133.45,17.56 133.13,17.24 132.18,17.24 130.68,15.74 69.28,15.74 63.79,21.23 60.21,21.23 59.22,22.23 58.09,22.23 57.71,22.61 51.48,22.61 51.11,22.98 50.76,22.98 49.16,21.38 46.45,21.38 45.59,22.23 45.59,23.03 45.1,23.52 38.87,23.52 v1(37.5,24.9)
HPS_JTAG_TDI: length 158.3
  TOP w0.149: U6.U21 v1(135.07,41.75)
  L07_SIG3 w0.089: v1(135.07,41.75) 135.07,42.09 134.89,42.26 134.73,42.26 134.34,42.65 134.34,43.24 133.49,44.08 133.07,44.08 132.4,44.75 132.1,44.75 131.8,45.06 131.43,45.06 130.82,45.67 130.26,45.67 130.01,45.92 129.48,45.92 129.23,45.67 128.66,45.67 128.41,45.92 127.88,45.92 127.63,45.67 127.2,45.67 126.87,46 126.41,46 126.08,45.67 125.73,45.67 125.31,45.25 124.94,45.25 124.44,44.75 124.11,44.75 123.65,44.29 123.5,44.29 123.14,43.93 123.14,43.26 122.84,42.95 122.56,42.95 122.28,42.68 122.28,40.47 arc(122.31,40.35) 122.38,40.24 122.54,40.07 arc(122.64,40.01) 122.74,39.98 arc(122.85,39.95) 122.94,39.89 123.07,39.76 123.07,37.32 121.47,35.72 121.47,34.57 121.62,34.42 121.62,32.26 121.62,31.66 121.29,31.33 121.29,30.17 120.47,29.35 120.47,21.63 119.86,21.02 119.86,18.97 120.47,18.36 120.47,17.91 121.08,17.3 121.08,15.63 121.09,15.63 121.09,15.57 123.94,12.72 125.61,12.72 125.77,12.88 v1(125.96,12.88)
  L14_SIG5 w0.081: v1(33.5,25.9) 34.02,25.38 38.22,25.38 40.02,23.58 47.37,23.58 48.04,24.25 49.44,24.25 50.43,25.24 50.44,25.24 50.67,25.47 51.19,25.47 51.56,25.1 51.56,24.46 51.82,24.2 51.82,23.65 52.43,23.04 52.94,23.04 53.45,22.53 53.45,21.76 55.52,19.69 58.4,19.69 58.67,19.96 58.99,19.96 59.25,19.71 59.25,18.89 63.81,14.33 63.81,13.72 68.37,9.15 115.32,9.15 118.09,11.92 119.88,11.92 120.82,12.86 121.47,12.86 121.58,12.97 122.52,12.97 122.8,12.69 125.76,12.69 v1(125.96,12.88)
HPS_JTAG_TDO: length 140
  TOP w0.149: v1(37.9,26.42) 38.42,25.9 U34.H16
  L07_SIG3 w0.089: v1(121.32,13.23) 120.31,14.24 120.31,16.4 119.38,17.33 119.38,21.14 120.05,21.8 120.05,29.53 120.8,30.29 120.8,30.39 120.8,31.53 121.14,31.86 121.14,32.06 121.14,33.29 121.14,33.32 121.14,34.22 120.99,34.37 120.99,36.16 122.27,37.44 122.27,39.3 122,39.57 121.86,39.57 121.52,39.91 121.52,43.39 121.52,43.9 121.74,44.12 121.96,44.12 122.42,44.58 122.71,44.58 123.38,45.25 123.63,45.25 124.05,45.67 124.44,45.67 125.33,46.56 125.95,46.56 126.27,46.88 127.03,46.88 127.32,46.59 127.63,46.59 127.92,46.88 128.43,46.88 128.72,46.59 130.29,46.59 v1(130.66,46.97)
  L14_SIG5 w0.081: v1(37.9,26.42) 38.73,25.59 41.94,25.59 42.17,25.82 42.6,25.82 42.83,25.59 43.21,25.59 44.12,24.68 49.54,24.68 50.35,25.49 50.37,25.49 50.58,25.71 51.29,25.71 51.8,25.2 51.8,24.69 52.64,23.84 52.75,23.84 55.23,21.36 55.23,20.31 55.62,19.92 58.3,19.92 58.57,20.19 59.09,20.19 59.51,19.77 59.51,18.96 66.37,12.1 68.78,12.1 71.42,9.46 78.48,9.46 79.04,10.03 80.13,10.03 80.65,9.51 115.35,9.51 117.99,12.15 119.78,12.15 120.86,13.23 v1(121.32,13.23)
HPS_JTAG_TMS: length 133.6
  L12_SIG4 w0.089: v1(136.24,40.07) 135.83,39.65 135.83,36.01 136.34,35.49 136.34,32.96 137.19,32.11 137.19,29.52 137.69,29.02 137.69,27.91 137.22,27.43 137.22,20.63 137.19,20.6 137.19,20.46 135.94,19.22 135.94,18.56 135.47,18.09 134.78,18.09 133.98,17.29 133.72,17.29 133.45,17.02 133.45,16.55 132.13,15.22 128.8,15.22 128.58,15.45 69.22,15.45 63.8,20.86 61.61,20.86 61.21,20.46 58.86,20.46 57.91,21.41 54.59,21.41 53.21,20.03 48.13,20.03 47.35,20.81 45.31,20.81 44.83,21.29 44.83,21.29 43.68,22.44 43.19,22.44 42.97,22.65 42.22,22.65 41.97,22.91 38.96,22.91 37.87,24 37.87,24.06 37.65,24.28 37.59,24.28 35.58,26.29 34.11,26.29 v1(33.5,26.9)
HPS_OSC_CLK: length 195.1
  L03_SIG1 w0.081: v1(53.16,9.94) 52.77,9.94 52.09,10.62 52.09,11.61 51.38,12.32 51.38,14.62 51.52,14.75 51.52,15.34 50.03,16.83 50.03,21.08 v2(49.18,21.93)
  L16_SIG6 w0.081: v1(133.85,41.45) 134.84,41.45 134.91,41.38 135.23,41.38 135.82,40.79 135.82,38.05 136.44,37.43 136.44,34.55 136.68,33.97 136.73,33.69 136.96,33.46 138.23,33.46 139.05,34.28 140.19,34.28 146.01,28.46 150.76,28.46 153.14,26.07 153.5,26.07 153.72,25.85 153.72,25.57 154.01,25.27 154.3,25.27 154.8,24.77 156.72,24.77 157.23,25.28 170.95,25.28 171.71,24.52 171.71,16.67 170.53,15.49 134.65,15.49 126.65,7.49 60.81,7.49 58.51,9.79 56.54,9.79 56.36,9.6 53.49,9.6 v1(53.16,9.94)
HPS_UART_RX: length 127.5
  TOP w0.149: v1(137.57,35.33) 138.64,35.33 138.77,35.21 R6286.1
  L07_SIG3 w0.089: J15.2 235.8,27.75 234.72,27.75 230.37,32.11 221.59,32.11 221.18,31.7 214.34,31.7 209.45,26.81 208.69,26.81 207.75,26.81 v1(207.26,26.32)
  L14_SIG5 w0.081: v1(195.33,24.06) 197.78,26.52 207.06,26.52 v1(207.26,26.32)
  L16_SIG6 w0.081: v1(195.33,24.06) 194.92,23.66 194.92,22.97 195.54,22.35 195.54,19.72 194.17,18.35 193.67,18.35 193.42,18.61 192.98,18.61 192.73,18.35 192.4,18.35 191.84,18.92 191.28,18.92 190.72,18.35 189.69,18.35 189.46,18.58 189.15,18.58 188.92,18.35 188.59,18.35 188.03,18.91 187.16,18.91 186.19,17.95 185.02,17.95 184.06,18.91 183.29,18.91 182.74,18.35 182.07,18.35 181.84,18.58 181.53,18.58 181.3,18.35 180.51,18.35 172.18,26.69 170.2,26.69 170.06,26.83 169.75,26.83 169.61,26.69 169.4,26.69 169.26,26.83 168.95,26.83 168.81,26.69 168.6,26.69 168.46,26.83 168.15,26.83 168.01,26.69 167.19,26.69 167.04,26.84 166.74,26.84 166.59,26.69 165.4,26.69 165.26,26.83 164.95,26.83 164.81,26.69 164.6,26.69 164.46,26.83 164.15,26.83 164.01,26.69 163.8,26.69 163.66,26.83 163.35,26.83 163.21,26.69 160.08,26.69 159.9,26.87 159.59,26.87 159.44,26.72 159.26,26.72 159.1,26.87 158.79,26.87 158.64,26.72 158.45,26.72 158.3,26.87 157.99,26.87 157.81,26.69 157.11,26.69 156.72,26.3 156.41,26.3 156.02,26.69 155.28,26.69 155.08,26.89 153.99,26.89 153.78,27.11 153.78,27.45 153.51,27.71 153.18,27.71 152.98,27.91 152.98,28.33 150.88,30.43 150.27,30.43 145.36,35.33 v1(137.57,35.33) 137.57,35.53 138.21,36.17 138.21,39.69 v1(137.84,40.07)
HPS_UART_TX: length 138.5
  TOP w0.149: R6285.1 137.05,34.58 v1(137.04,34.57)
  L07_SIG3 w0.089: v1(208.09,26.31) 210.39,26.31 213.27,29.19 213.27,29.67 215.06,31.46 221.3,31.46 221.7,31.86 228.07,31.86 234.65,25.29 J15.1
  L14_SIG5 w0.081: v1(208.09,26.31) 207.73,25.94 197.76,25.94 195.39,23.57 v1(195.39,23.38)
  L16_SIG6 w0.081: v1(195.39,23.38) 195.77,23 195.77,21.5 196.43,20.84 196.43,20.51 196.2,20.28 196.2,20.07 196.43,19.84 196.43,19.49 195.72,18.78 194.97,18.78 194.31,18.12 188.49,18.12 188.13,18.49 187.06,18.49 186.61,18.03 186.61,17.31 186.38,17.08 186.05,17.08 185.82,17.31 185.34,17.31 185.11,17.08 184.78,17.08 184.55,17.31 184.55,18.08 184.03,18.61 183.32,18.61 182.83,18.12 180.23,18.12 172.46,25.9 170.2,25.9 170.06,26.03 169.75,26.03 169.62,25.9 169.4,25.9 169.26,26.03 168.95,26.03 168.82,25.9 168.6,25.9 168.46,26.03 168.15,26.03 168.02,25.9 165.4,25.9 165.26,26.03 164.95,26.03 164.82,25.9 164.6,25.9 164.46,26.03 164.15,26.03 164.02,25.9 163.8,25.9 163.66,26.03 163.35,26.03 163.22,25.9 161.86,25.9 161.58,26.18 161.27,26.18 160.99,25.9 160.07,25.9 159.9,26.07 159.59,26.07 159.43,25.91 159.26,25.91 159.1,26.07 158.79,26.07 158.62,25.9 156.88,25.9 156.72,26.06 156.41,26.06 156.23,25.88 155.29,25.88 155.1,26.07 154.79,26.07 154.61,25.89 154.51,25.89 154.31,26.09 153.99,26.09 153.78,26.31 153.78,26.62 153.5,26.9 153.5,26.89 153.19,26.89 152.98,27.11 152.98,27.42 150.76,29.64 149.74,29.64 144.35,35.02 138.56,35.02 138.11,34.57 v1(137.04,34.57) 137.04,35.39 137.87,36.22 137.87,36.95 137.41,37.41 137.41,42.31 135.2,44.52 135.2,44.73 135.01,44.93 134.64,44.93 133.06,46.51 v1(133.05,46.51)
HRAM_CK: length 37.3
  BOTTOM w0.149: R6224.2 35.62,24.16 35.32,24.45 34.47,24.45 33.93,23.91 33.93,23.66 33.58,23.31 33.33,23.31 33.09,23.07 33.09,22.5 32.01,21.42 32.01,18.3 29.6,15.89 22.33,15.89 22.18,16.04 22.18,17.21 21.89,17.51 21.38,17.51 21.09,17.21 21.09,16.04 20.94,15.89 20.47,15.89 19.46,16.89 19.46,18.05 19.17,18.35 18.67,18.35 18.37,18.05 18.37,17.46 18.22,17.31 17.92,17.31 17.78,17.46 17.78,19.78 17.48,20.07 17.01,20.07 16.68,19.74 16.68,17.46 16.53,17.31 15.25,17.31 U103.B2
HRAM_CK_N: length 37.3
  BOTTOM w0.149: R6225.2 35.74,22.87 35.17,23.44 34.46,23.44 34.01,22.99 34.01,22.7 32.95,21.64 32.95,18.89 29.7,15.64 22.23,15.64 21.93,15.94 21.93,17.11 21.78,17.26 21.49,17.26 21.34,17.11 21.34,15.94 21.04,15.64 20.36,15.64 19.21,16.79 19.21,17.95 19.07,18.1 18.77,18.1 18.62,17.95 18.62,17.36 18.33,17.06 17.82,17.06 17.53,17.36 17.53,19.67 17.38,19.82 17.12,19.82 16.93,19.63 16.93,17.36 16.64,17.06 15.2,17.06 U103.B1
HRAM_CK_N_R:
  vias: v1(37.5,22.9)
HRAM_CK_R:
  vias: v1(36.49,23.9)
HRAM_CS: length 32.7
  L07_SIG3 w0.089: v1(36.84,16.98) 36.28,16.98 35.79,17.48 34.75,17.48 34.66,17.56 34.66,17.97 34.57,18.05 34.39,18.05 34.3,17.97 34.3,17.56 34.22,17.48 31.92,17.48 30.25,15.8 19.64,15.8 19.25,16.19 19.13,16.19 18.77,15.83 18.64,15.83 18.52,15.95 18.52,16.08 18.88,16.44 18.88,16.56 18.75,16.69 18.63,16.69 18.26,16.33 18.14,16.33 18.01,16.45 18.01,16.58 18.37,16.94 18.37,17.07 18.25,17.19 18.12,17.19 17.36,16.43 17.2,16.43 17.09,16.54 17.09,16.66 17.87,17.44 17.87,17.57 17.62,17.82 17.02,17.82 16.87,17.67 16.87,17.08 16.77,16.98 16.6,16.98 16.51,17.07 16.51,17.69 16.42,17.78 16.3,17.78 16.01,17.5 15.89,17.5 15.76,17.62 15.76,17.75 16.04,18.03 16.04,18.15 15.96,18.24 15.38,18.24 v1(15.35,18.21)
  BOTTOM w0.149: R6213.2 v1(36.84,16.98)
  BOTTOM w0.15: U103.A3 v1(15.35,18.21)
HRAM_CS_R:
  vias: v1(37.5,17.9)
HRAM_D0: length 34.6
  L07_SIG3 w0.089: v1(11.49,19.23) 11.49,19.13 11.92,18.7 12.23,18.7 12.82,18.12 12.82,15.84 14.38,14.28 35.82,14.28 38.08,16.53 38.08,17.59 38.08,19.32 v1(37.5,19.9)
HRAM_D1: length 36.1
  L07_SIG3 w0.089: v1(38.5,20.9) 39.13,20.27 39.36,20.27 39.58,20.05 39.58,19.27 38.29,17.98 38.29,17.5 38.29,16.36 35.96,14.03 13.67,14.03 11.93,15.78 11.93,17.63 v1(12.33,18.03)
HRAM_D2: length 33
  L07_SIG3 w0.089: v1(37.5,18.9) 37.12,19.28 36.34,19.28 36.12,19.06 36.12,18.62 36.4,18.34 36.59,18.34 36.87,18.06 36.87,17.62 37.21,17.28 37.21,16.72 36.98,16.49 35.71,16.49 35.34,16.87 31.91,16.87 30.13,15.09 17.9,15.09 17.89,15.08 17.56,15.08 17.56,15.09 17.53,15.09 17.21,15.4 17.21,15.49 16.98,15.73 16.89,15.73 13.92,18.69 13.92,20.78 v1(14.35,21.21)
HRAM_D3: length 34.2
  L07_SIG3 w0.089: v1(13.11,20.25) 13.11,18.82 13.81,18.12 13.81,16.06 15.36,14.52 35.72,14.52 36.51,15.31 36.55,15.31 37.87,16.62 37.87,17.68 37.87,19.06 37.38,19.54 36.85,19.54 v1(36.49,19.9)
HRAM_D4: length 33.6
  TOP w0.149: R2695.2 13.22,21.08 v1(13.44,21.31)
  L07_SIG3 w0.089: v1(36.49,18.9) 37.12,18.28 37.12,17.75 37.42,17.45 37.42,16.47 36.47,15.52 36.38,15.52 35.62,14.76 35.29,14.76 35.21,14.85 35.21,15.06 35.12,15.15 34.94,15.15 34.85,15.06 34.85,14.85 34.76,14.76 34.58,14.76 34.49,14.85 34.49,15.06 34.41,15.15 34.23,15.15 34.14,15.06 34.14,14.85 34.05,14.76 16.73,14.76 16.31,15.18 16.31,15.97 13.68,18.59 13.68,20.46 13.44,20.7 v1(13.44,21.31)
HRAM_D5: length 34.5
  L07_SIG3 w0.089: v1(38.5,19.9) 38.08,20.32 36.74,20.32 36.7,20.28 36.34,20.28 36.12,20.06 36.12,19.7 34.95,18.53 34.65,18.53 34.65,18.53 32.38,18.53 30.21,16.35 21.1,16.35 17.32,20.13 17,20.13 16.75,20.38 16.75,20.7 15.71,21.74 13.13,21.74 12.77,21.38 12.77,21.03 12.53,20.79 12.31,20.79 11.77,20.25 11.77,20.03 11.53,19.79 11.52,19.79 10.55,18.82 v1(10.55,18.24)
HRAM_D6: length 36.1
  TOP w0.149: R2697.2 10.12,17.25 v1(9.79,17.58)
  L07_SIG3 w0.089: v1(37.5,21.9) 36.87,21.28 36.34,21.28 36.12,21.06 36.12,20.7 35.74,20.32 35.38,20.32 35.34,20.28 33.47,20.28 30.72,17.53 28.06,17.53 28.01,17.57 27.7,17.57 27.66,17.53 21.61,17.53 17.92,21.22 16.92,21.22 15.91,22.22 11.76,22.22 9.79,20.24 v1(9.79,17.58)
HRAM_D7: length 37.8
  L07_SIG3 w0.089: v1(10.4,16.13) 10.4,17.87 10.18,18.08 10.18,19.79 11.17,20.79 11.53,20.79 11.84,21.1 11.84,21.54 12.28,21.98 15.81,21.98 16.82,20.97 17.78,20.97 22.07,16.69 29.36,16.69 29.37,16.68 29.68,16.68 29.68,16.69 30.24,16.69 33.08,19.53 35.65,19.53 35.87,19.75 35.87,20.15 36.25,20.53 36.65,20.53 38.02,21.9 v1(38.5,21.9)
HRAM_RST_N: length 34.9
  L07_SIG3 w0.089: v1(36.49,17.9) 36.1,18.3 32.45,18.3 30.22,16.07 20.86,16.07 20.38,16.54 20.26,16.54 19.86,16.15 19.74,16.15 19.61,16.28 19.61,16.4 20.01,16.8 20.01,16.92 19.88,17.05 19.75,17.05 19.36,16.65 19.24,16.65 19.11,16.78 19.11,16.91 19.5,17.3 19.5,17.42 19.38,17.55 19.25,17.55 18.86,17.16 18.73,17.16 18.61,17.28 18.61,17.41 19,17.8 19,17.93 18.87,18.05 18.75,18.05 18.36,17.66 18.23,17.66 18.1,17.79 18.1,17.91 18.5,18.3 18.5,18.43 18.37,18.56 18.25,18.56 17.85,18.16 17.73,18.16 17.6,18.29 17.6,18.41 17.99,18.81 17.99,18.93 17.87,19.06 17.74,19.06 17.03,18.35 16.85,18.35 16.75,18.45 16.75,18.57 17.49,19.31 17.49,19.44 17.36,19.56 17.24,19.56 16.24,18.56 16.11,18.56 16.01,18.67 16.01,18.83 16.87,19.69 16.87,19.82 16.48,20.21 v1(16.35,20.21)
  BOTTOM w0.15: U103.A4 v1(16.35,20.21)
HRAM_RWDS: length 28.9
  L07_SIG3 w0.089: v1(14.35,19.21) 14.84,18.72 14.84,18.12 16.91,16.05 17.76,16.05 18.29,15.51 30.26,15.51 31.9,17.15 35.58,17.15 v1(35.86,16.87)
  BOTTOM w0.149: R6214.2 38.41,16.96 37.8,16.35 36.38,16.35 v1(35.86,16.87)
  BOTTOM w0.15: U103.C3 v1(14.35,19.21)
HRAM_RWDS_R:
  vias: v1(38.5,18.9)
HSSI_GXF_AGND: length 8.1
  BOTTOM w0.203: ST17.1 78.54,68.07 78.39,68.23 C7661.1
  BOTTOM w0.381: R5945.2 v1(74.63,67.44) 76.03,67.44 76.82,68.23 C7661.1 ; R5946.1 71.2,70.7 v1(71.3,70.6) 71.33,70.63 71.91,70.63 R5947.1 ; v1(71.97,68.63) 71.94,68.61 R5944.1 ; v1(71.3,71.9) 71.68,71.52 R6154.1
  vias: v1(70.03,71.9) v1(70.03,70.6) v1(73.26,68.71)
I2C2_SCL: length 549.7
  TOP w0.149: v1(65.37,100.44) 65.52,100.44 65.67,100.29 65.67,93.26 64.36,91.95 64.36,87.47 69.49,82.34 74.28,82.34 74.61,82.01 EU1.12 ; J6.A8 219.84,20.78 v1(219.72,20.91)
  L03_SIG1 w0.081: v1(202,19.76) 202,19.22 201.55,18.77 201.28,18.77 201.05,18.54 201.05,18.21 201.28,17.98 201.57,17.98 201.86,17.69 201.86,17.47 203.26,16.06 207.26,16.06 207.69,16.5 208.02,16.5 208.2,16.31 209.25,16.31 210.08,15.48 212.1,15.48 212.94,16.31 214.08,16.31 214.57,16.81 214.57,19.65 214.57,20.17 214.98,20.58 217.24,20.58 217.33,20.49 219.3,20.49 v1(219.72,20.91)
  L07_SIG3 w0.089: v1(202,19.76) 203.02,19.76 203.47,20.2 210.83,20.2 214.01,23.39 219.37,23.39 219.61,23.14 222.48,23.14 223.75,24.41 226.94,24.41 228.54,22.8 229.5,22.8 229.9,22.41 236.17,22.41 237.11,23.34 237.38,23.34 243.34,29.3 243.34,33.37 245.13,35.16 245.13,35.84 248.73,39.43 248.84,39.43 249.86,40.46 249.86,44.19 250.67,44.99 250.67,46.51 249.63,47.56 249.16,47.56 248.64,48.08 248.64,48.73 249.32,49.41 249.32,49.77 252.23,52.69 252.23,54.4 250.47,56.17 250.47,66.68 251.75,67.95 251.75,99.05 242.58,108.22 235.82,108.22 234.54,109.5 196.62,109.5 195.76,108.64 189.32,108.64 187.61,106.92 186.53,106.92 185.16,108.29 177.41,108.29 v1(176.79,107.67) 176.38,107.26 175.68,107.26 173.91,109.03 150.23,109.03 150.23,109.03 75.81,109.03 69.25,102.47 67.79,102.47 65.76,100.44 v1(65.37,100.44) 59.63,100.44 59.15,99.96 54.34,99.96 53.84,99.47 50.59,99.47 48.58,97.45 32.28,97.45 30.74,95.91 14.21,95.91 12.44,94.15 12.44,92.42 13.47,91.39 13.47,84.66 14.23,83.9 14.67,83.9 v1(15.33,83.23)
  L12_SIG4 w0.089: v1(15.33,83.23) 16.82,83.23 21.98,78.08 22.5,78.08 24.59,75.98 24.91,75.98 27.38,73.52 27.58,73.52 30.72,70.37 30.72,64.79 30.12,64.19 30.12,61.06 30.98,60.19 v1(31,60.19) 35.02,56.16 35.02,42.83 38.63,39.22 38.63,34.93 37.68,33.98 34.57,33.98 v1(33.5,32.9) 33.89,32.51 38.73,32.51 39.07,32.85 39.55,32.85 40.53,33.83 44.19,33.83 44.73,33.29 44.73,33.25 v1(45.55,32.43)
  BOTTOM w0.149: EU2.12 172.61,90.14 173.01,89.74 174.89,89.74 176.66,91.51 176.66,107.53 v1(176.79,107.67) ; U107.19 200.26,20.67 200.91,21.32 201.37,21.32 202,20.7 v1(202,19.76) ; v1(15.33,83.23) 15.5,83.4 U14.23
I2C2_SDA: length 552.3
  TOP w0.149: v1(218.96,20.91) 219.43,21.38 J6.A9 ; EU1.11 75.1,80.99 75.47,81.36 75.47,81.78 74.6,82.65 69.62,82.65 64.72,87.55 64.72,91.81 66.03,93.11 66.03,100.72 v1(65.72,101.03)
  L03_SIG1 w0.081: v1(218.96,20.91) 218.86,20.81 214.89,20.81 214.34,20.27 214.34,16.91 213.98,16.55 212.84,16.55 212.01,15.71 210.25,15.71 209.42,16.55 208.3,16.55 208.12,16.73 207.6,16.73 207.16,16.3 203.53,16.3 202.1,17.73 v1(202.1,18.74)
  L07_SIG3 w0.089: v1(202.1,18.74) 202.1,19 202.19,19.09 210.08,19.09 214.14,23.14 219.27,23.14 219.51,22.9 222.58,22.9 223.85,24.17 226.84,24.17 228.44,22.56 229.4,22.56 229.8,22.16 236.27,22.16 237.21,23.1 237.48,23.1 243.59,29.2 243.59,33.16 245.39,34.97 245.39,35.75 248.83,39.19 250.21,39.19 250.91,39.89 250.91,46.61 249.73,47.8 249.26,47.8 248.88,48.18 248.88,48.49 249.68,49.29 249.68,49.79 252.47,52.59 252.47,54.5 250.73,56.25 250.71,56.28 250.71,66.58 251.99,67.85 251.99,99.15 242.68,108.46 235.93,108.46 234.65,109.74 196.52,109.74 195.66,108.88 189.22,108.88 187.51,107.16 186.63,107.16 185.26,108.53 176.73,108.53 v1(175.84,107.63) 174.2,109.27 75.71,109.27 69.15,102.71 67.4,102.71 v1(65.72,101.03) 64.31,101.03 64.28,100.99 56.06,100.99 55.6,100.53 54.56,100.53 53.74,99.71 50.23,99.71 48.21,97.69 31.7,97.69 30.17,96.15 13.66,96.15 12,94.49 12,92.1 12.96,91.14 12.96,84.59 v1(14.31,83.23)
  L12_SIG4 w0.089: v1(44.76,32.43) 44.15,33.04 43.86,33.04 43.78,33.12 41.09,33.12 39.8,31.83 39.8,31.64 39.53,31.37 36.33,31.37 35.8,31.9 v1(34.5,31.9) 34.1,32.29 33.81,32.29 33.8,32.3 33.57,32.3 33.12,32.75 33.12,33.06 34.29,34.23 37.59,34.23 38.39,35.03 38.39,39.09 34.78,42.69 34.78,43.96 31.11,47.64 31.11,56.91 31.35,57.16 31.35,58.56 v1(29.73,60.19) 29.73,64.5 30.25,65.02 30.25,70.29 24.81,75.72 24.29,75.72 22.23,77.78 21.71,77.78 16.82,82.67 14.88,82.67 v1(14.31,83.23)
  BOTTOM w0.149: v1(14.31,83.23) 14.98,83.9 U14.24 ; v1(175.84,107.63) 175.84,91.22 174.81,90.2 173.16,90.2 172.72,90.64 EU2.11 ; v1(202.1,18.74) 202.04,18.8 202.04,19.13 201.48,19.69 201.48,20.21 201.24,20.44 200.91,20.44 200.64,20.17 U107.20
I2C3_SCL: length 26.1
  BOTTOM w0.149: v1(34.5,32.9) 34.76,32.9 35.17,32.5 38.1,32.5 39.2,31.4 39.57,31.4 40.15,31.98 40.15,32.4 40.15,32.41 40.49,32.75 41.97,32.75 42.47,33.25 43.49,33.25 43.77,32.98 44.24,32.98 44.56,33.3 44.56,33.59 45.12,34.16 53.43,34.16 53.86,33.73 55.61,33.73 55.76,33.88 55.76,34.18 R328.1 56.42,34.24 56.57,34.09 U29.13
I2C3_SDA: length 32.5
  BOTTOM w0.149: U29.12 56.53,33.44 56.32,33.23 R327.1 55.82,32.77 55.55,32.5 51.94,32.5 51.82,32.39 48.3,32.39 47.23,31.32 47.23,30.49 47.64,30.08 47.64,29.89 47.64,29.89 47.64,29.29 47.26,28.9 46.64,28.9 46.54,29 41.81,29 41.63,29.18 41.63,29.97 41.45,30.15 41.45,32.13 41.14,32.44 40.62,32.44 40.45,32.28 40.45,31.85 39.69,31.1 39,31.1 38.6,31.5 36.33,31.5 35.94,31.88 35.09,31.88 34.66,32.31 34.15,32.31 33.74,31.9 v1(33.5,31.9)
IIN-_0: length 1
  TOP w0.254: R5952.2 194.92,42.36 v1(194.41,42.87)
  vias: v1(188.93,42.29) v1(188.93,39.75) v1(190.2,41.02) v1(190.2,39.75) v1(191.47,42.29) v1(191.47,41.02) v1(191.47,39.75) v1(192.74,41.02) v1(192.74,39.75) v1(193.81,42.88) v1(193.86,39.8) v1(193.86,39.3) v1(193.86,38.79) v1(194.47,39.8) v1(194.47,39.3) v1(194.47,38.79) v1(195.1,39.8) v1(195.1,39.3) v1(195.1,38.79)
INTVCC4: length 3.2
  TOP w0.254: v3(42.77,102.64) 42.35,102.64 41.7,102 U68.20
  BOTTOM w0.381: R660.2 37.56,106.09 v1(37.37,106.28)
INTVCC5: length 4.3
  TOP w0.254: U69.20 205.61,32.6
  TOP w0.381: 205.61,32.6 206.23,31.98 v1(206.23,31.51)
  BOTTOM w0.381: R671.2 209.54,37.61 209.61,37.67 209.64,37.67 209.93,37.96 v1(209.93,38.05)
  BOTTOM w0.508: R668.2 208.66,36.62 209.3,37.26 R671.2
INTVCC6: length 3.3
  TOP w0.254: C1332.1 56.42,102.69 55.77,102.05 U71.20
  TOP w0.381: v1(56.83,102.79) 56.84,102.77 C1332.1
  BOTTOM w0.203: v1(51.44,106.31) 51.63,106.12 R946.2
INTVCC_PVCC: length 0.7
  TOP w0.381: v1(197.72,61.6) 197.56,61.77 R6076.2
IO_1P8V: length 6.4
  TOP w0.305: v1(53.47,33.42) v1(52.46,33.42)
  TOP w0.381: R6285.2 R6286.2 139.36,33.69 v1(139.55,33.89) ; C498.1 41.96,16.54 42.95,16.54 v1(43.02,16.61)
  BOTTOM w0.254: U26.8 17.7,108.27 17.45,108.01 v3(17.45,107.64)
  BOTTOM w0.305: R282.1 v1(2.36,79.2)
  vias: v1(2.36,86.57) v1(2.36,85.55) v1(2.36,83.52) v1(2.36,81.36) v1(18.47,106.75) v1(19.48,106.75) v1(39.34,18.33) v1(42.49,35.64) v1(42.56,14.54) v1(45.07,14.07) v1(45.85,43.7) v1(46.87,43.7) v1(50.43,33.42) v1(52.14,44.66) v1(52.14,43.64) v1(52.14,35.51) v1(53.03,41.61) v1(54.87,43.51) v1(55.57,43.51) v1(58.29,45.23) v1(60.62,29.51) v1(61.23,28.99) v1(61.26,29.79) v1(68.88,39.46) v1(68.88,38.66) v1(68.88,35.46) v1(68.88,34.66) v1(73.03,33.43) v1(73.57,39.45) v1(73.6,38.66) v1(73.6,35.47) v1(73.6,34.67) v1(83.89,44.27) v1(108.35,70.89) v1(108.35,69.97) v1(109.95,70.89) v1(109.95,69.97) v1(124.29,49.73) v1(124.29,48.81) v1(125.09,48.35) v3(45.42,33.4) v3(51.91,20.85) v3(52.46,20.45) v3(109.95,85.14) v3(109.9,83.95) v4(41.12,43.37) v4(41.13,42.72)
IO_1P8V_AGND: length 1
  BOTTOM w0.203: ST20.1 67.72,35.28 R6287.1
  vias: v1(67.01,35.79)
IO_1P8V_EN: length 46.1
  L14_SIG5 w0.127: v1(39.22,33.88) 39.22,34.47 42.24,37.49 42.24,37.79 43.76,39.31 44.5,39.31 45.08,39.89 45.08,41.55 45.68,42.15 46.03,42.15 47.47,43.59 47.47,43.88 49.3,45.7 53.41,45.7 53.94,45.16 54.24,45.16 54.37,45.04 54.37,42.61 56.41,40.58 56.82,40.58 57.07,40.33 57.07,39.92 57.42,39.56 57.84,39.56 58.08,39.32 58.08,38.9 58.33,38.65 v1(65.54,38.65)
  L16_SIG6 w0.127: v1(39.22,33.88) 38.88,34.22 33.99,34.22 33,35.22 v1(32.94,35.22)
  BOTTOM w0.127: v1(65.54,38.65) 64.84,38.65 64.59,38.4 R6167.1
IO_1P8V_PG: length 89.4
  L03_SIG1 w0.127: v1(47.55,32.28) 48.96,30.88 48.96,27.78 48.69,27.51 48.69,21.54 48.95,21.28 49.31,21.28 49.68,20.91 49.68,16.13 47.42,13.88 47.07,13.88 46.86,13.66 44.89,13.66 44.64,13.91 42.88,13.91 42.75,13.89 41.66,13.89 41.44,13.67 35.57,13.67 35.32,13.91 29.17,13.91 27.93,15.15 26.65,15.15 24.1,17.7 24.1,18.07 24.35,18.31 25.08,18.31 v1(25.5,17.9)
  L07_SIG3 w0.127: v1(61.31,36.69) 61.99,36.02 66,36.02 67.04,37.06 v1(69.68,37.06)
  L14_SIG5 w0.127: v1(61.31,36.69) 60.3,37.71 59.52,37.71 59.28,37.96 58.97,37.96 58.73,37.71 58.38,37.71 58.14,37.96 58.14,38.45 57.86,38.73 57.49,38.73 57.25,38.97 57.25,39.34 56.84,39.74 56.48,39.74 54.03,42.19 54.03,44.69 53.48,45.24 49.52,45.24 48.35,44.07 48.35,43.07 47.19,41.92 47.19,32.64 v1(47.55,32.28)
  BOTTOM w0.127: R6145.1 61.84,36.17 v1(61.31,36.69)
IO_1P8V_SI53254_1: length 8.9
  TOP w0.254: U24.18 v1(61.68,40.9) ; U24.4 v1(57.42,35.98) ; U24.1 55.66,36.39 v1(55.43,36.39) ; U24.9 v1(59.92,35.98) ; U24.25 v1(58.42,43.32) ; U24.15 v1(61.66,39.4)
  BOTTOM w0.381: v1(59.92,35.98) 59.92,36.56 C1389.1 ; C1391.1 61.33,39.4 v1(61.66,39.4) ; C1390.1 61.36,40.9 v1(61.68,40.9) ; v1(57.42,35.98) 57.41,35.99 C1293.1 ; C1392.1 55.63,36.59 v1(55.43,36.39) ; v1(58.42,43.32) 58.43,43.32 C1294.1 57.73,42.69 57.16,43.26 v1(57.16,43.51)
  vias: v1(56.46,43.51)
IO_3P3V: length 111.2
  TOP w0.254: v1(53.18,12.14) 53.18,11.99 R150.1
  TOP w0.305: R226.2 R227.2
  TOP w0.381: U28.14 30.53,93.51 v1(31,93.04) ; v1(52.71,11.4) 52.67,11.45 v1(51.69,11.45) ; v1(24.39,92.92) 23.67,93.63 U31.14 ; v1(17.53,92.92) 16.82,93.63 U32.14
  BOTTOM w0.191: U27.1 16.78,104.22 v3(16.78,104.22) ; U27.8 18.11,103.75 v3(17.24,102.88)
  BOTTOM w0.254: R149.2 v1(51.69,11.45) ; 15.75,85.04 15.89,84.9 U14.26 ; R328.2 v1(54.24,34.24) ; v1(15.06,58.63) v1(15.06,57.61) ; U14.54 28.72,83.4 28.76,83.44 ; 17.64,80.85 17.61,80.88 U14.20 ; U14.43 24.61,87.31 ; U14.9 23.11,80.98 ; U26.1 v3(17.07,108.72)
  BOTTOM w0.305: R342.2 v1(6.97,64.28) ; R343.2 v1(6.08,64.28) ; R356.2 249.24,41.61 v1(248.67,41.61) ; R361.2 v1(248.67,38.43) ; R363.2 v1(249.08,36.53) ; U15.14 102.52,30.55 101.88,29.91 96.8,29.91 96.06,30.66 96.06,31.61 94.51,33.15 93.31,33.15 ; v3(55.89,35.26) 56.41,34.74 57.09,34.74 ; R359.2 v1(248.67,39.83) ; R355.2 v1(15.07,64.28) ; U42.19 246.65,47.84 246.51,47.7 v3(246.51,47.2) ; R350.2 v1(10.58,73.87) ; R364.2 v1(248.67,42.75) ; R354.2 v1(15.96,64.28)
  BOTTOM w0.356: v3(25.71,88.01) v3(24.79,88.01) 24.61,87.83 24.61,87.31 ; v3(29.31,84.53) C299.2 v3(29.31,83.44) 28.76,83.44 ; 15.75,85.04 v3(15.33,85.46) v3(15.33,86.46) ; 17.64,80.85 v3(17.64,79.9) v3(18.64,79.9) ; 23.11,80.98 23.11,79.91 v3(23.12,79.9) v3(22.11,79.9)
  BOTTOM w0.381: R348.1 v1(15.5,95.33) ; v1(46.34,31.59) 46.33,31.59 46.48,31.73 R333.1 ; R156.1 58.57,11.45 v1(59.21,12.09) ; R340.1 v1(22.36,95.33) ; U43.8 v3(33.54,62.25) ; R347.1 v1(14.49,95.33) ; 93.31,33.15 92.57,33.15 90.98,31.56 77.46,31.56 76.37,30.47 66.68,30.47 66.44,30.23 62.51,30.23 61.88,30.86 61.88,34.54 61.55,34.87 61.14,34.87 60.92,34.65 59.8,34.65 59.66,34.78 58.53,34.78 58.48,34.74 U29.14 57.09,34.74 ; R224.2 v1(53.37,29.57) ; v1(43.5,76.66) 43.5,77.09 ; v1(43.5,76.66) 43.5,76.23 ; v1(43.5,76.66) 43.08,76.66 ; U15.14 107.2,30.55 107.21,30.53 v1(107.46,30.53) C310.1 ; R349.1 v1(16.52,95.33) ; R341.1 v1(23.38,95.33) ; R339.1 v1(21.34,95.33)
  BOTTOM w0.457: v3(57.73,17.92) FB7.1
  vias: v1(2.36,76.66) v1(2.45,70.75) v1(14.44,84.46) v1(14.44,82.21) v1(16.11,109.54) v1(18.51,101.99) v1(19.78,101.99) v1(20.87,109.45) v1(24.88,79.01) v1(25.53,92.92) v1(25.88,79.01) v1(29.47,51.96) v1(31.5,51.96) v1(34.55,51.96) v1(42.74,88.72) v1(43.5,75.64) v1(43.63,51.11) v1(43.92,82.63) v1(43.86,32.43) v1(45.41,76.66) v1(45.41,75.64) v1(45.49,52.12) v1(45.49,51.11) v1(46.15,30.35) v1(54.76,21.01) v1(54.92,33.28) v1(55.63,11.45) v1(60.37,13.97) v1(209.51,89.51) v1(209.51,88.67) v3(43.44,77.8) v3(44.08,78.82) v3(44.08,54.12) v3(44.33,57.86) v3(45.02,87.07) v3(45.02,85.8) v3(45.02,84.03) v3(45.09,88.85) v3(45.22,79.71) v3(45.22,77.93) v3(45.22,64.09) v3(45.22,62.31) v3(45.22,61.04) v3(45.22,59.26) v3(45.22,54.94) v3(45.22,53.16) v3(45.66,78.82) v3(45.66,63.2) v3(45.66,60.15) v3(45.66,54.05) v3(45.85,88.85) v3(46.11,87.07) v3(46.11,85.8) v3(46.11,84.03) v3(46.11,79.71) v3(46.11,77.93) v3(46.11,64.09) v3(46.11,62.31) v3(46.11,61.04) v3(46.11,59.26) v3(46.11,54.94) v3(46.11,53.16) v3(51.35,16.39) v4(27.41,68.79) v4(36.2,80.22) v4(36.2,79.45) v4(37.22,80.22) v4(37.22,79.45) v4(38.23,80.22) v4(38.23,79.45) v4(39.76,80.22) v4(39.76,79.45) v4(40.52,80.22) v4(40.52,79.45) v4(41.79,80.22) v4(41.79,79.45)
IO_3P3V_EN: length 49.8
  L03_SIG1 w0.127: v1(34.26,35.87) 34.24,35.87 34.22,35.88 34.13,35.88 33.88,36.13 33.88,37.18 33.7,37.36 33.7,45.36 34.74,46.4 34.74,51.18 34.13,51.79 34.13,52.57 31.41,55.29 31.41,60.83 30.67,61.57 30.67,71.79 29.82,72.63 29.82,77.55 29.27,78.11 29.27,79.5 30.66,80.9 v1(31.06,80.9)
  BOTTOM w0.127: R6243.1 34.17,35.62 34.17,35.81 34.24,35.87 v1(34.26,35.87)
IO_EXPNDR1_INT_N: length 197.9
  L14_SIG5 w0.081: v1(133.66,11.84) 132.55,11.84 132.11,11.39 130.57,11.39 130.39,11.58 125.15,11.58 124.96,11.39 124.32,11.39 124.31,11.39 121.88,11.39 121.43,10.94 121.43,9.74 118.87,7.19 68.63,7.19 62.39,13.42 62.13,13.42 61.73,13.82 61.73,14.69 59.2,17.22 55.89,17.22 53.08,20.02 52.11,20.02 50.1,22.03 47.91,22.03 46.8,20.93 44.4,20.93 44.03,20.56 42.22,20.56 40.21,22.56 40.19,22.56 38.23,24.53 33.35,24.53 33.34,24.53 33.34,24.53 33.12,24.75 33.12,27.06 33.6,27.53 33.65,27.53 33.87,27.75 33.87,27.83 34.57,28.53 34.65,28.53 35.11,29 35.11,31.13 34.72,31.53 29.87,31.53 v1(29.5,31.9)
  L16_SIG6 w0.081: v1(133.66,11.84) 133.66,11.93 137.02,15.28 170.72,15.28 171.42,15.99 176.21,15.99 176.49,16.27 180.02,16.27 181.72,14.57 187,14.57 188.32,15.89 193.16,15.89 194.48,17.21 196.67,17.21 198.63,19.17 v1(200.7,19.17)
  BOTTOM w0.254: U107.22 v1(200.7,19.17)
IO_EXPNDR1_RST_N: length 203.2
  TOP w0.149: v1(46.06,12.39) 45.51,12.94 v2(45.51,18.08) ; v1(198.74,14.1) 198.71,14.1 198.71,14.17 198.8,14.17 198.8,14.16 199.68,15.04 199.68,15.65 200.44,16.41 200.44,17.23 v1(200.7,17.49)
  L03_SIG1 w0.081: v1(198.74,14.1) 198.07,13.44 192.49,13.44 191.06,14.86 187.63,14.86 186.68,13.92 179.54,13.92 178.61,14.85 177.72,14.85 176.76,13.89 138.84,13.89 135.66,10.7 v1(132.68,10.7) ; v2(28.5,32.9) 28.97,32.9 29.34,32.53 29.54,32.53 30.05,32.02 30.05,27.9 31.05,26.9 31.05,24.82 31.83,24.04 31.83,23.46 32.12,23.16 32.12,22.75 33.6,21.27 33.7,21.27 34.12,20.84 34.12,19.75 34.34,19.53 34.65,19.53 35.9,18.28 35.9,17.8 36.22,17.49 38.67,17.49 39.14,17.96 42.66,17.96 42.8,17.82 43.13,17.82 43.36,18.05 43.36,18.38 43.75,18.77 44.85,18.77 45.51,18.1 v2(45.51,18.08)
  L05_SIG2 w0.081: v1(132.68,10.7) 132.68,12.44 132.22,12.91 130.89,12.91 126.05,8.06 126.05,8.04 125.82,7.81 59.98,7.81 57.87,9.93 54.52,9.93 53.44,11.01 50.08,11.01 49.3,11.79 48.98,11.79 48.77,11.59 46.86,11.59 v1(46.06,12.39)
  BOTTOM w0.254: U107.24 200.02,18.17 v1(200.7,17.49)
IREF: length 15.3
  TOP w0.149: U119.44 182.69,64.76 182.91,64.98 183.17,64.98 v1(183.5,65.31) 183.51,65.29 U119.43 ; U119.48 181.09,64.98 181.24,65.13 v1(181.38,65.13) 181.49,65.02 U119.47 ; U119.33 184.29,59.74 184.67,60.11 184.67,61.04 v1(184.7,61.07)
  L14_SIG5 w0.081: v1(183.5,65.31) 183.5,64.96 183.45,64.91 183.45,61.58 183.94,61.09 184.68,61.09 v1(184.7,61.07)
  L16_SIG6 w0.081: v1(181.38,65.13) 181.83,65.58 183.23,65.58 v1(183.5,65.31)
  BOTTOM w0.149: C1718.2 181.42,64.33 R6194.2
ISENSE0: length 42.4
  TOP w0.149: v1(176.55,64.04) 176.93,64.04 177.08,63.89 177.08,63.57 178.11,62.54 U119.4
  L07_SIG3 w0.254: v1(173.58,86.21) 173.58,86.81 173.52,86.88 173.52,87.32 172.56,88.28 171.31,88.28 164.62,81.58 164.62,69.95 168.19,66.37 174.62,66.37 175.82,65.18 175.82,64.77 v1(176.55,64.04)
ISENSE2: length 16
  TOP w0.149: U119.3 178.16,62.94 177.43,63.68 177.43,64.06 176.59,64.9 R5881.2 v1(176.55,65.71)
  L07_SIG3 w0.089: v1(176.55,65.71) 176.55,64.87 178.08,63.34 178.08,62.33 177.82,62.07 177.38,62.07 177.11,61.81 177.11,59.97 176.59,59.45 176.02,59.45 175.57,59.89 174.6,59.89 173.62,58.91 v1(173.62,58.21)
ISENSE3: length 31.4
  TOP w0.149: U126.33 173.39,43.4 v1(174.33,43.4) ; v1(178.8,65.23) 178.8,65.16 U119.52
  L07_SIG3 w0.089: v1(174.33,43.4) 174.33,43.41 174.98,44.06 174.98,45.01 176.62,46.64 176.62,50.74 177.42,51.54 180.34,51.54 181.8,53.01 181.8,53.6 182.04,53.84 182.04,54.73 181.96,54.81 181.96,62.37 181.73,62.6 181.5,62.6 180.99,63.12 180.99,63.38 180.73,63.64 180.39,63.64 v1(178.8,65.23)
  BOTTOM w0.149: R6035.2 179.49,64.89 179.15,65.23 v1(178.8,65.23)
ISENSE4: length 30.3
  TOP w0.149: U119.51 179.89,64.95 179.66,65.18 179.51,65.18 179.31,65.38 179.31,65.61 178.99,65.93 v1(178.76,65.93)
  TOP w0.203: U121.33 174.14,72.16 v1(174.21,72.09)
  L03_SIG1 w0.081: v1(174.21,72.09) 174.28,72.16 183.31,72.16 184.99,70.47 184.99,68.13 185.66,67.46 185.97,67.46 186.24,67.19 186.24,66.55 185.08,65.39 v1(184.28,65.39) 183.79,64.9 182.17,64.9 181.14,65.93 v1(178.76,65.93)
  BOTTOM w0.149: v1(184.28,65.39) 184.28,65.39 184.28,63.53 184.12,63.36 R5882.2
ITH0: length 2.1
  TOP w0.149: C1720.1 176.85,60.47 178.14,60.47 178.21,60.54 U119.9
ITHR0: length 1.8
  TOP w0.149: U119.10 178.21,60.14 178.18,60.17 177.41,60.17 C1721.1
JTAG_INPUT_SOURCE: length 25.6
  L03_SIG1 w0.081: v1(23.7,53.77) 23.7,53.24 25.9,51.04 v1(25.9,50.52) 25.43,50.52 23.77,48.86 23.77,37.83 25.46,36.14 25.46,34.13 25.94,33.66 26.26,33.66 26.87,33.06 26.87,32.27 v2(26.5,31.9)
JTAGEN: length 8.8
  TOP w0.149: v1(25.94,34.18) 26.08,34.32 arc(26.09,34.33) R6189.1
  L03_SIG1 w0.081: v2(28.5,26.9) 28.5,26.94 28.09,27.35 28.09,31.83 27.65,32.27 27.6,32.27 27.1,32.77 27.1,33.34 26.25,34.19 25.95,34.19 v1(25.94,34.18)
  BOTTOM w0.381: v1(25.94,34.18) R6190.2
LT4625_INTVCC:
  vias: v1(228.92,59.72) v1(231.22,64.82) v1(235.69,63.86)
LTM3888_ALERTN: length 9
  TOP w0.149: v1(177.94,52.78) 177.48,53.23 177.48,55.57 177.34,55.72 177.34,56.45 177.75,56.86 178.09,56.86 178.36,57.13 178.36,57.22 178.48,57.34 U119.17
  L14_SIG5 w0.081: v1(175.19,53.28) 176.18,52.29 177.45,52.29 v1(177.94,52.78)
LTM3888_SCL: length 255.5
  TOP w0.149: v1(177.88,57.96) 177.88,57.94 177.88,57.94 177.88,57.96 178,57.96 178.18,58.14 U119.15
  L07_SIG3 w0.089: v1(167.02,87.32) 162.61,82.9 162.61,60.3 169.14,53.77 171.19,53.77 171.19,53.77 172.25,53.77 174.02,55.54 174.02,57.72 174.12,57.83 174.12,58.66 175.1,59.63 175.49,59.63 175.97,59.15 176.67,59.15 176.85,59.33 177.5,59.33 177.88,58.95 v1(177.88,57.96) ; v1(226.48,36.89) 224.44,38.93 224.44,45.34 226.66,47.56 242.25,47.56 245.41,50.72 246.29,50.72 247.9,52.33 247.9,66.5 250.06,68.65 250.06,98.31 242.78,105.59 236.01,105.59 234.38,107.22 228.13,107.22 227.56,107.8 197.31,107.8 194.65,105.14 194.65,104.01 194.15,103.52 193.06,103.52 192.81,103.27 192.81,103.15 v1(192.81,103.15)
  L16_SIG6 w0.081: v1(192.81,103.15) 192.81,103.15 192.81,103.28 192.49,103.6 186.23,103.6 184.31,101.68 184.31,98.67 176.45,90.81 176.45,89.63 174.29,87.47 167.18,87.47 v1(167.02,87.32)
  BOTTOM w0.149: v1(226.48,36.89) 227.13,36.24 227.13,21.14 227.86,20.41 R546.2 227.97,18.32 J12.1
LTM3888_SDA: length 257.7
  TOP w0.149: v1(177.96,57.3) 177.96,57.31 178.06,57.41 178.06,57.56 178.24,57.74 U119.16
  L07_SIG3 w0.089: v1(177.96,57.3) 177.73,57.07 177.73,56.86 176.93,56.06 176.72,56.06 172.98,52.32 169.42,52.32 161.78,59.96 161.78,83.45 v1(166.18,87.85) ; v1(191.15,104.71) 191.15,106.03 191.75,106.63 191.75,106.64 192.44,107.33 196.17,107.33 197.12,108.29 234.01,108.29 236.16,106.14 242.94,106.14 250.54,98.54 250.54,68.45 248.38,66.3 248.38,51.91 245.7,49.22 244.71,49.22 243.37,47.89 243.37,46.88 241.92,45.43 240.54,45.43 239.44,46.52 226.57,46.52 224.92,44.88 224.92,40.07 v1(226.45,38.55)
  L16_SIG6 w0.081: v1(191.15,104.71) 190.86,104.42 183.92,104.42 182.65,103.15 182.65,98.46 178.4,94.21 178.4,93.84 177.05,92.49 174.82,92.49 170.92,88.59 166.92,88.59 v1(166.18,87.85)
  BOTTOM w0.149: J12.2 229.11,17.88 R547.2 229,20.41 228.54,20.88 228.54,21.94 227.58,22.9 227.58,37.41 v1(226.45,38.55)
LTM4623_INTVCC: length 3.7
  BOTTOM w0.254: R2788.2 206.67,19.75 206.93,20.01 207.75,20.01 C7650.1 207.91,19.95 R6141.2 208.48,20.72 v1(208.52,20.75)
LTM4623_INTVCC1: length 2.4
  BOTTOM w0.203: R6219.1 C7697.2
  BOTTOM w0.254: v1(18.45,42.9) 18.41,42.94 ; 18.41,42.94 R6111.2 ; 18.41,42.94 18.35,43 C7697.2
LTM4623_INTVCC2: length 8.5
  TOP w0.381: R6220.1 35.9,43.5 35.32,44.08 31.41,44.08 v1(30.33,43)
  BOTTOM w0.381: C7700.2 30.17,43.86 29.75,43.44 R6115.2 29.76,43 v1(30.33,43)
LTM4623_INTVCC3: length 11.9
  L16_SIG6 w0.381: v1(9.65,35.51) 7.17,35.51 6.59,36.1 6.59,39.14 7.04,39.6 7.58,39.6 7.8,39.83 7.8,42.12 v1(7.2,42.73)
  BOTTOM w0.381: v1(9.65,35.51) 9.65,34.8 R6221.1
LTM4623_INTVCC4: length 15
  L16_SIG6 w0.381: v1(18.18,64.07) 18.18,60.51 v1(17.32,59.64) 17.32,59.41 17.7,59.03 23.93,59.03 v1(24.59,58.37)
  BOTTOM w0.381: C7704.2 24.82,58.14 v1(24.59,58.37)
LTM4623_INTVCC5: length 3
  BOTTOM w0.381: C7714.2 74.42,88.12 R6136.2 74.81,87.35 75.09,87.07 75.09,86.41 74.78,86.11 R6223.1
  vias: v1(74.53,88)
LTM_INTVCC1: length 0.2
  TOP w0.381: U117.C7 v1(73.57,37.97)
  vias: v1(68.88,36.26) v1(69.16,31.45) v1(71.28,37.86) v1(73.6,36.27)
LTM_PMBUS_ALERTN: length 409.6
  TOP w0.149: v1(60.12,102.71) 60.12,102.4 60.34,102.18 60.34,93 61.29,92.05 61.29,69.33 61.86,68.76 v1(67.05,68.76)
  L05_SIG2 w0.081: v1(207.82,28.84) 207.51,28.52 202.49,28.52 201.8,29.21 201.8,32.87 201.41,33.27 193.59,33.27 191.05,35.81 191.05,38.19 187.52,41.72 180.61,41.72 v1(180.04,42.29)
  L07_SIG3 w0.089: v1(60.12,102.71) 60.12,103.97 65.9,109.76 185.07,109.76 v1(187.04,107.78) ; v1(187.56,85.83) 187.39,86 187.39,93.58 187.69,93.88 187.69,101.58 187.04,102.23 v1(187.04,103.09) 187.8,103.09 188.48,102.42 190.96,102.42 191.42,101.96 191.73,101.96 192.3,102.53 193.06,102.53 193.24,102.71 194.67,102.71 196.22,101.16 198.26,101.16 199.53,102.44 199.53,104.76 200.79,106.02 234.89,106.02 235.82,105.09 242.56,105.09 249.57,98.08 249.57,68.92 247.42,66.77 247.42,53.51 245.66,51.75 245.37,51.75 242.31,48.7 242.31,48.31 242.05,48.04 226.42,48.04 223.75,45.36 223.75,43.02 222.53,41.8 213.17,41.8 211.27,39.91 211.27,38.57 209.93,37.22 208.86,37.22 207.7,36.06 207.7,35.04 209.92,32.82 209.92,30.03 208.73,28.84 v1(207.82,28.84)
  BOTTOM w0.149: v1(187.56,85.83) 187.56,85.78 187.55,85.77 R5847.2 ; v1(187.04,107.78) 186.84,107.57 186.84,103.3 v1(187.04,103.09) ; R6163.2 178.57,43.94 178.6,43.97 178.94,43.97 179.48,43.43 179.48,42.99 179.95,42.52 arc(180.02,42.42) v1(180.04,42.29)
LTM_SCL: length 470.7
  TOP w0.149: U136.E4 68.23,69.38 67.72,69.9 67.41,69.9 66.77,70.54 66.77,70.85 66.45,71.17 62.94,71.17 62.31,71.8 62.31,92.52 61.03,93.81 61.03,104.61 v1(60.33,105.31) ; R621.2 236.65,19.83 R6289.2 ; R621.2 235.81,19.82 235.39,20.24 235.39,21.63 235.91,22.16 238.56,22.16 244.7,28.3 248.77,28.3 249.39,28.91 v2(251.16,28.91) ; R621.2 236.64,18.99 237.03,18.6 J13.1 235.73,17.47 234.01,19.19 234.01,23.6 v1(231.92,25.69) ; U118.E4 v1(187.73,83.16)
  L03_SIG1 w0.081: v1(187.73,83.16) 187.91,83.16 188.82,84.07 188.82,86.38 187.9,87.29 186.73,87.29 186.19,87.83 186.19,88.49 186.49,88.8 188.2,88.8 190.21,90.81 190.21,91.96 190.45,92.19 191.35,92.19 192.91,93.75 192.91,94.4 195.3,96.79 195.3,98.73 196.38,99.81 197.01,99.81 199.08,101.88 199.08,105.03 200.48,106.43 216.87,106.43 218.29,105 220.03,105 221.04,104 221.04,102.62 221.66,102 222.84,102 223.85,103.01 232.22,103.01 233.88,104.67 243.52,104.67 251.62,96.57 251.62,67.05 250.79,66.22 250.79,54.98 250.57,54.76 250.57,50.33 250.81,50.09 250.81,34.52 251.35,33.97 251.35,29.1 v2(251.16,28.91)
  L05_SIG2 w0.081: v1(178.77,43.56) 178.77,41.77 180.24,40.3 186.57,40.3 189.42,37.46 189.42,36.08 192.85,32.65 196.21,32.65 196.22,32.65 200.39,32.65 200.65,32.39 200.65,29.7 202.59,27.76 208.3,27.76 210.25,29.71 210.99,29.71 212.25,28.46 214.19,28.46 214.21,28.47 214.25,28.46 218.46,28.46 221.41,31.41 226.2,31.41 v1(231.92,25.69)
  L16_SIG6 w0.081: v1(60.33,105.31) 60.68,105.66 61.89,105.66 64.09,107.86 71.99,107.86 72.36,108.23 72.69,108.23 73.06,107.86 138.29,107.86 138.38,107.96 152.96,107.96 153.06,107.86 174.39,107.86 175.1,107.16 185.26,107.16 185.44,107.33 194.01,107.33 194.95,106.39 194.95,101.9 194.87,101.82 194.72,101.82 194.5,101.6 194.5,101.35 194.06,100.91 193.75,100.91 190.21,97.37 190.21,91.64 190.4,91.45 190.4,91.09 188.81,89.5 188.81,83.91 188.06,83.16 v1(187.73,83.16)
LTM_SDA: length 476
  TOP w0.149: U136.D4 66.99,69.36 66.45,69.9 63.25,69.9 61.97,71.18 61.97,92.17 60.65,93.49 60.65,103.79 v1(60,104.43) ; R622.2 239.88,19.81 R6290.2 ; R622.2 240.99,19.82 241.27,20.09 241.27,22.72 244.43,25.88 249.32,25.88 250.45,27.02 v2(250.45,28.23) ; R622.2 239.88,18.97 239.57,18.66 J13.2 238.27,16.17 236.1,16.17 233.16,19.1 233.16,22.66 231.29,24.53 231.29,25.64 231.89,26.23 v1(232.44,26.23)
  L03_SIG1 w0.081: v1(188.14,83.92) 188.58,84.36 188.58,85.48 187.25,86.81 186,86.81 185.25,87.56 185.25,88.47 185.81,89.03 187.94,89.03 188.51,89.6 188.51,90.72 190.71,92.91 190.71,93.69 192.02,95.01 192.8,95.01 194.9,97.1 194.9,98.73 195.41,99.25 195.41,101.91 194.9,102.42 194.9,105.18 196.75,107.04 216.71,107.04 218.51,105.24 220.16,105.24 221.27,104.13 221.27,102.72 221.76,102.23 222.75,102.23 223.79,103.27 232.15,103.27 233.81,104.93 243.89,104.93 251.86,96.96 251.86,66.96 251.02,66.12 251.02,56.57 251.63,55.96 251.63,53.68 251.44,53.49 251.44,49.46 251.63,49.27 251.63,47.33 251.11,46.81 251.11,34.86 251.63,34.34 251.63,28.71 251.15,28.23 v2(250.45,28.23)
  L05_SIG2 w0.081: v1(181.31,42.29) 180.59,43.02 179.72,43.02 179.47,42.77 179.47,41.96 180.03,41.39 186.77,41.39 190.53,37.63 190.53,35.68 193.18,33.04 201.31,33.04 201.57,32.78 201.57,29.11 202.44,28.24 208.45,28.24 209.45,29.24 209.45,29.27 210.13,29.95 211.09,29.95 212.34,28.69 214.09,28.69 214.98,29.58 219.14,29.58 221.27,31.71 226.96,31.71 v1(232.44,26.23)
  L16_SIG6 w0.081: v1(60,104.43) 61.07,104.43 64.06,107.43 72.67,107.43 72.83,107.59 137.38,107.59 137.75,107.22 140.98,107.22 141.34,107.58 174.25,107.58 174.92,106.91 184.73,106.91 185.26,106.38 193.73,106.38 194.55,105.56 194.55,102.59 192.56,100.61 192.25,100.61 192.02,100.83 190.4,100.83 188.47,98.91 188.47,95.33 188.62,95.18 188.62,93.51 188.64,93.49 188.64,91.43 187.39,90.17 187.39,86.18 187.19,85.98 187.19,85.43 188.14,84.48 v1(188.14,83.92)
M10_1V2_CLK: length 90
  L14_SIG5 w0.081: v1(37.09,60.72) 36.72,60.72 36.56,60.88 36.56,62.1 36.8,62.34 38.95,62.34 43.37,66.76 61.33,66.76 63.36,64.73 63.69,64.73 63.77,64.65 63.77,64.37 63.85,64.29 64.03,64.29 64.11,64.37 64.11,64.65 64.19,64.73 64.36,64.73 64.44,64.65 64.44,64.37 64.52,64.29 64.7,64.29 64.78,64.37 64.78,64.65 64.86,64.73 65.03,64.73 65.11,64.65 65.11,64.37 65.2,64.29 65.37,64.29 65.45,64.37 65.45,64.65 65.53,64.73 65.7,64.73 65.78,64.65 65.78,64.37 65.87,64.29 66.04,64.29 66.12,64.37 66.12,64.65 66.2,64.73 66.37,64.73 66.46,64.65 66.46,64.37 66.54,64.29 66.71,64.29 66.79,64.37 66.79,64.65 66.87,64.73 67.04,64.73 67.13,64.65 67.13,64.37 67.21,64.29 67.38,64.29 67.46,64.37 67.46,64.65 67.54,64.73 67.72,64.73 67.8,64.65 67.8,64.37 67.88,64.29 68.05,64.29 68.13,64.37 68.13,64.65 68.21,64.73 77.97,64.73 78.71,65.47 78.71,67 81.52,69.81 82.15,69.81 82.44,70.1 82.44,70.65 82.73,70.94 83.01,70.94 83.29,71.23 83.29,71.56 83.79,72.05 84.5,72.05 85.79,73.34 87,73.34 87.72,74.05 87.97,74.05 88.43,74.52 89.41,74.52 89.62,74.31 89.9,74.31 90.4,74.81 90.76,74.81 90.97,75.01 92.02,75.01 92.72,74.31 93.79,74.31 93.95,74.47 94.23,74.47 94.39,74.31 95.31,74.31 95.64,74.64 96.01,74.64 96.38,75.01 97.17,75.01 97.57,74.62 97.97,74.62 98.28,74.31 98.56,74.31 98.87,74.62 99.61,74.62 100.25,73.98 100.52,73.98 100.98,73.52 101.32,73.52 101.74,73.1 102.39,73.1 102.64,72.86 102.91,72.86 103.16,73.1 103.55,73.1 103.98,73.53 103.98,74.23 104,74.24 104,74.26 104.21,74.48 104.51,74.48 105.06,75.03 v1(105.96,75.03)
  BOTTOM w0.149: v1(37.09,60.72) 37.5,60.31 U40.3
M10_1V2_DATA0: length 89.3
  L14_SIG5 w0.081: v1(105.96,75.95) 106.38,75.53 106.38,74.76 106.1,74.48 105.81,74.48 105.59,74.26 105.59,73.38 105.31,73.1 105.01,73.1 104.74,72.83 104.74,72.05 104.58,71.9 104.21,71.9 103.96,72.16 103.45,72.16 103.19,71.9 102.36,71.9 102.12,72.14 101.84,72.14 101.64,71.94 100.78,71.94 100.54,72.18 100.21,72.18 99.75,72.64 98.89,72.64 98.56,72.97 98.28,72.97 98.04,72.72 97.28,72.72 96.86,73.15 96.51,73.15 95.99,72.64 95.43,72.64 95.1,72.31 94.82,72.31 94.47,72.66 93.68,72.66 93.36,72.97 93.09,72.97 92.76,72.64 92.23,72.64 91.76,73.11 91.33,73.11 90.85,72.64 90.23,72.64 89.9,72.31 89.62,72.31 89.35,72.58 88.5,72.58 88.14,72.22 87.5,72.22 87.16,71.88 86.23,71.88 85.71,71.36 85.08,71.36 84.4,70.68 84.4,68.85 83.97,68.43 81.39,68.43 79.36,66.41 79.36,65.2 77.65,63.49 76.11,63.49 76.02,63.57 76.02,63.9 75.94,63.98 75.77,63.98 75.69,63.9 75.69,63.57 75.61,63.49 75.44,63.49 75.35,63.57 75.35,63.9 75.27,63.98 75.1,63.98 75.02,63.9 75.02,63.57 74.94,63.49 74.77,63.49 74.68,63.57 74.68,63.9 74.6,63.98 74.43,63.98 74.35,63.9 74.35,63.57 74.27,63.49 74.09,63.49 74.01,63.57 74.01,63.9 73.93,63.98 73.76,63.98 73.68,63.9 73.68,63.57 73.6,63.49 73.42,63.49 73.34,63.57 73.34,63.9 73.26,63.98 73.09,63.98 73.01,63.9 73.01,63.57 72.93,63.49 63.02,63.49 60.43,66.09 43.82,66.09 39.63,61.9 39.63,61.45 39.33,61.14 38.98,61.14 38.57,60.72 v1(38.11,60.72)
  BOTTOM w0.149: v1(38.11,60.72) 38.15,60.68 U40.4
M10_1V2_DATA1: length 90.1
  L14_SIG5 w0.081: v1(105.17,76.41) 105.17,76.22 104.52,75.58 104.13,75.58 103.5,74.94 103.42,74.94 103.2,74.72 103.2,73.86 103.01,73.67 102.69,73.67 102.16,74.2 101.62,74.2 101.33,74.48 101.15,74.48 100.47,75.16 99.93,75.16 99.73,75.36 98.62,75.36 98.56,75.31 97.86,75.31 97.69,75.47 96.99,75.47 96.83,75.31 96.13,75.31 95.42,76.01 94.43,76.01 94.13,75.71 93.63,75.71 93.36,75.97 90.99,75.97 90.11,75.09 89.56,75.09 89.2,74.74 88.55,74.74 88.28,75.01 87.88,75.01 87.66,74.79 87.66,74.46 86.87,73.67 85.66,73.67 84.46,72.47 83.37,72.47 78.39,67.48 78.39,66.83 76.69,65.14 63.55,65.14 61.58,67.11 43.25,67.11 38.82,62.67 36.46,62.67 35.46,61.66 35.46,61.45 35.22,61.21 34.89,61.21 34.68,61 34.68,60.37 35.15,59.9 38.3,59.9 v1(39.12,60.72)
  BOTTOM w0.149: v1(39.12,60.72) 38.8,60.4 U40.5
M10_1V2_DATA2: length 90.5
  L14_SIG5 w0.081: v1(40.14,60.72) 40.14,61.01 40.65,61.52 40.65,62.41 43.98,65.75 60.31,65.75 62.89,63.16 63.19,63.16 63.27,63.08 63.27,62.86 63.35,62.78 63.52,62.78 63.6,62.86 63.6,63.08 63.68,63.16 63.86,63.16 63.94,63.08 63.94,62.86 64.02,62.78 64.19,62.78 64.27,62.86 64.27,63.08 64.35,63.16 64.53,63.16 64.61,63.08 64.61,62.86 64.69,62.78 64.86,62.78 64.94,62.86 64.94,63.08 65.02,63.16 65.2,63.16 65.28,63.08 65.28,62.86 65.36,62.78 65.53,62.78 65.61,62.86 65.61,63.08 65.69,63.16 65.87,63.16 65.95,63.08 65.95,62.86 66.03,62.78 66.2,62.78 66.28,62.86 66.28,63.08 66.37,63.16 66.54,63.16 66.62,63.08 66.62,62.86 66.7,62.78 66.87,62.78 66.95,62.86 66.95,63.08 67.04,63.16 67.21,63.16 67.29,63.08 67.29,62.86 67.37,62.78 67.54,62.78 67.63,62.86 67.63,63.08 67.71,63.16 67.88,63.16 67.96,63.08 67.96,62.86 68.04,62.78 68.21,62.78 68.3,62.86 68.3,63.08 68.38,63.16 68.55,63.16 68.63,63.08 68.63,62.86 68.71,62.78 68.89,62.78 68.97,62.86 68.97,63.08 69.05,63.16 69.22,63.16 69.3,63.08 69.3,62.86 69.38,62.78 69.56,62.78 69.64,62.86 69.64,63.08 69.72,63.16 69.89,63.16 69.97,63.08 69.97,62.86 70.05,62.78 70.23,62.78 70.31,62.86 70.31,63.08 70.39,63.16 70.56,63.16 70.64,63.08 70.64,62.86 70.72,62.78 70.9,62.78 70.98,62.86 70.98,63.08 71.06,63.16 71.23,63.16 71.31,63.08 71.31,62.86 71.39,62.78 71.57,62.78 71.65,62.86 71.65,63.08 71.73,63.16 71.9,63.16 71.98,63.08 71.98,62.86 72.07,62.78 72.24,62.78 72.32,62.86 72.32,63.08 72.4,63.16 77.78,63.16 79.69,65.07 79.69,66 80.47,66.78 81.28,66.78 82.6,68.1 84.5,68.1 85.37,68.97 85.37,70.46 85.97,71.06 87.17,71.06 87.4,71.29 87.4,71.62 87.82,72.04 88.52,72.04 88.76,71.81 90.76,71.81 91.04,72.08 91.69,72.08 92,71.77 92.66,71.77 92.88,71.99 93.77,71.99 93.95,71.81 95.96,71.81 96.23,72.08 96.83,72.08 97.17,71.73 97.87,71.73 98.22,72.08 98.93,72.08 99.33,71.68 99.73,71.68 99.99,71.42 100.72,71.42 101.03,71.72 101.33,71.72 101.64,71.42 102.37,71.42 102.64,71.68 102.91,71.68 103.18,71.42 103.57,71.42 104.01,70.98 104.73,70.98 105.23,71.48 105.3,71.48 105.54,71.71 105.54,72.47 105.7,72.64 105.89,72.64 106.39,73.14 106.39,74.2 v1(106.76,74.57)
  BOTTOM w0.149: U40.6 39.45,60.03 v1(40.14,60.72)
M10_1V2_DATA3: length 90.5
  L14_SIG5 w0.081: v1(107.56,75.03) 107.18,74.65 107.18,73.4 106.87,73.1 106.61,73.1 106.39,72.88 106.39,71.25 106.12,70.98 105.78,70.98 105.32,70.52 104.87,70.52 104.6,70.8 104,70.8 103.73,70.52 103.42,70.52 103.08,70.86 102.47,70.86 102.13,70.52 101.83,70.52 101.49,70.86 101.08,70.86 100.97,70.75 100.71,70.75 100.52,70.56 100.25,70.56 99.83,70.97 98.62,70.97 98.12,71.47 96.99,71.47 96.83,71.31 96.13,71.31 95.96,71.47 93.53,71.47 93.36,71.31 92.66,71.31 92.5,71.47 91.8,71.47 91.63,71.31 90.93,71.31 90.76,71.47 88.33,71.47 87.55,70.69 86.87,70.69 86.42,70.23 86.42,69.49 84.23,67.31 82.45,67.31 82.45,67.3 82.39,67.3 80.13,65.03 80.13,64.35 78.19,62.41 62.45,62.41 59.44,65.42 56.51,65.42 56.42,65.34 56.42,64.95 56.34,64.87 56.17,64.87 56.09,64.95 56.09,65.34 56.01,65.42 55.84,65.42 55.75,65.34 55.75,64.95 55.67,64.87 55.5,64.87 55.42,64.95 55.42,65.34 55.34,65.42 55.16,65.42 55.08,65.34 55.08,64.95 55,64.87 54.83,64.87 54.75,64.95 54.75,65.34 54.67,65.42 54.49,65.42 54.41,65.34 54.41,64.95 54.33,64.87 54.16,64.87 54.08,64.95 54.08,65.34 54,65.42 53.82,65.42 53.74,65.34 53.74,64.95 53.66,64.87 53.49,64.87 53.41,64.95 53.41,65.34 53.33,65.42 53.15,65.42 53.07,65.34 53.07,64.95 52.99,64.87 52.82,64.87 52.74,64.95 52.74,65.34 52.66,65.42 52.48,65.42 52.4,65.34 52.4,64.95 52.32,64.87 52.15,64.87 52.07,64.95 52.07,65.34 51.98,65.42 51.81,65.42 51.73,65.34 51.73,64.95 51.65,64.87 51.48,64.87 51.4,64.95 51.4,65.34 51.31,65.42 44.19,65.42 42.62,63.86 42.62,61.5 41.84,60.72 v1(41.16,60.72)
  BOTTOM w0.149: v1(41.16,60.72) 40.51,60.07 40.27,60.07 40.1,59.91 U40.7
M10_1V2_GPIO0: length 84.2
  L14_SIG5 w0.081: v1(40.75,59.41) 40.99,59.41 42.95,61.37 42.95,63.08 44.39,64.52 59.25,64.52 61.69,62.09 78.47,62.09 80.99,64.6 80.99,65.44 82.53,66.97 84.67,66.97 88.86,71.17 90.13,71.17 90.49,70.81 92.5,70.81 92.81,71.12 95.37,71.12 95.69,70.81 95.96,70.81 96.28,71.12 97.1,71.12 97.42,70.81 97.77,70.81 98.52,70.05 100,70.05 100.25,70.3 100.52,70.3 100.77,70.05 101.37,70.05 101.83,69.6 102.13,69.6 102.45,69.91 103.1,69.91 103.42,69.6 103.73,69.6 104.18,70.05 104.56,70.05 105.01,69.6 105.32,69.6 105.6,69.87 106.13,69.87 106.77,70.52 106.91,70.52 107.13,70.74 107.13,72.54 107.45,72.86 107.69,72.86 107.98,73.14 107.98,75.2 107.75,75.43 107.35,75.43 107.15,75.63 107.15,76.02 v1(106.76,76.41)
M10_1V2_GPIO1: length 84.6
  L14_SIG5 w0.081: v1(41.4,58.14) 41.4,59.41 43.24,61.25 43.24,62.84 44.06,63.67 46.58,63.67 46.97,64.06 59.13,64.06 61.34,61.85 78.57,61.85 81.22,64.5 81.22,65.29 82.63,66.69 84.8,66.69 87.23,69.12 87.98,69.12 88.67,69.81 89.4,69.81 90.06,70.47 90.76,70.47 90.93,70.31 93.36,70.31 93.53,70.47 94.23,70.47 94.39,70.31 95.1,70.31 95.26,70.47 95.96,70.47 96.13,70.31 96.49,70.31 97.02,69.78 97.02,69.77 97.82,69.77 98.45,69.14 99.95,69.14 100.23,69.42 100.54,69.42 100.78,69.18 102.92,69.18 103.42,68.68 103.73,68.68 104.14,69.09 104.74,69.09 105.03,69.38 105.6,69.38 105.82,69.6 106.91,69.6 107.22,69.91 107.22,70.57 107.42,70.76 107.66,70.76 107.95,71.06 107.95,72.85 108.2,73.1 108.33,73.1 108.74,73.51 108.74,75.64 108.43,75.95 v1(107.56,75.95)
M10_1V2_SSN: length 89
  L14_SIG5 w0.081: v1(105.17,74.57) 105.17,74.28 104.41,73.52 104.23,73.52 103.99,73.28 103.99,72.62 103.73,72.36 103.42,72.36 103.14,72.64 102.41,72.64 102.13,72.36 101.56,72.36 101.32,72.6 101.02,72.6 100.46,73.16 100.08,73.16 99.64,73.61 98.95,73.61 98.62,73.28 98.06,73.28 97.84,73.5 97.3,73.5 96.83,73.97 96.13,73.97 95.96,73.81 95.39,73.81 95.18,74.02 94.63,74.02 94.39,73.77 93.56,73.77 93.36,73.97 93.09,73.97 92.76,73.65 91.96,73.65 91.63,73.97 90.93,73.97 90.76,73.81 90.49,73.81 90.28,74.01 89.38,74.01 89.15,73.79 88.7,73.79 87.92,73.01 87.73,73.01 86.93,72.21 86.11,72.21 85.82,71.93 85.09,71.93 83.85,70.69 83.73,70.69 83.5,70.46 83.5,69.88 83.09,69.47 81.74,69.47 79.04,66.76 79.04,65.34 78.05,64.35 72.47,64.35 72.06,63.94 71.61,63.94 71.53,64.02 71.53,64.3 71.45,64.38 71.27,64.38 71.19,64.3 71.19,64.02 71.11,63.94 70.94,63.94 70.86,64.02 70.86,64.3 70.78,64.38 70.6,64.38 70.52,64.3 70.52,64.02 70.44,63.94 70.27,63.94 70.19,64.02 70.19,64.3 70.11,64.38 69.93,64.38 69.85,64.3 69.85,64.02 69.77,63.94 69.6,63.94 69.52,64.02 69.52,64.3 69.43,64.38 69.26,64.38 69.18,64.3 69.18,64.02 69.1,63.94 68.93,63.94 68.85,64.02 68.85,64.3 68.76,64.38 68.59,64.38 68.51,64.3 68.51,64.02 68.43,63.94 63.04,63.94 60.55,66.43 43.54,66.43 39.13,62.02 38.83,62.02 38.63,61.82 38.63,61.47 38.32,61.17 37.93,61.17 37.65,60.88 37.65,60.5 37.4,60.24 35.54,60.24 v1(35.06,60.72)
  BOTTOM w0.149: U40.1 36.2,59.52 35.06,60.66 v1(35.06,60.72)
