# Allegro board FM85_AGILEX_PCIE_DK_CMC_ADI_REVC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_COMP_CH0_DQ66: length 65.9
  L12_SIG4 w0.089: v1(105.17,45.13) 104.76,44.43 arc(104.71,44.2) 104.77,43.98 arc(104.83,43.75) 104.77,43.52 104.77,43.52 arc(104.6,43.35) 104.37,43.29 104.36,43.29 arc(104.14,43.22) 103.97,43.06 arc(103.8,42.89) 103.58,42.83 103.57,42.83 arc(103.34,42.77) 103.18,42.6 103.17,42.59 arc(103,42.43) 102.77,42.37 arc(102.55,42.31) 102.38,42.15 102.37,42.13 arc(102.2,41.96) 101.98,41.91 arc(101.75,41.85) 101.59,41.69 101.58,41.68 101.58,41.45 101.44,41.31 arc(101.41,41.26) 101.39,41.2 101.39,40.98 101.16,40.74 100.98,40.62 arc(100.75,40.55) 100.59,40.39 arc(100.4,40.2) 100.15,40.14 arc(99.91,40.07) 99.72,39.89 99.72,39.88 arc(99.54,39.7) 99.29,39.64 99.28,39.64 arc(99.04,39.57) 98.85,39.39 arc(98.79,39.14) 98.85,38.89 arc(98.92,38.64) 98.86,38.39 98.85,38.39 arc(98.67,38.2) 98.42,38.14 arc(98.17,38.07) 97.99,37.89 97.99,37.89 arc(97.81,37.7) 97.56,37.64 arc(97.31,37.57) 97.13,37.39 97.09,37.33 arc(96.94,37.2) 96.75,37.14 arc(96.62,37.1) 96.51,37.04 arc(96.46,36.99) 96.42,36.94 96.35,36.83 arc(96.2,36.7) 96.01,36.64 95.54,36.16 91.86,36.16 86.79,31.09 86.79,30.42 86.37,30 86.37,26.23 86.28,26.14 83.28,26.14 83.19,26.05 83.19,25.04 83.08,24.93 82.93,24.93 82.85,25.02 82.85,26.05 82.76,26.14 81.34,26.14 81.17,26.31 81.17,29.88 81.02,30.03 78.96,30.03 78.78,29.86 78.78,26.52 78.59,26.33 75.76,26.33 75.54,26.11 75.14,26.11 75.02,25.98 75.02,25.41 74.92,25.32 74.4,25.32 74.18,25.09 74.18,24.74 73.94,24.51 73.14,24.51 72.92,24.29 72.92,21.86 72.77,21.71 72.62,21.71 72.53,21.8 72.53,22.87 72.43,22.97 72.29,22.97 72.19,22.87 72.19,21.71 72.08,21.61 71.92,21.61 71.84,21.69 71.84,22.87 71.75,22.97 71.59,22.97 71.5,22.88 71.5,21.76 71.38,21.64 71.12,21.64 70.97,21.78 70.97,22.69 70.59,23.06 v1(70.59,23.33)
DDR4_COMP_CH0_DQ67: length 65.5
  L12_SIG4 w0.089: v1(73.79,23.33) 74.09,23.33 74.18,23.42 74.18,24.26 74.44,24.53 75.88,24.53 76.01,24.66 76.01,25.89 76.1,25.98 78.45,25.98 78.59,25.84 78.59,24.67 78.74,24.51 79.46,24.51 79.59,24.64 79.59,29.59 79.67,29.68 80.25,29.68 80.35,29.58 80.35,25.14 80.52,24.98 81.3,24.98 81.71,24.56 83.32,24.56 83.6,24.85 83.6,25.09 83.87,25.36 85.99,25.36 86.12,25.23 86.12,24.05 86.21,23.96 86.36,23.96 86.47,24.06 86.47,25.33 86.55,25.42 87.1,25.42 87.19,25.51 87.19,26.19 87.09,26.29 86.83,26.29 86.72,26.4 86.72,26.56 86.9,26.74 86.9,26.91 86.72,27.08 86.72,27.25 86.9,27.43 86.9,27.59 86.72,27.77 86.72,27.94 86.9,28.11 86.9,28.28 86.72,28.45 86.72,28.62 86.9,28.8 86.9,28.96 86.72,29.14 86.72,29.31 86.9,29.48 86.9,30.04 87.13,30.28 87.13,30.95 92,35.82 96.76,35.82 98.18,37.24 99.05,37.24 99.88,38.06 100.42,38.06 100.86,38.51 101.2,38.51 101.53,38.84 101.53,39.7 101.89,40.07 101.98,40.07 arc(102.38,40.3) 102.38,40.75 102.37,40.76 arc(102.31,40.99) 102.38,41.22 arc(102.54,41.38) 102.77,41.45 102.77,41.45 arc(103,41.51) 103.17,41.67 103.17,41.68 arc(103.34,41.85) 103.57,41.91 arc(103.8,41.96) 103.96,42.12 103.98,42.15 arc(104.14,42.31) 104.37,42.37 arc(104.6,42.43) 104.76,42.59 104.77,42.6 arc(104.94,42.77) 105.17,42.83 105.17,42.83 arc(105.4,42.89) 105.56,43.06 arc(105.73,43.22) 105.96,43.29 105.96,43.29 arc(106.19,43.35) 106.36,43.52 106.36,43.52 arc(106.42,43.75) 106.36,43.98 106.36,44.05 106.36,44.05 106.36,44.36 106.62,44.62 106.9,44.62 107.36,45.08 107.56,45.13 arc(107.78,45.19) 107.95,45.35 v1(108.35,46.05)
DDR4_COMP_CH0_DQ68: length 67
  L12_SIG4 w0.089: v1(104.37,46.51) 104.13,46.51 104.04,46.59 103.39,46.59 102.93,46.13 102.6,46.13 102.06,45.59 101.99,45.59 101.98,45.59 arc(101.75,45.53) 101.58,45.36 101.58,45.35 arc(101.41,45.19) 101.18,45.13 101.18,45.13 arc(100.95,45.06) 100.78,44.9 arc(100.62,44.73) 100.39,44.67 100.38,44.67 arc(100.15,44.6) 99.99,44.44 arc(99.82,44.27) 99.59,44.21 99.59,44.21 arc(99.36,44.14) 99.19,43.98 98.85,43.39 98.42,43.14 arc(98.17,43.07) 97.99,42.89 97.99,42.88 97.96,42.85 97.79,42.85 97.73,42.8 97.67,42.78 97.59,42.76 97.52,42.76 97.45,42.78 97.38,42.8 97.32,42.85 97.15,42.85 97.12,42.89 arc(96.94,43.07) 96.7,43.14 96.69,43.14 arc(96.44,43.07) 96.26,42.89 96.25,42.88 arc(96.07,42.7) 95.82,42.64 95.82,42.64 arc(95.57,42.57) 95.39,42.39 arc(95.21,42.2) 94.96,42.14 94.96,42.14 arc(94.71,42.07) 94.53,41.89 94.52,41.88 arc(94.34,41.7) 94.09,41.64 arc(93.84,41.57) 93.66,41.39 93.66,41.38 arc(93.47,41.2) 93.23,41.14 arc(92.98,41.07) 92.79,40.89 92.79,40.89 arc(92.61,40.7) 92.37,40.64 92.35,40.64 arc(92.11,40.57) 91.93,40.39 arc(91.89,40.33) 91.85,40.28 91,39.44 91,39.17 91.06,38.89 91.06,38.88 arc(90.88,38.7) 90.63,38.64 90.62,38.64 arc(90.37,38.57) 90.19,38.39 90.19,38.38 arc(90.01,38.2) 89.76,38.14 89.75,38.14 arc(89.24,37.92) 89.03,37.41 89.03,36.26 88.45,35.67 88.32,35.67 88.1,35.89 87.97,35.89 87.85,35.78 87.85,35.65 88.08,35.43 88.08,35.3 87.96,35.19 87.84,35.19 87.61,35.41 87.49,35.41 87.37,35.29 87.37,35.17 87.59,34.94 87.59,34.82 87.48,34.7 87.35,34.7 87.13,34.93 87,34.93 86.88,34.81 86.88,34.68 87.11,34.46 87.11,34.33 86.99,34.22 86.87,34.22 86.64,34.44 86.52,34.44 86.4,34.32 86.4,34.2 86.62,33.97 86.62,33.85 86.51,33.73 86.38,33.73 86.16,33.96 86.03,33.96 85.91,33.84 85.91,33.71 86.14,33.49 86.14,33.36 86.02,33.25 85.9,33.25 85.67,33.47 85.55,33.47 85.43,33.35 85.43,33.23 85.65,33 85.65,32.88 85.54,32.76 85.41,32.76 85.19,32.99 85.06,32.99 84.94,32.87 84.94,32.74 85.17,32.52 85.17,32.39 85.05,32.28 84.93,32.28 84.7,32.5 84.58,32.5 84.46,32.38 84.46,32.26 84.68,32.03 84.68,31.91 84.57,31.79 84.44,31.79 84.16,32.07 83.99,32.07 83.79,31.87 78.32,31.87 76.82,30.36 75.8,30.36 74.87,31.29 74.34,31.29 74.26,31.2 74.26,30.95 74.17,30.86 74,30.86 73.91,30.95 73.91,31.2 73.82,31.29 73.66,31.29 73.57,31.2 73.57,30.95 73.48,30.86 73.32,30.86 73.23,30.95 73.23,31.2 73.14,31.29 72.97,31.29 72.88,31.2 72.88,30.95 72.79,30.86 72.63,30.86 72.54,30.95 72.54,31.2 72.45,31.29 72.29,31.29 72.2,31.2 72.2,30.95 72.11,30.86 71.94,30.86 71.86,30.95 71.86,31.2 71.77,31.29 71.12,31.29 71.03,31.2 71.03,30.95 70.94,30.86 70.77,30.86 70.68,30.95 70.68,31.2 70.59,31.29 70.43,31.29 70.34,31.2 70.34,30.95 70.25,30.86 70.09,30.86 70,30.95 70,31.2 69.89,31.31 69.58,31.31 69.32,31.05 68.6,31.05 68.47,30.92 68.47,30.32 68.55,30.23 69.72,30.23 69.84,30.11 69.84,29.85 69.74,29.75 68.7,29.75 68.61,29.66 68.61,28.63 68.7,28.54 69.28,28.54 69.42,28.4 69.42,27.89 69.27,27.74 68.7,27.74 68.61,27.66 68.61,23.8 68.7,23.71 69.42,23.71 v1(69.79,23.33)
DDR4_COMP_CH0_DQ69: length 66.7
  L12_SIG4 w0.089: v1(107.56,44.67) 107.53,44.62 107.54,44.57 107.48,44.47 107.48,44.2 107.18,43.9 107.18,43.61 107.13,43.57 107.15,43.52 107.16,43.51 arc(107.22,43.29) 107.16,43.06 arc(106.99,42.89) 106.77,42.83 106.76,42.83 arc(106.53,42.77) 106.36,42.6 106.36,42.59 arc(106.19,42.43) 105.96,42.37 arc(105.74,42.31) 105.57,42.15 105.56,42.12 arc(105.39,41.96) 105.16,41.91 arc(104.94,41.85) 104.77,41.68 104.76,41.67 arc(104.6,41.51) 104.37,41.45 arc(104.14,41.38) 103.97,41.22 arc(103.81,41.05) 103.58,40.99 103.57,40.99 arc(103.34,40.93) 103.17,40.76 103.17,40.75 arc(103.11,40.52) 103.17,40.3 arc(103.23,40.07) 103.17,39.84 103.17,39.83 arc(103,39.67) 102.77,39.61 102.77,39.61 arc(102.54,39.54) 102.38,39.38 arc(102.31,39.15) 102.37,38.92 102.38,38.91 arc(102.44,38.68) 102.38,38.46 102.17,38.26 101.89,38.26 101.28,37.65 101.02,37.65 100.23,36.86 98.28,36.86 96.83,35.41 96.44,35.41 96.35,35.32 96.35,35.16 96.29,35.11 96.06,35.11 96.01,35.17 96.01,35.32 95.92,35.41 95.75,35.41 95.66,35.32 95.66,35.2 95.57,35.11 95.41,35.11 95.32,35.2 95.32,35.32 95.23,35.41 95.07,35.41 94.98,35.32 94.98,35.2 94.89,35.11 94.72,35.11 94.63,35.2 94.63,35.32 94.55,35.41 94.38,35.41 94.29,35.32 94.29,35.2 94.2,35.11 94.04,35.11 93.95,35.2 93.95,35.32 93.86,35.41 93.69,35.41 93.61,35.32 93.61,35.2 93.52,35.11 93.35,35.11 93.26,35.2 93.26,35.32 93.17,35.41 93.01,35.41 92.92,35.32 92.92,35.2 92.83,35.11 92.67,35.11 92.58,35.2 92.58,35.32 92.49,35.41 92.15,35.41 87.93,31.19 87.93,31.19 87.53,30.79 87.53,29.76 87.44,29.67 87.33,29.67 87.24,29.58 87.24,29.41 87.33,29.32 87.44,29.32 87.53,29.23 87.53,29.07 87.44,28.98 87.33,28.98 87.24,28.89 87.24,28.73 87.33,28.64 87.44,28.64 87.53,28.55 87.53,28.38 87.44,28.3 87.33,28.3 87.24,28.21 87.24,28.04 87.33,27.95 87.44,27.95 87.53,27.86 87.53,27.7 87.44,27.61 87.33,27.61 87.24,27.52 87.24,27.36 87.33,27.27 87.44,27.27 87.53,27.18 87.53,27.01 87.44,26.92 87.33,26.92 87.24,26.83 87.24,26.67 87.33,26.58 87.44,26.58 87.53,26.49 87.53,25.02 87.44,24.93 87.01,24.93 86.93,24.84 86.93,24.69 87.03,24.59 87.44,24.59 87.53,24.5 87.53,24.33 87.44,24.24 86.91,24.24 86.82,24.16 86.82,24.01 86.93,23.9 87.44,23.9 87.53,23.81 87.53,23.36 87.43,23.26 86.19,23.26 85.68,23.76 85.29,23.76 85.16,23.89 85.16,24.46 85.07,24.55 83.79,24.55 83.36,24.11 80.96,24.11 80.56,23.72 78.23,23.72 78.11,23.84 78.11,25.55 78.02,25.64 77.86,25.64 77.77,25.55 77.77,23.85 77.67,23.75 77.52,23.75 77.43,23.84 77.43,25.55 77.34,25.64 77.17,25.64 77.08,25.55 77.08,23.85 76.98,23.75 76.83,23.75 76.74,23.84 76.74,25.55 76.65,25.64 76.49,25.64 76.4,25.55 76.4,23.85 76.3,23.75 74.68,23.75 74.59,23.66 v1(74.59,23.33)
DDR4_COMP_CH0_DQ70: length 65.5
  L12_SIG4 w0.089: v1(107.56,46.51) 107.16,47.2 107.16,47.2 arc(106.99,47.37) 106.76,47.43 arc(106.53,47.49) 106.36,47.65 106.36,47.66 arc(106.19,47.83) 105.96,47.89 105.56,47.66 105.56,47.65 arc(105.39,47.49) 105.17,47.43 arc(104.94,47.49) 104.77,47.65 104.77,47.66 arc(104.6,47.82) 104.38,47.89 104.36,47.89 arc(104.14,47.95) 103.97,48.12 arc(103.8,48.28) 103.58,48.35 103.57,48.35 arc(103.34,48.29) 103.17,48.12 103.17,48.11 arc(103,47.95) 102.77,47.89 102.76,47.89 arc(102.54,47.82) 102.38,47.66 arc(102.21,47.49) 101.98,47.43 arc(101.75,47.37) 101.58,47.2 101.58,47.2 arc(101.41,47.03) 101.18,46.97 101.18,46.97 arc(100.95,46.9) 100.78,46.74 arc(100.62,46.57) 100.39,46.51 100.38,46.51 arc(100.15,46.44) 99.99,46.28 99.98,46.27 arc(99.82,46.11) 99.59,46.05 99.31,46.05 98.8,45.53 98.8,45.48 98.58,45.26 98.53,45.26 98.23,44.96 97.99,44.89 97.98,44.88 arc(97.8,44.7) 97.56,44.64 97.55,44.64 arc(97.3,44.71) 97.12,44.89 arc(96.94,45.07) 96.69,45.14 96.69,45.14 arc(96.44,45.07) 96.26,44.89 96.25,44.88 arc(96.07,44.7) 95.82,44.64 95.82,44.64 arc(95.57,44.57) 95.39,44.39 arc(95.21,44.21) 94.96,44.14 94.96,44.14 arc(94.71,44.07) 94.53,43.89 94.52,43.89 arc(94.34,43.7) 94.09,43.64 94.08,43.64 arc(93.84,43.57) 93.66,43.39 arc(93.48,43.2) 93.23,43.14 93.22,43.14 arc(92.97,43.07) 92.79,42.89 arc(92.61,42.71) 92.37,42.64 92.35,42.64 arc(92.11,42.57) 91.93,42.39 arc(91.75,42.21) 91.5,42.14 91.49,42.14 arc(91.25,42.07) 91.06,41.89 91.05,41.88 arc(90.87,41.7) 90.63,41.64 arc(90.38,41.57) 90.2,41.39 90.19,41.39 arc(90.16,41.33) 90.11,41.28 90.11,41.01 87.46,38.36 87.46,36.5 83.51,32.55 78.04,32.55 76.53,31.04 76.09,31.04 74.9,32.23 74.34,32.23 74.25,32.14 74.25,32.06 74.17,31.98 74,31.98 73.91,32.06 73.91,32.14 73.82,32.23 73.66,32.23 73.57,32.14 73.57,32.06 73.48,31.98 73.31,31.98 73.23,32.06 73.23,32.19 73.1,32.32 72.73,32.32 72.39,31.98 70.22,31.98 69.76,32.44 68.83,32.44 67.76,31.37 67.76,21.25 67.85,21.16 68.46,21.16 68.6,21.3 68.6,21.87 68.68,21.95 68.68,22.07 68.77,22.16 70.5,22.16 70.59,22.25 v1(70.59,22.53)
DDR4_COMP_CH0_DQ71: length 66.7
  L12_SIG4 w0.089: v1(108.35,45.13) 108.13,44.82 107.95,44.52 107.95,43.98 arc(108.02,43.75) 107.96,43.52 107.95,43.52 arc(107.89,43.29) 107.95,43.06 arc(108.02,42.83) 107.96,42.6 107.95,42.59 arc(107.78,42.43) 107.56,42.37 arc(107.33,42.31) 107.16,42.15 107.15,42.12 arc(106.98,41.96) 106.76,41.91 arc(106.53,41.85) 106.36,41.68 106.36,41.67 arc(106.19,41.51) 105.96,41.45 105.96,41.45 arc(105.73,41.38) 105.56,41.22 arc(105.4,41.05) 105.17,40.99 105.16,40.99 arc(104.93,40.92) 104.77,40.76 arc(104.6,40.59) 104.37,40.53 104.36,40.53 arc(104.13,40.46) 103.97,40.3 arc(103.91,40.07) 103.97,39.84 103.97,39.83 arc(104.03,39.6) 103.97,39.38 arc(103.8,39.21) 103.58,39.15 103.57,39.15 arc(103.34,39.09) 103.17,38.92 103.17,38.91 arc(103.11,38.68) 103.17,38.46 103.18,38.45 arc(103.23,38.22) 103.17,38 arc(103.13,37.89) 103.11,37.77 102.65,37.31 101.16,37.31 100.33,36.48 98.48,36.48 98.04,36.03 98.04,35.91 98.35,35.6 98.35,35.47 98.23,35.36 98.11,35.36 97.8,35.67 97.67,35.67 97.56,35.55 97.56,35.42 97.99,34.98 97.99,34.86 97.88,34.74 97.75,34.74 97.31,35.18 97.19,35.18 96.77,34.77 94.52,34.77 94.43,34.68 94.43,34.5 94.35,34.41 94.18,34.41 94.09,34.5 94.09,34.68 94,34.77 93.84,34.77 93.75,34.68 93.75,34.5 93.66,34.41 93.49,34.41 93.41,34.5 93.41,34.68 93.32,34.77 93.15,34.77 93.06,34.68 93.06,34.5 92.97,34.41 92.81,34.41 92.72,34.5 92.72,34.68 92.63,34.77 91.99,34.77 87.88,30.65 87.88,22.45 87.7,22.27 87.22,22.27 87.07,22.42 87.07,22.83 86.98,22.92 86.82,22.92 86.73,22.83 86.73,22.42 86.64,22.33 86.47,22.33 86.39,22.42 86.39,22.83 86.3,22.92 86.04,22.92 85.99,22.97 85.74,22.97 85.73,22.96 85.42,22.96 85.42,22.97 84.94,22.97 84.93,22.96 84.62,22.96 84.62,22.97 84.47,22.97 84.38,23.06 84.38,23.66 84.29,23.75 83.45,23.75 83.36,23.66 83.36,22.31 83.27,22.22 82.83,22.22 82.74,22.31 82.74,23.66 82.66,23.75 81.77,23.75 81.68,23.66 81.68,22.8 81.59,22.71 81.15,22.71 80.95,22.91 78.88,22.91 78.77,22.81 78.77,22.57 78.71,22.51 78.08,22.51 77.99,22.6 77.99,23.31 77.9,23.4 77.73,23.4 77.64,23.31 77.64,22.6 77.56,22.51 77.39,22.51 77.3,22.6 77.3,23.31 77.21,23.4 77.05,23.4 76.96,23.31 76.96,22.6 76.87,22.51 76.7,22.51 76.62,22.6 76.62,23.31 76.53,23.4 76.36,23.4 76.27,23.31 76.27,22.6 76.16,22.49 75.86,22.49 75.77,22.58 75.77,22.82 75.68,22.91 74.19,22.91 73.81,22.53 v1(73.79,22.53)
DDR4_COMP_CH0_DQS_N0: length 40
  L12_SIG4 w0.076: 109.33,37.42 109.33,37.44 109.33,37.45 109.33,37.53 arc(109.34,37.63) 109.34,37.72 arc(109.36,37.87) 109.44,38 arc(109.51,38.18) 109.48,38.38 arc(109.42,38.69) 109.48,38.99 arc(109.52,39.14) 109.49,39.29 arc(109.49,39.3) 109.48,39.31 arc(109.47,39.33) 109.46,39.36 arc(109.4,39.64) 109.5,39.92 arc(109.51,39.95) 109.53,39.99 arc(109.53,40.04) 109.54,40.08 arc(109.54,40.12) 109.53,40.16 109.51,40.19 arc(109.46,40.22) 109.4,40.21 v1(109.15,40.07)
  L12_SIG4 w0.089: 109.33,37.42 109.33,37.17 arc(109.29,37) 109.2,36.85 109.19,36.85 107.72,35.37 104.12,35.37 98.67,29.92 91.54,29.92 91.34,29.72 91.34,29.16 91.55,28.95 93.04,28.95 93.13,28.86 93.13,28.7 93.04,28.61 91.57,28.61 91.37,28.41 91.37,28.09 91.57,27.89 93.04,27.89 93.13,27.8 93.13,27.63 93.04,27.54 91.57,27.54 91.37,27.34 91.37,26.37 91.64,26.1 92.94,26.1 93.03,26.01 93.03,25 92.67,24.63 92.12,24.63 92.03,24.72 92.03,24.83 91.94,24.92 91.76,24.92 91.68,24.83 91.68,24.72 91.59,24.63 91.24,24.63 v1(90.94,24.94)
DDR4_COMP_CH0_DQS_N1: length 43.5
  TOP w0.149: U1.A7 v1(93.74,29.34)
  L07_SIG3 w0.076: v1(105.96,42.83) 106.22,42.68 arc(106.25,42.63) 106.25,42.58 106.25,42.57 arc(106.23,42.54) 106.21,42.51 arc(106.17,42.32) 106.24,42.15 arc(106.33,41.95) 106.29,41.73 arc(106.2,41.43) 106.26,41.12 arc(106.28,41.06) 106.29,40.99 arc(106.28,40.89) 106.24,40.81 arc(106.24,40.8) 106.23,40.8 arc(106.2,40.74) 106.18,40.67 106.17,40.61 arc(106.17,40.45) 106.24,40.3 arc(106.31,40.19) 106.33,40.07 106.33,40.03 arc(106.32,39.96) 106.29,39.89 arc(106.23,39.75) 106.21,39.61 arc(106.23,39.47) 106.28,39.34 arc(106.3,39.3) 106.31,39.26 arc(106.32,39.25) 106.32,39.24 arc(106.33,39.16) 106.32,39.08 arc(106.32,39.03) 106.31,38.98 arc(106.31,38.93) 106.29,38.89 arc(106.25,38.71) 106.28,38.52 arc(106.29,38.47) 106.3,38.42 arc(106.31,38.37) 106.32,38.32 arc(106.33,38.18) 106.28,38.05 arc(106.22,37.84) 106.23,37.63 106.24,37.61 arc(106.26,37.46) 106.27,37.31 arc(106.24,37.18) 106.17,37.07 106.14,37.04 106.02,36.9 106,36.87 105.97,36.84 105.96,36.84 105.95,36.83
  L07_SIG3 w0.089: 105.95,36.83 103.4,34.29 arc(103.07,34.07) 102.69,33.99 99.54,33.99 99.18,34.35 92.01,34.35 91.81,34.15 91.81,33.32 92.05,33.07 94.56,33.07 94.67,32.96 94.67,32.65 94.54,32.52 91.92,32.52 91.74,32.34 91.74,30.14 91.95,29.92 93.56,29.92 93.77,30.13 93.77,31.59 93.91,31.72 94.52,31.72 94.6,31.63 94.6,30.78 94.8,30.58 95.92,30.58 96.57,29.93 96.57,29.69 96.38,29.5 95.73,29.5 95.63,29.6 95.63,29.65 95.53,29.75 95.38,29.75 95.28,29.65 95.28,29.6 95.18,29.5 94.7,29.5 94.23,29.03 94.04,29.03 v1(93.74,29.34)
DDR4_COMP_CH0_DQS_N2: length 31.3
  TOP w0.149: U2.F3 111.56,24.64 111.98,24.64 v1(112.2,24.86)
  L14_SIG5 w0.076: v1(115.52,44.67) 115.53,44.67 115.71,44.82 arc(115.74,44.86) 115.74,44.91 arc(115.73,44.96) 115.69,45 arc(115.66,45.01) 115.62,45.03 arc(115.53,45.04) 115.43,45.02 115.41,45.02 arc(115.31,44.97) 115.23,44.89 arc(115.18,44.78) 115.16,44.67 arc(115.16,44.61) 115.18,44.55 arc(115.19,44.51) 115.21,44.47 arc(115.25,44.4) 115.27,44.33 arc(115.28,44.28) 115.29,44.24 arc(115.29,44.18) 115.28,44.13 arc(115.28,44.13) 115.28,44.12 arc(115.26,44.03) 115.21,43.95 arc(115.21,43.95) 115.21,43.94 arc(115.18,43.89) 115.17,43.83 arc(115.16,43.69) 115.21,43.55 arc(115.26,43.45) 115.27,43.34 115.27,43.22 arc(115.26,43.12) 115.21,43.03 arc(115.16,42.83) 115.21,42.63 arc(115.26,42.53) 115.27,42.43 115.27,42.4 arc(115.27,42.37) 115.27,42.35 arc(115.27,42.33) 115.27,42.3 arc(115.26,42.2) 115.21,42.11 arc(115.16,41.91) 115.21,41.71 arc(115.26,41.61) 115.27,41.51 115.27,41.47 arc(115.27,41.45) 115.27,41.42 115.27,41.38 arc(115.26,41.24) 115.22,41.11 arc(115.22,41.11) 115.21,41.1 arc(115.19,40.98) 115.22,40.86 arc(115.26,40.73) 115.27,40.59 115.27,40.55 arc(115.27,40.53) 115.27,40.5 115.27,40.46 arc(115.26,40.36) 115.21,40.27 arc(115.16,40.07) 115.21,39.87 arc(115.26,39.77) 115.27,39.67 115.27,39.63 arc(115.27,39.61) 115.27,39.58 115.27,39.54 arc(115.26,39.44) 115.21,39.35 arc(115.16,39.15) 115.21,38.95 arc(115.26,38.85) 115.27,38.75 115.27,38.62 arc(115.26,38.52) 115.21,38.43 arc(115.16,38.23) 115.21,38.03 arc(115.26,37.93) 115.27,37.83 115.27,37.8 arc(115.27,37.77) 115.27,37.74 115.27,37.06 115.27,37.06 115.27,37.04
  L14_SIG5 w0.081: v1(112.2,24.86) 112.2,24.58 112.12,24.5 111.7,24.5 111.62,24.58 111.62,25.12 111.84,25.33 111.84,25.58 111.92,25.66 112.08,25.66 112.17,25.74 112.17,25.91 112.08,26 111.92,26 111.84,26.08 111.84,29.2 111.92,29.28 112.83,29.28 113.01,29.47 113.01,29.79 112.83,29.98 111.92,29.98 111.84,30.06 111.84,30.23 111.92,30.31 112.93,30.31 113.12,30.5 113.12,30.83 112.93,31.02 111.92,31.02 111.84,31.1 111.84,31.64 112.1,31.9 114.49,31.9 115.27,32.69 115.27,37.04
DDR4_COMP_CH0_DQS_N3: length 45.3
  TOP w0.149: U2.A7 v1(114.06,29.34)
  L12_SIG4 w0.076: v1(110.74,44.67) 111,44.81 arc(111.06,44.82) 111.1,44.79 111.15,44.7 111.22,44.63 arc(111.33,44.57) 111.46,44.57 arc(111.83,44.43) 111.87,44.04 arc(111.86,44.02) 111.85,44 111.82,43.96 111.82,43.95 arc(111.82,43.95) 111.82,43.95 arc(111.78,43.82) 111.78,43.69 arc(111.79,43.66) 111.8,43.62 arc(111.8,43.61) 111.81,43.59 arc(111.83,43.55) 111.85,43.51 arc(112.04,43.29) 112.32,43.2 arc(112.55,43.14) 112.72,42.99 arc(112.92,42.83) 113.16,42.78 arc(113.21,42.78) 113.25,42.76 113.35,42.7 arc(113.4,42.66) 113.43,42.61 arc(113.5,42.49) 113.6,42.39 arc(113.72,42.32) 113.86,42.28 arc(113.92,42.28) 113.98,42.28 arc(114.04,42.28) 114.09,42.26 114.16,42.21 arc(114.2,42.18) 114.23,42.13 arc(114.31,42.02) 114.41,41.93 arc(114.57,41.84) 114.76,41.82 arc(114.79,41.82) 114.83,41.81 arc(114.85,41.8) 114.86,41.79 114.92,41.76 114.92,41.76 arc(114.98,41.72) 115.02,41.67 115.02,41.67 arc(115.02,41.66) 115.03,41.66 arc(115.03,41.66) 115.03,41.66 arc(115.03,41.65) 115.04,41.65 arc(115.05,41.64) 115.05,41.62 115.11,41.49 arc(115.13,41.37) 115.09,41.25 arc(115.02,41.02) 115.06,40.78 arc(115.1,40.62) 115.09,40.45 arc(115.09,40.43) 115.08,40.4 arc(115.07,40.39) 115.06,40.38 arc(115.05,40.34) 115.02,40.31 arc(115,40.26) 114.99,40.2 114.99,40.18 arc(114.99,39.96) 115.07,39.76 arc(115.12,39.61) 115.07,39.46 arc(114.98,39.19) 115.03,38.92 arc(115.08,38.69) 115.03,38.46 arc(114.98,38.18) 115.08,37.91 arc(115.13,37.78) 115.11,37.65 arc(115.07,37.57) 115.01,37.5 arc(114.92,37.35) 114.88,37.18 114.88,37.06 114.88,37.06 114.88,37.04
  L12_SIG4 w0.089: v1(114.06,29.34) 114.36,29.03 114.49,29.03 114.86,29.4 114.86,29.69 114.8,29.75 114.7,29.75 114.61,29.84 114.61,30.01 114.7,30.09 114.8,30.09 114.86,30.15 114.86,30.35 114.77,30.44 114.38,30.44 113.51,29.57 113.51,28.3 113.11,27.9 112.07,27.9 111.75,28.22 111.75,29.04 111.48,29.31 109.49,29.31 108.26,28.08 108.26,26.57 107.82,26.13 106.73,26.13 106.28,26.58 106.28,29.2 105.33,30.14 105.33,31.01 106.01,31.69 107.08,31.69 107.34,31.69 107.76,32.11 110.95,32.11 111.51,32.67 111.51,32.95 114.88,36.31 114.88,37.04
DDR4_COMP_CH0_DQS_N4: length 66.1
  TOP w0.149: U3.F3 v1(81.18,24.54)
  L14_SIG5 w0.076: 108.93,37.04 108.93,37.06 108.93,37.06 108.93,37.46 arc(108.93,37.61) 108.92,37.77 arc(108.9,37.9) 108.85,38.02 arc(108.78,38.2) 108.82,38.4 arc(108.86,38.52) 108.87,38.65 arc(108.86,38.76) 108.85,38.87 arc(108.85,38.88) 108.85,38.88 arc(108.83,38.94) 108.81,38.99 arc(108.78,39.14) 108.81,39.3 arc(108.82,39.31) 108.83,39.33 arc(108.83,39.35) 108.84,39.36 arc(108.9,39.63) 108.81,39.9 arc(108.78,39.97) 108.77,40.05 arc(108.77,40.06) 108.77,40.08 arc(108.78,40.16) 108.81,40.23 arc(108.9,40.5) 108.84,40.77 arc(108.79,40.99) 108.84,41.2 arc(108.89,41.38) 108.88,41.57 arc(108.88,41.58) 108.88,41.59 arc(108.86,41.66) 108.83,41.72 arc(108.78,41.91) 108.84,42.11 arc(108.87,42.16) 108.89,42.21 arc(108.9,42.26) 108.91,42.31 arc(108.91,42.32) 108.92,42.34 arc(108.92,42.43) 108.9,42.52 arc(108.88,42.56) 108.86,42.6 arc(108.78,42.79) 108.82,42.98 arc(108.88,43.29) 108.82,43.59 arc(108.78,43.78) 108.84,43.95 arc(108.92,44.21) 108.84,44.46 arc(108.78,44.68) 108.86,44.89 arc(108.91,44.99) 108.93,45.11 108.93,45.22 arc(108.92,45.32) 108.87,45.4 arc(108.82,45.59) 108.87,45.77 arc(108.92,45.86) 108.93,45.95 108.93,46.06 arc(108.91,46.18) 108.86,46.29 arc(108.78,46.51) 108.86,46.73 arc(108.91,46.83) 108.93,46.95 108.93,47.03 arc(108.88,47.21) 108.76,47.35 arc(108.67,47.4) 108.57,47.44 arc(108.57,47.44) 108.56,47.44 arc(108.49,47.47) 108.41,47.48 arc(108.41,47.49) 108.4,47.49 arc(108.4,47.49) 108.4,47.49 arc(108.36,47.49) 108.33,47.5 arc(108.15,47.55) 108.02,47.68 arc(107.98,47.73) 107.94,47.77 arc(107.77,47.9) 107.57,47.95 arc(107.5,47.95) 107.44,47.93 arc(107.26,47.86) 107.13,47.73 arc(106.98,47.6) 106.78,47.55 arc(106.77,47.55) 106.76,47.55 arc(106.75,47.55) 106.75,47.55
  L14_SIG5 w0.081: v1(81.18,24.54) 81.18,24.46 81.01,24.3 80.76,24.3 80.59,24.46 80.59,24.8 80.7,24.9 81.76,24.9 82.88,23.79 82.88,22.06 83.67,21.26 83.67,21.26 83.75,21.19 84.26,21.19 84.32,21.25 85.11,21.25 85.17,21.31 86.41,21.31 88.97,23.86 88.97,29.12 89.3,29.45 93.31,29.45 93.56,29.71 94.25,29.71 94.65,29.31 96.29,29.31 96.37,29.23 96.37,27.73 96.56,27.54 96.88,27.54 97.07,27.73 97.07,29.22 97.16,29.31 97.32,29.31 97.4,29.23 97.4,27.73 97.59,27.54 97.92,27.54 98.1,27.73 98.1,29.22 98.2,29.31 103.13,29.31 103.56,29.74 106.67,29.74 106.9,29.97 106.9,31.04 107.41,31.56 107.41,33.26 108.43,34.28 108.43,35.51 108.93,36.01 108.93,37.04 ; v1(105.96,47.43) 106.21,47.28 106.24,47.28 arc(106.28,47.29) 106.31,47.31 106.36,47.37 arc(106.45,47.44) 106.55,47.51 arc(106.59,47.52) 106.63,47.54 arc(106.69,47.55) 106.75,47.55
DDR4_COMP_CH0_DQS_N5: length 48.6
  TOP w0.149: U3.A7 v1(83.58,29.34)
  L14_SIG5 w0.076: 98.48,46.04 98.5,46.04 99.41,45.96 99.61,45.96 arc(99.86,46.02) 100.05,46.21 100.06,46.23 arc(100.2,46.37) 100.38,46.42 100.39,46.42 arc(100.57,46.37) 100.71,46.23 arc(100.9,46.03) 101.17,45.96 101.18,45.96 arc(101.34,45.92) 101.47,45.82 101.45,45.74 v1(101.18,45.59)
  L14_SIG5 w0.081: v1(83.58,29.34) 83.27,29.03 82.71,29.03 82.63,29.11 82.63,29.52 82.55,29.6 82.38,29.6 82.29,29.52 82.29,29.11 82.21,29.03 81.85,29.03 81.72,29.16 81.72,30.8 81.37,31.15 79.98,31.15 79.47,31.65 79.47,31.92 77.62,33.77 77.62,38.3 80.88,41.56 81.69,41.56 81.77,41.48 81.77,41.11 81.95,40.93 82.3,40.93 82.47,41.11 82.47,41.48 82.55,41.56 82.73,41.56 82.81,41.48 82.81,41.11 82.99,40.93 83.32,40.93 83.51,41.12 83.51,41.48 83.59,41.56 83.76,41.56 83.84,41.48 83.84,41.18 84.03,40.99 84.35,40.99 84.55,41.19 84.55,41.48 84.63,41.56 84.8,41.56 84.88,41.48 84.88,41.31 85.07,41.12 85.39,41.12 85.58,41.31 85.58,41.48 85.66,41.56 86.28,41.56 86.37,41.48 86.37,41.38 86.55,41.19 86.88,41.19 87.07,41.38 87.07,41.48 87.15,41.56 87.79,41.56 88.05,41.81 88.05,43.79 88.3,44.05 89.77,44.05 arc(89.97,43.99) 90.11,43.84 90.13,43.82 90.13,43.82 arc(90.34,43.62) 90.62,43.55 90.69,43.55 92.36,43.55 arc(92.51,43.58) 92.64,43.66 92.9,43.92 arc(92.94,43.95) 93,43.96 93.1,43.96 arc(93.31,44) 93.48,44.12 93.84,44.48 arc(93.87,44.5) 93.9,44.5 94,44.5 arc(94.14,44.53) 94.26,44.61 94.31,44.66 arc(94.33,44.68) 94.34,44.69 arc(94.46,44.77) 94.54,44.89 arc(94.55,44.9) 94.57,44.92 94.61,44.97 arc(94.66,45) 94.72,45.01 94.94,45.01 arc(95.05,45.03) 95.15,45.09 95.46,45.41 arc(95.52,45.44) 95.58,45.46 arc(95.73,45.47) 95.88,45.5 arc(95.95,45.54) 96.02,45.59 96.43,46.01 arc(96.63,46.09) 96.82,46.01 arc(96.85,45.98) 96.88,45.95 arc(96.95,45.9) 97.01,45.83 arc(97.06,45.76) 97.14,45.71 97.33,45.59 arc(97.42,45.56) 97.5,45.55 97.56,45.55 arc(97.84,45.62) 98.05,45.81 arc(98.07,45.84) 98.1,45.87 arc(98.24,45.98) 98.4,46.04 arc(98.44,46.04) 98.48,46.04
DDR4_COMP_CH0_DQS_N6: length 33.3
  L07_SIG3 w0.076: v1(110.74,42.83) 111,42.68 arc(111.03,42.63) 111.03,42.58 111.03,42.57 arc(111.01,42.54) 110.99,42.51 arc(110.95,42.32) 111.02,42.15 arc(111.11,41.95) 111.07,41.73 arc(110.98,41.43) 111.04,41.12 arc(111.07,41.06) 111.07,40.99 arc(111.06,40.89) 111.02,40.81 arc(111.02,40.8) 111.01,40.8 arc(110.98,40.74) 110.96,40.67 110.95,40.61 arc(110.95,40.45) 111.03,40.3 arc(111.09,40.19) 111.11,40.07 111.11,40.03 arc(111.1,39.96) 111.07,39.89 arc(111.01,39.75) 110.99,39.61 arc(111.01,39.47) 111.06,39.34 arc(111.08,39.3) 111.09,39.26 arc(111.1,39.25) 111.1,39.24 arc(111.11,39.16) 111.11,39.08 arc(111.1,39.03) 111.09,38.98 arc(111.09,38.93) 111.08,38.89 arc(111.03,38.71) 111.06,38.52 arc(111.07,38.47) 111.08,38.42 arc(111.09,38.37) 111.1,38.32 arc(111.11,38.18) 111.06,38.05 arc(111,37.84) 111.01,37.63 111.01,37.63 arc(110.98,37.55) 110.97,37.47 110.97,37.12 110.97,37.11 110.97,37.04
  L07_SIG3 w0.089: 110.97,37.04 110.97,35.94 110.96,35.89 110.52,35.06 109.78,34.32 107.89,34.32 107.22,33.64 107.22,33.63 107.22,33.1 107.22,32.76 106.02,31.57 105.14,31.57 104.4,30.82 104.4,29.97 104.31,29.88 104.14,29.88 104.05,29.97 104.05,30.42 103.84,30.63 103.82,30.63 102.98,30.63 102.77,30.42 102.77,29.85 102.68,29.76 102.41,29.76 102.32,29.85 102.32,30.43 102.12,30.63 101.03,30.63 100.81,30.41 100.81,29.79 101.63,28.97 103.22,28.97 103.31,28.88 103.31,28.44 103.22,28.35 102.02,28.35 101.82,28.15 101.82,26.4 101.73,26.31 101.69,26.31 101.6,26.22 101.6,26.06 101.69,25.97 101.73,25.97 101.82,25.88 101.82,24.73 101.73,24.65 101.39,24.65 v1(101.1,24.94)
DDR4_COMP_CH0_DQS_N7: length 40.6
  TOP w0.149: U4.A7 v1(103.9,29.34)
  L05_SIG2 w0.076: 116.06,36.67 115.83,36.9 115.83,37.35 arc(115.82,37.37) 115.82,37.38 arc(115.79,37.5) 115.78,37.62 arc(115.78,37.66) 115.78,37.7 arc(115.78,37.86) 115.83,38.01 arc(115.84,38.03) 115.85,38.05 arc(115.85,38.06) 115.86,38.07 arc(115.89,38.18) 115.89,38.3 arc(115.88,38.31) 115.88,38.32 arc(115.87,38.38) 115.85,38.45 arc(115.8,38.72) 115.86,39 arc(115.89,39.17) 115.84,39.34 arc(115.77,39.52) 115.78,39.7 arc(115.78,39.71) 115.79,39.72 arc(115.79,39.75) 115.8,39.78 arc(115.81,39.81) 115.83,39.85 arc(115.84,39.87) 115.85,39.9 arc(115.86,39.91) 115.86,39.92 arc(115.89,40.02) 115.89,40.13 arc(115.89,40.14) 115.88,40.16 arc(115.87,40.2) 115.85,40.24 arc(115.78,40.47) 115.8,40.7 arc(115.82,40.75) 115.82,40.81 arc(115.83,40.85) 115.84,40.89 arc(115.85,41.02) 115.81,41.15 arc(115.76,41.27) 115.75,41.4 115.75,41.47 arc(115.76,41.58) 115.82,41.69 arc(115.89,41.89) 115.84,42.1 arc(115.81,42.16) 115.79,42.22 arc(115.77,42.36) 115.78,42.51 arc(115.79,42.54) 115.81,42.58 arc(115.82,42.64) 115.78,42.69
  L05_SIG2 w0.081: v1(103.9,29.34) 103.9,29.22 104.18,28.94 104.39,28.94 104.56,29.12 104.56,29.31 104.75,29.5 104.94,29.5 105.09,29.65 105.27,29.65 105.42,29.5 105.61,29.5 105.76,29.65 105.95,29.65 106.09,29.5 106.31,29.5 106.5,29.31 106.5,28.45 106.58,28.37 106.75,28.37 106.83,28.45 106.83,29.31 107.02,29.5 107.34,29.5 107.53,29.31 107.53,28.45 107.61,28.37 107.79,28.37 107.87,28.45 107.87,29.31 108.06,29.5 108.5,29.5 108.89,29.89 111.8,29.89 111.99,29.7 111.99,27.65 112.07,27.57 112.25,27.57 112.33,27.65 112.33,29.69 112.53,29.89 112.86,29.89 113.07,29.68 113.07,27.65 113.15,27.57 113.32,27.57 113.4,27.65 113.4,29.7 113.59,29.89 115.45,29.89 115.62,30.06 115.62,34.16 115.81,34.35 115.99,34.35 116.07,34.43 116.07,34.61 115.99,34.69 115.81,34.69 115.62,34.88 115.62,35.2 115.81,35.39 115.99,35.39 116.07,35.47 116.07,35.64 115.99,35.72 115.81,35.72 115.62,35.91 115.62,36.24 115.81,36.42 115.98,36.42 116.06,36.51 116.06,36.67 ; 115.78,42.69 v1(115.52,42.83)
DDR4_COMP_CH0_DQS_N8: length 67.5
  TOP w0.149: v1(71.16,24.74) 70.96,24.93 U5.F3
  L12_SIG4 w0.076: 91.49,37.09 91.5,37.09 91.51,37.1 91.59,37.1 arc(92.14,37.21) 92.61,37.54 arc(92.65,37.55) 92.69,37.57 arc(92.83,37.65) 92.93,37.78 arc(93.1,37.94) 93.33,37.95 arc(93.49,37.93) 93.65,37.97 arc(93.65,37.97) 93.65,37.97 arc(94.53,38.45) 95.36,39.01 arc(95.45,39.11) 95.51,39.23 arc(95.61,39.39) 95.79,39.46 arc(95.92,39.5) 96.03,39.57 arc(96.19,39.73) 96.36,39.89 arc(96.45,39.97) 96.54,40.06 arc(96.61,40.11) 96.7,40.13 arc(96.94,40.19) 97.12,40.36 arc(97.3,40.53) 97.55,40.59 arc(97.83,40.66) 98.03,40.87 arc(98.21,41.05) 98.45,41.13 arc(98.79,41.28) 98.93,41.63 arc(98.97,41.69) 99.04,41.69 arc(99.11,41.66) 99.18,41.64 arc(99.63,41.77) 99.79,42.21 arc(99.81,42.36) 99.92,42.47 arc(100.17,42.6) 100.43,42.73 arc(100.46,42.74) 100.5,42.75 arc(100.61,42.79) 100.72,42.85 arc(100.75,42.87) 100.78,42.89 arc(101.01,42.99) 101.24,43.09 arc(101.31,43.12) 101.38,43.15 arc(101.53,43.25) 101.63,43.41 arc(101.75,43.58) 101.95,43.65 arc(102.24,43.75) 102.47,43.96 arc(102.62,44.08) 102.81,44.11 arc(102.98,44.13) 103.14,44.21 arc(103.15,44.22) 103.16,44.23 arc(103.17,44.24) 103.18,44.25 arc(103.24,44.3) 103.28,44.37 arc(103.39,44.49) 103.55,44.54 arc(103.85,44.63) 104.08,44.85 arc(104.25,44.99) 104.47,44.99 arc(104.48,44.99) 104.5,44.99 arc(104.56,44.98) 104.63,45.01 arc(104.66,45.04) 104.68,45.08 arc(104.71,45.14) 104.74,45.19 arc(104.89,45.39) 105.11,45.48 arc(105.15,45.49) 105.19,45.49 arc(105.2,45.49) 105.2,45.49 arc(105.24,45.5) 105.27,45.5 arc(105.41,45.46) 105.51,45.36 arc(105.73,45.14) 106.04,45.08 arc(106.12,45.07) 106.19,45.01 arc(106.2,45) 106.2,44.99 arc(106.2,44.99) 106.21,44.98 arc(106.21,44.98) 106.21,44.98 106.25,44.92 arc(106.25,44.86) 106.22,44.81 v1(105.96,44.67)
  L12_SIG4 w0.089: v1(71.16,24.74) 70.87,24.45 70.49,24.45 70.4,24.54 70.4,25.05 70.5,25.15 71.13,25.15 71.33,25.35 71.33,26 71.42,26.09 71.66,26.09 71.75,26.18 71.75,26.34 71.66,26.43 71.42,26.43 71.33,26.52 71.33,28.72 72.01,29.41 75.98,29.41 76.22,29.17 76.22,27.27 76.48,27.01 77.72,27.01 78.1,27.39 78.1,28.47 77.9,28.67 77.15,28.67 77.06,28.76 77.06,28.93 77.15,29.02 77.9,29.02 78.1,29.22 78.1,30.22 78.74,30.86 81.73,30.86 81.82,30.77 81.82,29.76 82.02,29.56 82.83,29.56 82.92,29.47 82.92,29.31 82.83,29.22 82.02,29.22 81.82,29.02 81.82,28.64 82.02,28.44 82.92,28.44 83.01,28.35 83.01,28.14 82.78,27.91 82.02,27.91 81.82,27.71 81.82,27.27 82.26,26.83 83.29,26.83 83.6,27.14 83.6,27.49 83.82,27.71 84.11,27.71 84.29,27.9 84.29,29.07 84.75,29.53 84.75,29.81 84.58,29.99 84.58,30.11 84.69,30.23 84.82,30.23 84.99,30.06 85.28,30.06 85.98,30.75 85.98,31.77 91.3,37.09 91.49,37.09
DDR4_COMP_CH0_DQS_P0: length 40
  L12_SIG4 w0.076: v1(109.95,40.53) 109.69,40.38 arc(109.65,40.33) 109.66,40.28 109.68,40.24 arc(109.71,40.15) 109.72,40.05 arc(109.71,40.01) 109.7,39.97 arc(109.68,39.89) 109.64,39.81 arc(109.58,39.63) 109.62,39.44 arc(109.63,39.4) 109.65,39.37 arc(109.65,39.36) 109.65,39.35 arc(109.69,39.13) 109.64,38.92 arc(109.59,38.69) 109.64,38.46 arc(109.69,38.16) 109.57,37.88 arc(109.53,37.81) 109.51,37.72 arc(109.51,37.63) 109.51,37.53 109.51,37.45 109.52,37.44 109.52,37.42
  L12_SIG4 w0.089: v1(90.94,24.14) 91.24,24.44 92.79,24.44 93.22,24.87 93.22,26.09 93.02,26.29 91.72,26.29 91.56,26.45 91.56,27.26 91.65,27.35 93.12,27.35 93.32,27.55 93.32,27.88 93.12,28.08 91.65,28.08 91.56,28.17 91.56,28.33 91.65,28.42 93.12,28.42 93.32,28.62 93.32,28.94 93.12,29.14 91.63,29.14 91.53,29.24 91.53,29.64 91.62,29.73 98.75,29.73 104.2,35.18 107.8,35.18 109.33,36.72 arc(109.47,36.92) 109.52,37.17 109.52,37.42
DDR4_COMP_CH0_DQS_P1: length 43.4
  TOP w0.149: U1.B7 v1(93.74,28.54)
  L07_SIG3 w0.076: 106.08,36.7 106.21,36.85 106.29,36.95 arc(106.4,37.11) 106.44,37.3 arc(106.44,37.48) 106.41,37.65 106.4,37.67 arc(106.39,37.82) 106.44,37.96 arc(106.5,38.16) 106.49,38.36 arc(106.48,38.4) 106.48,38.44 arc(106.46,38.51) 106.45,38.58 arc(106.43,38.7) 106.46,38.82 arc(106.48,38.89) 106.49,38.97 arc(106.49,39.01) 106.5,39.05 arc(106.51,39.17) 106.49,39.29 arc(106.49,39.29) 106.49,39.29 arc(106.47,39.36) 106.44,39.42 arc(106.4,39.51) 106.39,39.61 arc(106.4,39.71) 106.44,39.8 arc(106.49,39.91) 106.51,40.03 106.51,40.07 arc(106.48,40.25) 106.38,40.42 arc(106.34,40.49) 106.34,40.57 106.35,40.64 arc(106.36,40.67) 106.38,40.7 arc(106.38,40.71) 106.39,40.72 arc(106.45,40.85) 106.47,40.99 arc(106.46,41.09) 106.42,41.2 arc(106.38,41.42) 106.44,41.65 arc(106.5,41.96) 106.38,42.26 arc(106.34,42.34) 106.36,42.42 arc(106.45,42.49) 106.57,42.48 v1(106.76,42.37)
  L07_SIG3 w0.089: v1(93.74,28.54) 94.04,28.84 94.31,28.84 94.78,29.31 96.46,29.31 96.76,29.61 96.76,30.01 95.99,30.77 94.88,30.77 94.79,30.86 94.79,31.71 94.59,31.91 93.83,31.91 93.58,31.67 93.58,30.21 93.49,30.11 92.03,30.11 91.93,30.22 91.93,32.26 92,32.33 94.62,32.33 94.86,32.57 94.86,33.04 94.64,33.26 92.13,33.26 92,33.4 92,34.07 92.08,34.16 99.1,34.16 99.43,33.83 arc(99.47,33.81) 99.51,33.8 102.69,33.8 arc(103.15,33.89) 103.54,34.15 106.08,36.7
DDR4_COMP_CH0_DQS_P2: length 31.5
  TOP w0.149: v1(112.2,24.06) 111.9,24.36 111.48,24.36 U2.G3
  L14_SIG5 w0.076: v1(116.32,45.13) 115.97,45.08 115.92,45.09 arc(115.85,45.11) 115.78,45.15 arc(115.75,45.17) 115.7,45.19 arc(115.69,45.19) 115.67,45.2 arc(115.52,45.22) 115.38,45.19 115.35,45.18 arc(115.21,45.11) 115.09,45 arc(115.01,44.84) 114.98,44.67 arc(114.99,44.58) 115.01,44.49 arc(115.03,44.43) 115.06,44.37 arc(115.09,44.33) 115.1,44.28 arc(115.11,44.26) 115.11,44.23 arc(115.11,44.19) 115.11,44.16 arc(115.11,44.15) 115.11,44.15 arc(115.09,44.09) 115.06,44.04 arc(115.02,43.96) 114.99,43.87 arc(114.99,43.66) 115.06,43.46 arc(115.09,43.4) 115.09,43.34 115.09,43.22 arc(115.09,43.17) 115.06,43.12 arc(114.98,42.83) 115.06,42.53 arc(115.09,42.48) 115.09,42.43 115.09,42.4 arc(115.1,42.37) 115.1,42.35 arc(115.09,42.33) 115.09,42.3 arc(115.09,42.25) 115.06,42.2 arc(114.98,41.91) 115.06,41.61 arc(115.09,41.56) 115.09,41.51 115.09,41.47 arc(115.1,41.45) 115.09,41.43 115.09,41.38 arc(115.08,41.28) 115.06,41.18 arc(115.05,41.17) 115.05,41.16 arc(115.02,40.97) 115.05,40.79 arc(115.08,40.69) 115.09,40.59 115.09,40.55 arc(115.1,40.53) 115.09,40.51 115.09,40.46 arc(115.09,40.41) 115.06,40.36 arc(114.98,40.07) 115.06,39.77 arc(115.09,39.72) 115.09,39.67 115.09,39.63 arc(115.1,39.61) 115.09,39.59 115.09,39.54 arc(115.09,39.49) 115.06,39.44 arc(114.98,39.15) 115.06,38.85 arc(115.09,38.8) 115.09,38.75 115.09,38.62 arc(115.09,38.57) 115.06,38.52 arc(114.98,38.23) 115.06,37.93 arc(115.09,37.88) 115.09,37.83 115.09,37.79 arc(115.1,37.77) 115.09,37.74 115.09,37.06 115.09,37.06 115.09,37.04
  L14_SIG5 w0.081: 115.09,37.04 115.09,32.77 114.41,32.09 112.03,32.09 111.66,31.71 111.66,31.02 111.84,30.83 112.85,30.83 112.93,30.75 112.93,30.58 112.85,30.5 111.84,30.5 111.66,30.31 111.66,29.98 111.84,29.8 112.75,29.8 112.83,29.71 112.83,29.54 112.75,29.46 111.84,29.46 111.66,29.27 111.66,25.41 111.44,25.19 111.44,24.51 111.63,24.32 111.94,24.32 v1(112.2,24.06)
DDR4_COMP_CH0_DQS_P3: length 45.3
  TOP w0.149: U2.B7 v1(114.06,28.54)
  L12_SIG4 w0.076: 115.07,36.98 115.07,37.06 115.06,37.06 115.06,37.18 arc(115.08,37.29) 115.14,37.37 arc(115.22,37.47) 115.28,37.59 arc(115.3,37.81) 115.22,38.01 arc(115.16,38.19) 115.19,38.38 arc(115.26,38.69) 115.19,38.99 arc(115.16,39.18) 115.22,39.36 arc(115.3,39.61) 115.22,39.86 arc(115.16,40) 115.16,40.14 arc(115.16,40.15) 115.16,40.15 arc(115.18,40.19) 115.19,40.23 arc(115.21,40.27) 115.24,40.3 arc(115.26,40.36) 115.26,40.41 arc(115.28,40.64) 115.22,40.85 arc(115.19,41.01) 115.24,41.16 arc(115.31,41.36) 115.27,41.56 115.22,41.69 arc(115.2,41.73) 115.18,41.76 arc(115.17,41.76) 115.17,41.77 arc(115.17,41.77) 115.16,41.78 arc(115.09,41.85) 115.02,41.91 115.01,41.91 arc(115.01,41.92) 115,41.92 114.95,41.95 arc(114.92,41.96) 114.89,41.98 arc(114.82,41.99) 114.75,42 arc(114.62,42.01) 114.51,42.07 arc(114.44,42.13) 114.39,42.21 arc(114.33,42.3) 114.25,42.37 114.18,42.41 arc(114.08,42.45) 113.96,42.46 arc(113.92,42.46) 113.89,42.46 arc(113.79,42.49) 113.71,42.53 arc(113.64,42.6) 113.59,42.68 arc(113.53,42.78) 113.44,42.85 113.34,42.91 arc(113.25,42.95) 113.15,42.96 arc(112.99,42.99) 112.87,43.09 arc(112.63,43.3) 112.33,43.38 arc(112.14,43.44) 112.01,43.58 arc(111.99,43.62) 111.97,43.66 arc(111.96,43.69) 111.96,43.72 arc(111.96,43.8) 111.98,43.87 arc(111.99,43.89) 112,43.91 arc(112.01,43.93) 112.02,43.95 arc(111.97,44.54) 111.42,44.74 arc(111.38,44.74) 111.34,44.76 111.29,44.81 111.26,44.88 arc(111.25,44.93) 111.28,44.98 v1(111.54,45.13)
  L12_SIG4 w0.089: v1(114.06,28.54) 114.36,28.84 114.57,28.84 115.05,29.32 115.05,30.43 114.85,30.63 114.3,30.63 113.32,29.65 113.32,28.38 113.03,28.09 112.15,28.09 111.94,28.3 111.94,29.12 111.55,29.5 109.41,29.5 108.07,28.16 108.07,26.65 107.74,26.32 106.81,26.32 106.47,26.66 106.47,29.27 105.52,30.22 105.52,30.93 106.08,31.5 107.08,31.5 107.42,31.5 107.84,31.92 111.03,31.92 111.7,32.6 111.7,32.87 115.07,36.23 115.07,36.98
DDR4_COMP_CH0_DQS_P4: length 66.1
  TOP w0.149: U3.G3 v1(81.18,23.74)
  L14_SIG5 w0.076: 108.75,37.04 108.75,37.06 108.75,37.06 108.75,37.46 arc(108.75,37.61) 108.75,37.77 arc(108.73,37.85) 108.7,37.92 arc(108.6,38.19) 108.66,38.48 arc(108.69,38.55) 108.69,38.63 arc(108.68,38.74) 108.67,38.85 arc(108.67,38.85) 108.67,38.86 arc(108.66,38.89) 108.65,38.92 arc(108.6,39.14) 108.65,39.37 arc(108.65,39.38) 108.66,39.39 arc(108.67,39.42) 108.68,39.44 arc(108.72,39.62) 108.66,39.8 arc(108.61,39.92) 108.59,40.04 arc(108.59,40.06) 108.59,40.09 arc(108.61,40.21) 108.66,40.33 arc(108.72,40.51) 108.68,40.69 arc(108.61,40.99) 108.68,41.28 arc(108.72,41.4) 108.71,41.53 arc(108.71,41.54) 108.7,41.56 arc(108.7,41.59) 108.68,41.63 arc(108.6,41.92) 108.69,42.2 arc(108.71,42.23) 108.72,42.26 arc(108.73,42.29) 108.73,42.32 arc(108.74,42.35) 108.74,42.38 arc(108.75,42.42) 108.74,42.45 arc(108.73,42.48) 108.71,42.5 arc(108.61,42.77) 108.65,43.06 arc(108.7,43.29) 108.65,43.52 arc(108.61,43.79) 108.7,44.05 arc(108.74,44.21) 108.7,44.36 arc(108.6,44.68) 108.71,45 arc(108.74,45.05) 108.75,45.11 108.75,45.22 arc(108.75,45.27) 108.73,45.31 arc(108.64,45.59) 108.73,45.87 arc(108.75,45.91) 108.75,45.95 108.75,46.06 arc(108.74,46.12) 108.71,46.18 arc(108.6,46.51) 108.71,46.84 arc(108.74,46.89) 108.75,46.95 108.75,47.03 arc(108.73,47.12) 108.66,47.2 arc(108.59,47.24) 108.51,47.27 arc(108.5,47.28) 108.49,47.28 arc(108.44,47.3) 108.39,47.31 arc(108.38,47.31) 108.37,47.31 arc(108.37,47.31) 108.37,47.31 arc(108.34,47.32) 108.31,47.32 arc(108.06,47.4) 107.87,47.58 arc(107.84,47.62) 107.81,47.66 arc(107.7,47.74) 107.56,47.77 arc(107.52,47.77) 107.48,47.76 arc(107.36,47.71) 107.28,47.63 arc(107.05,47.44) 106.77,47.38 arc(106.76,47.37) 106.76,47.37 106.75,47.37
  L14_SIG5 w0.081: v1(106.76,46.97) 106.51,47.11 arc(106.48,47.15) 106.47,47.2 arc(106.47,47.21) 106.47,47.21 arc(106.48,47.21) 106.48,47.22 arc(106.48,47.22) 106.48,47.22 arc(106.48,47.22) 106.48,47.22 arc(106.49,47.23) 106.49,47.24 arc(106.56,47.3) 106.64,47.34 arc(106.66,47.35) 106.68,47.36 arc(106.72,47.37) 106.75,47.37 arc(106.75,47.37) 106.75,47.37 ; 108.75,37.04 108.75,36.08 108.25,35.58 108.25,34.36 107.23,33.33 107.23,31.63 106.71,31.12 106.71,30.04 106.6,29.93 103.49,29.93 103.05,29.49 98.12,29.49 97.92,29.29 97.92,27.8 97.84,27.72 97.67,27.72 97.59,27.8 97.59,29.31 97.4,29.49 97.09,29.49 96.89,29.29 96.89,27.8 96.8,27.72 96.63,27.72 96.55,27.8 96.55,29.31 96.36,29.49 94.73,29.49 94.33,29.89 93.49,29.89 93.23,29.64 89.22,29.64 88.78,29.2 88.78,23.94 86.34,21.49 85.1,21.49 85.04,21.43 84.25,21.43 84.18,21.37 83.82,21.37 83.77,21.42 83.77,21.42 83.06,22.13 83.06,23.86 81.84,25.08 80.62,25.08 80.41,24.88 80.41,24.39 80.69,24.11 81.01,24.11 81.18,23.95 v1(81.18,23.74)
DDR4_COMP_CH0_DQS_P5: length 48.4
  TOP w0.149: U3.B7 v1(83.58,28.54)
  L14_SIG5 w0.076: 98.5,46.23 98.52,46.22 98.52,46.22 98.57,46.22 98.57,46.21 99.42,46.14 99.61,46.14 arc(99.77,46.18) 99.89,46.3 99.91,46.32 arc(100.11,46.52) 100.38,46.6 100.39,46.6 arc(100.66,46.52) 100.86,46.32 arc(100.99,46.19) 101.18,46.14 101.18,46.14 arc(101.42,46.08) 101.61,45.93 arc(101.62,45.92) 101.62,45.92 101.71,45.89 v1(101.98,46.05)
  L14_SIG5 w0.081: v1(83.58,28.54) 83.27,28.85 81.77,28.85 81.54,29.09 81.54,30.72 81.29,30.97 79.9,30.97 79.29,31.58 79.29,31.85 77.44,33.7 77.44,38.38 80.81,41.75 81.77,41.75 81.95,41.56 81.95,41.18 82.02,41.11 82.22,41.11 82.29,41.18 82.29,41.56 82.48,41.75 82.8,41.75 82.99,41.56 82.99,41.19 83.07,41.11 83.24,41.11 83.33,41.2 83.33,41.56 83.51,41.75 83.84,41.75 84.03,41.56 84.03,41.25 84.11,41.17 84.27,41.17 84.36,41.27 84.36,41.56 84.55,41.75 84.88,41.75 85.06,41.56 85.06,41.38 85.14,41.3 85.32,41.3 85.4,41.38 85.4,41.56 85.59,41.75 86.36,41.75 86.55,41.56 86.55,41.46 86.63,41.37 86.8,41.37 86.88,41.46 86.88,41.56 87.07,41.75 87.72,41.75 87.86,41.89 87.86,43.86 88.23,44.23 89.77,44.23 arc(90.06,44.15) 90.27,43.93 arc(90.28,43.92) 90.28,43.92 arc(90.43,43.78) 90.62,43.73 90.76,43.73 92.36,43.73 arc(92.44,43.74) 92.51,43.79 92.77,44.05 arc(92.87,44.12) 93,44.14 93.1,44.14 arc(93.24,44.17) 93.36,44.25 93.71,44.61 arc(93.8,44.67) 93.9,44.69 94,44.69 arc(94.07,44.7) 94.13,44.74 94.18,44.79 arc(94.22,44.82) 94.25,44.85 arc(94.33,44.9) 94.38,44.97 arc(94.41,45.01) 94.44,45.05 94.48,45.09 arc(94.59,45.17) 94.72,45.19 94.94,45.19 arc(94.98,45.2) 95.02,45.22 95.33,45.53 arc(95.45,45.61) 95.58,45.64 arc(95.7,45.65) 95.82,45.68 arc(95.86,45.7) 95.89,45.72 96.31,46.14 arc(96.63,46.27) 96.95,46.14 96.95,46.13 arc(96.96,46.12) 96.98,46.11 arc(97.08,46.03) 97.16,45.93 arc(97.19,45.89) 97.23,45.86 97.42,45.75 arc(97.46,45.73) 97.5,45.73 97.56,45.73 arc(97.75,45.78) 97.9,45.91 arc(97.93,45.96) 97.97,46 arc(98.15,46.14) 98.35,46.22 arc(98.43,46.23) 98.5,46.23
DDR4_COMP_CH0_DQS_P6: length 33.3
  L07_SIG3 w0.076: v1(111.54,42.37) 111.35,42.48 arc(111.23,42.49) 111.14,42.42 arc(111.12,42.34) 111.16,42.26 arc(111.29,41.96) 111.22,41.65 arc(111.16,41.42) 111.21,41.2 arc(111.24,41.09) 111.25,40.99 arc(111.23,40.85) 111.17,40.72 arc(111.17,40.71) 111.16,40.7 arc(111.14,40.67) 111.13,40.64 111.12,40.57 arc(111.12,40.49) 111.16,40.42 arc(111.26,40.25) 111.29,40.07 111.29,40.03 arc(111.27,39.91) 111.22,39.8 arc(111.18,39.71) 111.17,39.61 arc(111.18,39.51) 111.22,39.42 arc(111.25,39.36) 111.27,39.29 arc(111.27,39.29) 111.27,39.29 arc(111.29,39.17) 111.28,39.05 arc(111.27,39.01) 111.27,38.97 arc(111.26,38.89) 111.24,38.82 arc(111.21,38.7) 111.23,38.58 arc(111.25,38.51) 111.26,38.44 arc(111.26,38.4) 111.27,38.36 arc(111.28,38.16) 111.22,37.96 arc(111.17,37.82) 111.18,37.67 arc(111.19,37.61) 111.17,37.55 arc(111.16,37.51) 111.15,37.47 111.15,37.06 111.16,37.05 111.16,37.04
  L07_SIG3 w0.089: 111.16,37.04 111.16,35.93 111.15,35.84 110.68,34.94 109.86,34.13 107.97,34.13 107.41,33.56 107.41,33.17 107.41,32.68 106.1,31.38 105.22,31.38 104.59,30.75 104.59,29.89 104.39,29.69 104.06,29.69 103.86,29.89 103.86,30.34 103.76,30.44 103.74,30.44 103.06,30.44 102.96,30.34 102.96,29.77 102.76,29.57 102.33,29.57 102.13,29.77 102.13,30.35 102.04,30.44 101.11,30.44 101,30.33 101,29.87 101.71,29.16 103.3,29.16 103.5,28.96 103.5,28.36 103.3,28.16 102.1,28.16 102.01,28.07 102.01,24.66 101.81,24.45 101.41,24.45 v1(101.1,24.14)
DDR4_COMP_CH0_DQS_P7: length 40.4
  TOP w0.149: U4.B7 v1(103.9,28.54)
  L05_SIG2 w0.076: v1(116.32,42.37) 116.31,42.42 arc(116.28,42.47) 116.24,42.51 116.18,42.54 arc(116.06,42.56) 115.97,42.5 arc(115.97,42.49) 115.96,42.49 arc(115.96,42.48) 115.96,42.47 arc(115.95,42.37) 115.96,42.26 arc(115.97,42.22) 115.99,42.19 arc(116.07,41.88) 115.96,41.58 arc(115.93,41.53) 115.92,41.47 115.92,41.4 arc(115.93,41.32) 115.97,41.23 arc(116.03,41.04) 116.01,40.84 arc(116.01,40.82) 116,40.79 arc(115.99,40.72) 115.97,40.64 arc(115.95,40.49) 116.01,40.34 arc(116.04,40.26) 116.06,40.18 arc(116.06,40.17) 116.06,40.15 arc(116.07,40) 116.02,39.84 arc(116.02,39.84) 116.02,39.83 arc(116,39.8) 115.99,39.77 arc(115.98,39.75) 115.97,39.72 arc(115.96,39.7) 115.96,39.69 arc(115.96,39.68) 115.96,39.68 arc(115.96,39.67) 115.95,39.65 arc(115.95,39.54) 115.99,39.44 arc(116.07,39.19) 116.02,38.93 arc(115.98,38.72) 116.01,38.51 arc(116.04,38.43) 116.06,38.34 arc(116.06,38.34) 116.06,38.33 arc(116.07,38.16) 116.02,38 arc(116.02,38) 116.02,37.99 arc(116,37.96) 115.99,37.93 arc(115.96,37.83) 115.95,37.72 arc(115.96,37.67) 115.96,37.61 arc(115.96,37.53) 115.99,37.44 arc(116,37.4) 116,37.35 116,36.97 116.13,36.85 116.13,36.85 116.24,36.74 116.24,36.69 116.24,36.68 116.24,36.67
  L05_SIG2 w0.081: 116.24,36.67 116.24,36.43 116.05,36.24 115.89,36.24 115.81,36.16 115.81,35.99 115.89,35.91 116.06,35.91 116.25,35.72 116.25,35.39 116.06,35.21 115.89,35.21 115.81,35.12 115.81,34.95 115.89,34.87 116.06,34.87 116.25,34.68 116.25,34.36 116.06,34.17 115.89,34.17 115.81,34.09 115.81,29.99 115.53,29.71 113.67,29.71 113.59,29.63 113.59,27.57 113.4,27.38 113.07,27.38 112.88,27.57 112.88,29.61 112.78,29.71 112.61,29.71 112.51,29.61 112.51,27.57 112.32,27.38 112,27.38 111.81,27.57 111.81,29.63 111.73,29.71 108.96,29.71 108.57,29.32 108.13,29.32 108.05,29.24 108.05,28.38 107.86,28.19 107.54,28.19 107.35,28.38 107.35,29.24 107.27,29.32 107.1,29.32 107.01,29.24 107.01,28.38 106.83,28.19 106.5,28.19 106.31,28.38 106.31,29.24 106.23,29.32 104.82,29.32 104.74,29.24 104.74,29.04 104.46,28.76 104.15,28.76 103.93,28.54 v1(103.9,28.54)
DDR4_COMP_CH0_DQS_P8: length 67.7
  TOP w0.149: v1(71.16,23.97) 70.99,24.13 U5.G3
  L12_SIG4 w0.076: v1(106.76,45.13) 106.5,44.98 arc(106.45,44.97) 106.4,45.01 106.36,45.07 arc(106.36,45.08) 106.36,45.08 arc(106.35,45.1) 106.34,45.11 arc(106.2,45.23) 106.01,45.26 arc(105.81,45.29) 105.67,45.44 arc(105.5,45.62) 105.26,45.68 arc(105.22,45.67) 105.18,45.67 105.18,45.67 arc(105.18,45.67) 105.17,45.67 arc(105.13,45.66) 105.09,45.66 arc(104.78,45.53) 104.57,45.26 arc(104.55,45.21) 104.53,45.16 arc(104.53,45.16) 104.53,45.16 arc(104.19,45.16) 103.93,44.95 arc(103.76,44.78) 103.54,44.71 arc(103.3,44.64) 103.13,44.45 arc(103.1,44.42) 103.07,44.39 arc(103.06,44.38) 103.04,44.37 arc(103.03,44.36) 103.02,44.35 arc(102.93,44.3) 102.82,44.29 arc(102.55,44.24) 102.33,44.06 arc(102.15,43.9) 101.93,43.83 arc(101.64,43.72) 101.46,43.47 arc(101.41,43.38) 101.31,43.31 arc(101.24,43.28) 101.17,43.25 arc(100.94,43.16) 100.71,43.05 arc(100.66,43.03) 100.61,42.99 arc(100.54,42.95) 100.46,42.93 arc(100.41,42.91) 100.35,42.89 arc(100.09,42.76) 99.83,42.63 arc(99.65,42.44) 99.61,42.19 arc(99.51,41.9) 99.22,41.81 arc(99.17,41.83) 99.13,41.85 arc(98.88,41.84) 98.75,41.63 arc(98.66,41.41) 98.44,41.31 arc(98.11,41.2) 97.88,40.96 arc(97.74,40.82) 97.55,40.77 arc(97.22,40.69) 96.97,40.46 arc(96.85,40.35) 96.7,40.31 arc(96.55,40.27) 96.41,40.19 arc(96.32,40.1) 96.23,40.02 arc(96.23,40.01) 96.23,40.01 arc(96.07,39.86) 95.91,39.71 arc(95.84,39.66) 95.77,39.64 arc(95.5,39.53) 95.34,39.28 arc(95.3,39.21) 95.25,39.16 arc(94.44,38.6) 93.57,38.13 arc(93.48,38.11) 93.38,38.12 arc(93.03,38.11) 92.77,37.86 arc(92.71,37.79) 92.63,37.74 arc(92.59,37.72) 92.55,37.71 92.51,37.69 92.48,37.66 arc(92.07,37.37) 91.59,37.27 91.51,37.27 91.5,37.28 91.49,37.28
  L12_SIG4 w0.089: v1(71.16,23.97) 70.87,24.26 70.41,24.26 70.21,24.46 70.21,25.13 70.42,25.34 71.05,25.34 71.14,25.43 71.14,28.8 71.93,29.6 76.06,29.6 76.41,29.25 76.41,27.35 76.56,27.2 77.64,27.2 77.91,27.47 77.91,28.39 77.82,28.48 77.07,28.48 76.87,28.68 76.87,29.01 77.07,29.21 77.82,29.21 77.91,29.3 77.91,30.3 78.66,31.05 81.81,31.05 82.01,30.85 82.01,29.84 82.1,29.75 82.91,29.75 83.11,29.55 83.11,29.23 82.91,29.03 82.1,29.03 82.01,28.94 82.01,28.72 82.1,28.63 83,28.63 83.2,28.43 83.2,28.06 82.86,27.72 82.1,27.72 82.01,27.63 82.01,27.35 82.34,27.02 83.21,27.02 83.41,27.22 83.41,27.57 83.74,27.9 84.03,27.9 84.1,27.98 84.1,29.15 84.56,29.61 84.56,29.73 84.39,29.91 84.39,30.19 84.62,30.42 84.9,30.42 85.07,30.25 85.2,30.25 85.79,30.83 85.79,31.85 91.22,37.28 91.49,37.28
DDR4_COMP_CH0_ODT: length 83.1
  TOP w0.149: U4.K3 v1(101.64,21.74) ; U3.K3 v1(81.33,21.74) ; U2.K3 v1(111.85,21.74) ; U1.K3 v1(91.46,21.74)
  L07_SIG3 w0.089: v1(70.59,21.73) 71,22.14 71.61,22.14 71.7,22.23 71.7,22.31 71.79,22.4 71.95,22.4 72.04,22.31 72.04,22.23 72.13,22.14 72.3,22.14 72.39,22.23 72.39,22.31 72.47,22.4 72.64,22.4 72.73,22.31 72.73,22.23 72.82,22.14 80.38,22.14 U3.K3 v1(81.33,21.74) 81.76,22.18 87.54,22.18 87.67,22.05 87.67,21.74 87.76,21.65 87.92,21.65 88.01,21.74 88.01,22.05 88.1,22.14 90.54,22.14 U1.K3 v1(91.46,21.74) 91.86,22.14 92.2,22.14 92.29,22.05 92.29,21.69 92.37,21.6 92.54,21.6 92.63,21.69 92.63,22.05 92.72,22.14 100.7,22.14 U4.K3 v1(101.64,21.74) 103.71,21.74 104.11,22.14 110.86,22.14 111.26,21.74 v1(111.85,21.74)
  L16_SIG6 w0.081: v1(111.85,21.74) 111.75,21.84 111.75,22.4 111.83,22.48 112.02,22.48 112.1,22.56 112.1,22.74 112.02,22.82 111.83,22.82 111.75,22.9 111.75,23.07 111.83,23.15 112.02,23.15 112.1,23.24 112.1,23.41 112.02,23.49 111.83,23.49 111.75,23.57 111.75,26.06 111.67,26.14 109.21,26.14 109.13,26.22 109.13,26.8 109.25,26.93 111.75,26.93 111.83,27.01 111.83,27.64 111.75,27.73 109.22,27.73 109.14,27.81 109.14,29.44 109.31,29.61 109.71,29.61 109.83,29.5 109.83,29.33 109.91,29.25 110.08,29.25 110.16,29.33 110.16,29.5 110.31,29.64 110.62,29.64 110.85,29.41 110.85,28.6 110.93,28.52 112.32,28.52 112.52,28.72 112.52,29.39 112.04,29.87 111.89,29.87 111.41,29.39 111.3,29.39 111.18,29.52 111.18,29.63 111.65,30.1 111.65,30.22 111.36,30.51 111.36,30.63 111.66,30.93 111.66,31.04 111.56,31.15 111.41,31.15 111.12,30.86 111.01,30.86 106.02,35.85 106.02,36.79 105.16,37.64 v1(105.16,37.77)
