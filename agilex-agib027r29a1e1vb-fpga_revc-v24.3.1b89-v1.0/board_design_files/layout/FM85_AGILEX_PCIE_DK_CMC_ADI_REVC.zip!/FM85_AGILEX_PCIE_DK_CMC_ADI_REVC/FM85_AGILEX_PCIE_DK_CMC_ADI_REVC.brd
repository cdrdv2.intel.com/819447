# Allegro board FM85_AGILEX_PCIE_DK_CMC_ADI_REVC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_DDIMM2_TDQS_N14: length 54.2
  L03_SIG1 w0.081: v1(97.19,99.34) 97.41,99.34 97.49,99.26 97.49,98.34 97.79,98.03 98.59,98.03 98.66,97.96 98.95,97.96 99.1,97.81 99.1,96.61 98.99,96.5 98.78,96.5 98.09,97.19 98.09,97.41 97.96,97.54 97.74,97.54 97.63,97.65 97.05,97.65 96.97,97.73 96.97,98.6 96.78,98.79 96.46,98.79 96.27,98.6 96.27,98.03 96.18,97.94 96.02,97.94 95.94,98.02 95.94,98.6 95.75,98.79 95.42,98.79 95.24,98.6 95.24,98.14 95.15,98.05 94.5,98.05 94.08,98.47 93.12,98.47 92.68,98.92 89.61,98.92 89.35,98.65 89.35,98.34 89.58,98.11 90.02,98.11 90.17,97.96 91.62,97.96 91.76,97.82 91.76,97.39 91.96,97.2 92.27,97.2 92.46,97.39 92.46,97.58 92.55,97.66 93.1,97.66 93.41,97.35 94.11,97.35 94.2,97.27 94.2,96.86 94.38,96.67 94.71,96.67 94.9,96.86 94.9,97.27 94.98,97.35 95.22,97.35 95.3,97.27 95.3,96.83 95.55,96.57 95.55,95.46 95.47,95.37 93.5,95.37 93.29,95.16 93.29,94.87 93.49,94.67 93.8,94.67 94.03,94.43 94.39,94.43 94.62,94.66 94.73,94.66 94.89,94.5 95.27,94.5 95.43,94.66 95.8,94.66 95.88,94.58 95.88,94.04 95.59,93.75 95.59,91.84 104.68,82.76 104.68,81.33 104.61,81.27 104.61,79.92 104.91,79.62 105.28,79.62 105.39,79.51 105.39,79.39 v2(105.17,79.17)
DDR4_DDIMM2_TDQS_N15: length 54.2
  L05_SIG2 w0.076: 109.98,79.19 110.22,79.32 110.24,79.41 arc(110.24,79.42) 110.23,79.43 arc(110.2,79.67) 110.27,79.9 110.29,79.93 arc(110.48,80.11) 110.74,80.18 110.77,80.18 arc(110.94,80.23) 111.07,80.36 arc(111.12,80.53) 111.08,80.71 111.07,80.74 arc(111.04,80.78) 111.01,80.81 110.66,81.16 110.66,81.16 110.64,81.17
  L05_SIG2 w0.081: 109.98,79.19 v1(109.95,79.17) ; v1(87.84,99.34) 88.03,99.16 88.03,93.87 89.84,92.06 91.06,92.06 94.42,88.7 95.91,88.7 95.99,88.62 95.99,87.6 96.18,87.41 96.51,87.41 96.69,87.6 96.69,88.62 96.78,88.7 96.95,88.7 97.03,88.62 97.03,87.6 97.22,87.41 97.54,87.41 97.73,87.6 97.73,88.62 97.81,88.7 97.98,88.7 98.07,88.62 98.07,87.6 98.25,87.41 98.58,87.41 98.77,87.6 98.77,88.62 98.85,88.7 99.02,88.7 99.1,88.62 99.1,87.6 99.29,87.41 99.61,87.41 99.8,87.6 99.8,88.62 99.88,88.7 100.06,88.7 100.14,88.62 100.14,87.6 100.33,87.41 100.65,87.41 100.84,87.6 100.84,88.62 100.92,88.7 101.09,88.7 101.17,88.62 101.17,87.6 101.36,87.41 101.69,87.41 101.88,87.6 101.88,88.62 101.96,88.7 102.13,88.7 102.21,88.62 102.21,87.6 102.4,87.41 102.72,87.41 102.91,87.6 102.91,88.62 102.99,88.7 106.2,88.7 107.12,87.79 107.12,84.27 109.79,81.6 110.22,81.6 110.64,81.17
DDR4_DDIMM2_TDQS_N16: length 68
  L14_SIG5 w0.076: 112.71,81.71 112.71,81.63 112.71,81.63 112.71,81.47 arc(112.71,81.43) 112.7,81.39 arc(112.7,81.38) 112.69,81.36 arc(112.68,81.32) 112.66,81.28 arc(112.59,81.01) 112.66,80.74 112.66,80.73 arc(112.71,80.55) 112.66,80.36 112.66,80.36 arc(112.59,80.09) 112.66,79.82 arc(112.71,79.63) 112.66,79.44 112.6,79.22 112.6,79.17 112.62,79.08 112.64,79.01 112.68,78.94 arc(112.73,78.75) 112.68,78.57 112.66,78.52 arc(112.63,78.45) 112.6,78.38 arc(112.59,78.25) 112.6,78.12 arc(112.63,78.05) 112.66,77.98 112.66,77.97 arc(112.71,77.79) 112.66,77.6 112.66,77.6 arc(112.63,77.53) 112.6,77.46 arc(112.59,77.33) 112.6,77.2 arc(112.62,77.16) 112.63,77.11 arc(112.65,77.08) 112.66,77.06 arc(112.67,77.04) 112.67,77.03 arc(112.71,76.87) 112.67,76.71 112.65,76.66 arc(112.59,76.4) 112.66,76.13 arc(112.71,75.95) 112.66,75.77 112.66,75.76 arc(112.53,75.63) 112.36,75.58 112.32,75.58 arc(112.06,75.51) 111.87,75.32 111.86,75.3 arc(111.79,75.07) 111.83,74.83 arc(111.83,74.82) 111.83,74.81 111.81,74.72 v1(111.54,74.57)
  L14_SIG5 w0.081: v1(78.49,99.34) 78.83,99.01 78.83,98.34 78.75,98.26 78.14,98.26 77.95,98.07 77.95,97.74 78.14,97.56 78.75,97.56 78.83,97.47 78.83,97.3 78.75,97.22 77.84,97.22 77.65,97.03 77.65,96.71 77.84,96.52 78.84,96.52 78.92,96.44 78.92,96.26 78.84,96.18 77.84,96.18 77.65,96 77.65,95.67 77.84,95.48 78.54,95.48 78.62,95.4 78.62,93.98 79,93.6 79,93.2 79,92.35 79.49,91.86 81.25,91.86 81.33,91.78 81.33,90.98 81.52,90.79 81.85,90.79 82.03,90.98 82.03,91.78 82.11,91.86 82.29,91.86 82.37,91.78 82.37,90.98 82.56,90.79 82.88,90.79 83.07,90.98 83.07,91.78 83.15,91.86 83.32,91.86 83.41,91.78 83.41,90.98 83.59,90.79 83.92,90.79 84.11,90.98 84.11,91.78 84.19,91.86 84.36,91.86 84.44,91.78 84.44,90.98 84.63,90.79 84.95,90.79 85.14,90.98 85.14,91.78 85.22,91.86 86.31,91.86 88.56,89.61 91.58,89.61 94.33,86.85 109.96,86.85 111.5,85.32 111.5,84.34 112.06,83.78 112.63,83.78 112.71,83.7 112.71,81.71
DDR4_DDIMM2_TDQS_N17: length 55.5
  L12_SIG4 w0.076: 118.88,81.27 118.88,81.25 118.89,81.25 118.89,81.19 118.89,81.18 118.89,81.14 arc(118.9,81.07) 118.91,80.99 119.05,80.69 arc(119.09,80.53) 119.06,80.38 119.01,80.28 arc(118.99,80.22) 118.98,80.15 arc(119.08,79.78) 119.4,79.56 arc(119.46,79.55) 119.52,79.54 arc(119.64,79.52) 119.75,79.45 arc(119.78,79.37) 119.74,79.3 v1(119.51,79.17)
  L12_SIG4 w0.089: 118.88,81.27 118.88,83.68 arc(118.93,83.94) 119.08,84.17 119.22,84.3 arc(119.36,84.51) 119.41,84.76 119.41,86.48 120.29,87.36 121.75,87.36 124.51,90.12 125.58,90.12 125.78,89.92 125.78,89.33 125.87,89.24 126.03,89.24 126.12,89.33 126.12,89.92 126.32,90.12 127.2,90.12 128.09,91.01 129.26,91.01 129.48,91.23 129.48,91.6 129.72,91.85 130.1,91.85 130.23,91.98 130.23,92.36 130.48,92.6 130.85,92.6 131.15,92.9 131.74,92.9 131.98,93.13 133.87,93.13 135.7,94.97 136.79,94.97 136.99,94.77 136.99,94.54 137.08,94.45 137.24,94.45 137.33,94.54 137.33,94.74 137.53,94.94 139.07,94.94 139.27,95.14 139.7,95.14 139.98,94.85 139.98,94.51 140.07,94.42 140.24,94.42 140.33,94.51 140.33,94.83 140.53,95.03 142.63,95.03 142.88,95.28 143.44,95.28 143.83,94.89 144.19,94.89 144.57,94.51 144.69,94.51 144.78,94.6 144.78,95.2 144.98,95.4 145.31,95.4 145.51,95.2 145.51,94.76 145.6,94.67 145.76,94.67 145.85,94.76 145.85,95.2 146.05,95.4 146.37,95.4 146.57,95.2 146.57,94.76 146.66,94.67 146.83,94.67 146.92,94.76 146.92,95.2 147.12,95.4 147.44,95.4 147.64,95.2 147.64,94.76 147.73,94.67 147.89,94.67 147.98,94.76 147.98,95.23 148.18,95.43 148.49,95.43 148.71,95.21 148.71,94.76 148.8,94.67 149.15,94.67 151.62,97.15 152.57,97.15 152.69,97.26 152.69,97.76 152.51,97.95 v1(152.44,97.95)
DDR4_DDIMM_A0: length 74.1
  L05_SIG2 w0.081: v1(124.39,106.96) 124.39,107.63 124.26,107.76 122.33,107.76 122.25,107.84 122.25,108.15 122.17,108.23 122,108.23 121.91,108.15 121.91,107.84 121.83,107.76 121.66,107.76 121.58,107.84 121.58,108.15 121.5,108.23 121.32,108.23 121.24,108.15 121.24,107.84 121.16,107.76 120.99,107.76 120.91,107.84 120.91,108.15 120.83,108.23 120.65,108.23 120.57,108.15 120.57,107.84 120.49,107.76 119.96,107.76 118.53,106.33 117.8,106.33 116.95,105.48 116.09,105.48 115.5,104.9 114.79,104.9 114.34,105.35 114.16,105.35 114.07,105.43 114.07,105.68 113.99,105.76 113.82,105.76 113.74,105.68 113.74,105.38 113.66,105.3 112.46,105.3 112.38,105.22 112.38,105.07 112.3,104.99 112.13,104.99 112.05,105.07 112.05,105.22 111.97,105.3 111.23,105.3 111.14,105.22 111.14,104.96 111.06,104.88 110.89,104.88 110.81,104.96 110.81,105.22 110.73,105.3 107.21,105.3 107.08,105.17 107.08,104.48 107.24,104.32 107.64,104.32 107.73,104.4 107.73,104.72 107.81,104.8 107.96,104.8 108.06,104.7 108.06,104.4 108.14,104.32 108.32,104.32 108.4,104.4 108.4,104.72 108.48,104.8 108.64,104.8 108.73,104.7 108.73,104.4 108.81,104.32 108.99,104.32 109.07,104.4 109.07,104.72 109.15,104.8 109.31,104.8 109.4,104.7 109.4,104.46 109.48,104.38 110.19,104.38 110.19,104.37 110.5,104.37 110.5,104.38 112.83,104.38 112.96,104.51 113.99,104.51 114.12,104.38 115.56,104.38 115.95,103.98 115.95,102.51 116.26,102.2 116.26,101.89 115.95,101.58 115.95,100.71 116.44,100.23 118.74,100.23 119.28,99.69 119.28,99 118.8,98.52 118.8,94.34 119.42,93.72 120.3,93.72 120.6,93.41 122.09,93.41 122.94,92.57 122.94,91.24 122.22,90.53 120.43,90.53 120.15,90.25 120.15,87.96 120.6,87.51 121.04,87.51 121.57,86.99 121.57,84.84 122.01,84.39 122.01,83.3 121.5,82.78 121.5,81.73 121.16,81.39 120.91,81.39 120.73,81.21 arc(120.71,81.17) 120.7,81.13 120.7,80.78 120.72,80.75 arc(120.77,80.53) 120.71,80.32 120.7,80.31 arc(120.64,80.09) 120.71,79.86 arc(120.77,79.63) 120.71,79.4 120.7,79.4 arc(120.64,79.17) 120.71,78.94 arc(120.77,78.71) 120.71,78.48 120.71,78.48 arc(120.64,78.25) 120.71,78.02 arc(120.77,77.79) 120.71,77.56 120.7,77.56 arc(120.64,77.33) 120.71,77.1 arc(120.77,76.88) 120.72,76.66 120.31,75.95 arc(120.31,75.95) v1(120.31,75.95)
DDR4_DDIMM_A1: length 74.5
  L03_SIG1 w0.081: v1(119.51,76.41) 119.08,76.84 119.08,80.7 119.02,80.77 119.02,82.81 120.2,83.98 120.2,85.25 120.51,85.57 120.7,85.57 120.78,85.65 120.78,85.82 120.7,85.9 120.51,85.9 120.43,85.98 120.43,88.7 120.51,88.78 120.95,88.78 121.03,88.86 121.03,89.04 120.95,89.12 120.51,89.12 120.43,89.2 120.43,89.37 120.51,89.45 120.95,89.45 121.03,89.53 121.03,89.71 120.95,89.79 120.51,89.79 120.43,89.87 120.43,90.3 120.74,90.6 120.74,90.72 120.22,91.24 120.22,91.36 120.34,91.48 120.45,91.48 120.98,90.96 121.09,90.96 121.21,91.08 121.21,91.19 120.69,91.72 120.69,91.83 120.81,91.95 120.93,91.95 121.45,91.43 121.57,91.43 122.49,92.36 122.49,92.47 121.83,93.13 121.83,93.25 121.95,93.37 122.07,93.37 122.73,92.71 122.84,92.71 123.38,93.24 123.38,93.36 122.73,94 122.73,94.12 122.86,94.24 122.97,94.24 123.61,93.6 123.73,93.6 123.99,93.86 123.99,94.86 124.95,95.81 124.95,97.98 125.93,98.96 125.93,100.35 126.29,100.7 126.29,100.82 125.69,101.42 125.69,101.53 125.81,101.65 125.92,101.65 126.52,101.05 126.64,101.05 126.76,101.18 126.76,101.29 126.16,101.89 126.16,102 126.28,102.13 126.4,102.13 127,101.53 127.11,101.53 128.64,103.06 128.64,103.17 128.21,103.61 128.21,103.72 128.33,103.84 128.44,103.84 128.88,103.41 128.99,103.41 129.69,104.11 129.69,104.22 129.05,104.87 128.93,104.87 128.47,104.4 128.35,104.4 128.23,104.52 128.23,104.64 128.7,105.11 128.7,105.22 127.46,106.45 127.46,106.67 127.58,106.78 127.71,106.78 128,106.49 128.12,106.49 128.58,106.95 128.69,106.95 128.81,106.82 128.81,106.71 128.36,106.25 128.36,106.14 128.48,106.02 128.59,106.02 129.53,106.95 129.67,106.95 129.77,106.85 129.77,106.72 128.83,105.78 128.83,105.66 128.95,105.54 129.07,105.54 130.08,106.56 130.2,106.56 130.32,106.44 130.32,106.32 129.3,105.3 129.3,105.19 129.98,104.51 130.1,104.51 130.56,104.97 131.6,104.97 131.69,105.05 131.69,105.76 131.77,105.84 131.94,105.84 132.02,105.76 132.02,105.05 132.1,104.97 132.86,104.97 133.04,105.15 133.04,105.27 132.41,105.9 132.41,106.01 132.53,106.13 132.65,106.13 133.27,105.51 133.39,105.51 133.51,105.63 133.51,105.74 132.88,106.37 132.88,106.48 133.01,106.61 133.12,106.61 133.75,105.98 133.86,105.98 134.85,106.96 v1(135.44,106.96)
DDR4_DDIMM_A2: length 71.4
  L07_SIG3 w0.089: v1(135.44,100.96) 135.44,101.33 135.63,101.51 138.17,101.51 139.81,99.87 140.67,99.87 140.96,100.17 140.96,104.15 141.29,104.48 148.12,104.48 149.45,103.15 149.45,100.2 148.62,99.37 148.62,97.56 145.86,94.8 143.88,94.8 143.33,94.25 142.85,94.25 142.62,94.47 142.62,95.03 141.98,95.68 135.69,95.68 134.89,94.87 134.42,94.87 134.11,94.57 134.11,94.51 133.53,93.93 130.45,93.93 129.38,92.85 129.37,92.85 121.53,85 121.53,76.71 121.53,76.71 121.53,76.26 121.14,75.86 120.81,75.86 120.35,75.41 120,75.41 119.51,74.92 v1(119.51,74.57)
DDR4_DDIMM_A3: length 72.4
  L03_SIG1 w0.081: v1(136.24,106.96) 136.24,106.46 135.32,105.54 135.32,105.15 134.62,104.44 134.51,104.44 133.81,105.14 133.7,105.14 133.58,105.01 133.58,104.9 134.27,104.21 134.27,104.09 134.15,103.97 134.03,103.97 133.34,104.66 133.22,104.66 133.1,104.54 133.1,104.43 133.79,103.73 133.79,103.62 133.67,103.5 133.56,103.5 132.74,104.31 132.6,104.31 132.49,104.2 132.49,104.08 133.32,103.26 133.32,103.14 133.05,102.87 132.48,102.87 132.4,102.95 132.4,103.51 132.31,103.59 132.14,103.59 132.06,103.51 132.06,102.95 131.98,102.87 131.74,102.87 131.63,102.98 131.63,104.4 131.55,104.48 131.39,104.48 131.3,104.39 131.3,102.98 131.21,102.9 131.04,102.9 130.96,102.98 130.96,104.4 130.88,104.48 130.72,104.48 130.63,104.39 130.63,103.83 130.54,103.75 129.91,103.75 129.83,103.67 129.83,103.49 129.91,103.41 130.54,103.41 130.63,103.33 130.63,102.98 130.52,102.87 130.31,102.87 130.13,102.69 130.02,102.69 129.47,103.24 129.35,103.24 129.23,103.12 129.23,103 129.78,102.45 129.78,102.34 129.66,102.22 129.54,102.22 128.99,102.76 128.88,102.76 128.76,102.64 128.76,102.53 129.31,101.98 129.31,101.86 129.18,101.74 129.07,101.74 128.52,102.29 128.4,102.29 128.28,102.17 128.28,102.05 128.83,101.5 128.83,101.39 128.71,101.27 128.59,101.27 128.04,101.82 127.93,101.82 127.81,101.69 127.81,101.58 128.36,101.03 128.36,100.91 128.23,100.79 128.12,100.79 127.57,101.34 127.46,101.34 127.33,101.22 127.33,101.11 127.88,100.56 127.88,100.44 127.76,100.32 127.65,100.32 127.1,100.87 126.98,100.87 126.86,100.75 126.86,100.63 127.41,100.08 127.41,99.97 127.29,99.84 127.17,99.84 126.62,100.39 126.51,100.39 126.38,100.27 126.38,100.16 126.93,99.61 126.93,99.49 125.28,97.84 125.28,95.36 124.79,94.87 124.79,94.18 121.72,91.12 121.72,90 122.03,89.7 122.03,89.2 121.94,89.12 121.46,89.12 121.38,89.04 121.38,88.87 121.46,88.78 121.94,88.78 122.03,88.7 122.03,88.53 121.94,88.45 121.46,88.45 121.38,88.37 121.38,88.2 121.46,88.11 121.94,88.11 122.03,88.03 122.03,87.83 121.8,87.61 121.06,87.61 120.97,87.53 120.97,87.36 121.06,87.27 121.57,87.27 121.65,87.19 121.65,87.02 121.57,86.94 121.06,86.94 120.97,86.86 120.97,86.68 121.06,86.6 121.57,86.6 121.65,86.52 121.65,84.91 119.93,83.2 119.93,75.8 120.31,75.42 v1(120.31,75.03)
DDR4_DDIMM_A4: length 75.1
  L03_SIG1 w0.081: v1(121.9,75.95) 122.76,75.95 123.12,76.31 123.12,82 123.04,82.08 123.04,82.41 123.46,82.83 123.46,88.2 123.54,88.28 123.96,88.28 124.04,88.36 124.04,88.53 123.96,88.61 123.54,88.61 123.46,88.69 123.46,89 123.86,89.4 123.97,89.4 124.43,88.94 124.54,88.94 124.66,89.06 124.66,89.18 124.21,89.63 124.21,89.75 124.65,90.19 124.77,90.19 125.26,89.7 125.38,89.7 125.5,89.82 125.5,89.94 125.01,90.43 125.01,90.55 125.13,90.67 125.24,90.67 125.74,90.17 125.85,90.17 125.97,90.3 125.97,90.41 125.48,90.91 125.48,91.02 125.6,91.14 125.72,91.14 126.21,90.65 126.33,90.65 126.45,90.77 126.45,90.88 125.95,91.38 125.95,91.49 126.08,91.62 126.19,91.62 126.69,91.12 126.8,91.12 126.92,91.24 126.92,91.36 126.43,91.85 126.43,91.97 126.55,92.09 126.66,92.09 127.16,91.6 127.27,91.6 127.4,91.72 127.4,91.83 126.9,92.33 126.9,92.44 127.02,92.56 127.14,92.56 127.63,92.07 127.75,92.07 127.87,92.19 127.87,92.31 127.38,92.8 127.38,92.92 127.5,93.04 127.61,93.04 128.11,92.54 128.22,92.54 128.34,92.67 128.34,92.78 127.85,93.28 127.85,93.39 127.97,93.51 128.09,93.51 128.58,93.02 128.7,93.02 128.82,93.14 128.82,93.26 128.32,93.75 128.32,93.87 129.56,95.1 129.68,95.1 129.95,94.83 130.06,94.83 130.18,94.96 130.18,95.07 129.91,95.34 129.91,95.46 130.04,95.58 130.15,95.58 130.42,95.31 130.54,95.31 130.66,95.43 130.66,95.55 130.39,95.81 130.39,95.93 130.64,96.18 130.64,96.52 131.07,96.95 131.19,96.95 131.46,96.67 131.58,96.67 131.7,96.8 131.7,96.91 131.42,97.19 131.42,97.3 131.84,97.72 132.59,97.72 132.67,97.8 132.67,98.7 132.75,98.78 132.92,98.78 133,98.7 133,97.8 133.09,97.72 133.26,97.72 133.34,97.8 133.34,98.7 133.42,98.78 133.59,98.78 133.68,98.7 133.68,97.8 133.76,97.72 133.93,97.72 134.01,97.8 134.01,98.31 134.09,98.39 134.26,98.39 134.35,98.31 134.35,97.8 134.43,97.72 134.6,97.72 134.68,97.8 134.68,98.2 134.76,98.28 134.94,98.28 135.02,98.2 135.02,97.8 135.1,97.72 135.27,97.72 135.35,97.8 135.35,98.7 135.43,98.78 135.61,98.78 135.69,98.7 135.69,97.8 135.77,97.72 137.51,97.72 138.47,98.68 138.47,99.5 138.99,100.01 138.99,101.26 139.4,101.67 139.75,101.67 140.68,102.6 140.68,105.51 140.92,105.74 140.92,106.05 140.69,106.28 139.53,106.28 139.3,106.05 139.3,105.51 138.93,105.15 138.93,103.14 137.14,101.34 v1(137.14,100.96)
DDR4_DDIMM_A5: length 74.6
  L03_SIG1 w0.081: v1(137.99,100.96) 137.62,100.59 136.99,100.59 136.74,100.85 136.74,101.61 138.38,103.25 138.38,106.2 138.29,106.28 137.95,106.28 137.95,106.28 137.51,106.28 137.43,106.36 137.43,106.85 137.35,106.93 137.18,106.93 137.1,106.85 137.1,106.36 137.02,106.28 136.57,106.28 135.74,105.46 135.74,105.04 135.19,104.49 135.19,104.38 135.68,103.89 135.68,103.77 135.56,103.65 135.45,103.65 134.96,104.14 134.84,104.14 134.72,104.02 134.72,103.9 135.88,102.74 135.88,102.6 135.77,102.49 135.66,102.49 135.49,102.65 135.38,102.65 135.08,102.35 134.96,102.35 134.84,102.47 134.84,102.59 135.14,102.89 135.14,103 134.48,103.67 134.37,103.67 133.89,103.19 133.89,103.07 134.48,102.48 134.48,102.36 134.36,102.24 134.24,102.24 133.65,102.83 133.54,102.83 133.24,102.53 132.39,102.53 131.77,101.92 130.79,101.92 130.55,101.68 129.6,101.68 129.15,101.23 129.15,101.12 129.66,100.61 129.66,100.49 129.54,100.37 129.42,100.37 128.91,100.88 128.8,100.88 128.68,100.76 128.68,100.64 129.19,100.13 129.19,100.02 129.06,99.9 128.95,99.9 128.44,100.41 128.32,100.41 128.2,100.29 128.2,100.17 129.22,99.15 129.22,99.02 129.11,98.91 128.99,98.91 127.96,99.93 127.85,99.93 127.73,99.81 127.73,99.7 128.77,98.65 128.77,98.54 128.65,98.42 128.53,98.42 127.49,99.46 127.38,99.46 127.25,99.34 127.25,99.22 128.73,97.74 128.73,97.63 128.62,97.51 128.49,97.51 127.02,98.99 126.9,98.99 125.62,97.7 125.62,94.37 122.06,90.81 122.06,90.14 122.36,89.84 122.36,87.29 122.28,87.21 122.1,87.21 122.02,87.13 122.02,86.96 122.1,86.88 122.28,86.88 122.36,86.79 122.36,86.62 122.28,86.54 122.1,86.54 122.02,86.46 122.02,86.29 122.1,86.2 122.28,86.2 122.36,86.12 122.36,85.95 122.28,85.87 122.1,85.87 122.02,85.79 122.02,85.62 122.1,85.53 122.28,85.53 122.36,85.45 122.36,85.28 122.28,85.2 122.1,85.2 122.02,85.12 122.02,84.95 122.1,84.86 122.28,84.86 122.36,84.78 122.36,84.04 122.25,83.93 122.13,83.93 121.81,84.25 121.7,84.25 121.58,84.12 121.58,84.01 121.89,83.69 121.89,83.58 121.77,83.45 121.66,83.45 121.34,83.77 121.22,83.77 121.1,83.65 121.1,83.53 121.42,83.22 121.42,82.79 121.14,82.5 121.14,82.16 120.36,81.38 120.36,81.21 120.71,80.86 120.71,76.8 v1(121.1,76.41)
DDR4_DDIMM_A6: length 74.8
  L03_SIG1 w0.081: v1(138.01,105.87) 138.01,105.48 137.92,105.4 136.16,105.4 136.08,105.32 136.08,105.14 136.16,105.06 137.92,105.06 138.01,104.98 138.01,104.81 137.92,104.73 136.16,104.73 136.08,104.65 136.08,104.47 136.16,104.39 137.92,104.39 138.01,104.31 138.01,104.14 137.92,104.06 136.16,104.06 136.08,103.98 136.08,103.8 136.16,103.72 136.76,103.72 136.85,103.64 136.85,103.04 136.93,102.96 137.1,102.96 137.18,103.04 137.18,103.64 137.26,103.72 137.92,103.72 138.01,103.64 138.01,103.35 136.94,102.29 136.14,102.29 135.92,102.07 135.92,101.6 135.83,101.51 135.16,101.51 135.08,101.43 135.08,101.16 135,101.07 134.83,101.07 134.75,101.16 134.75,101.43 134.66,101.51 134.49,101.51 134.41,101.43 134.41,101.16 134.33,101.07 134.16,101.07 134.08,101.16 134.08,101.43 133.99,101.51 133.82,101.51 133.74,101.59 133.74,102.12 133.66,102.2 133.49,102.2 133.4,102.12 133.4,101.59 133.32,101.51 133.15,101.51 133.07,101.59 133.07,102.12 132.99,102.2 132.82,102.2 132.73,102.12 132.73,101.59 132.65,101.51 132.41,101.51 132.2,101.29 131.29,101.29 130.66,100.67 130.66,100.16 131.02,99.8 131.02,99.68 130.9,99.56 130.78,99.56 130.42,99.92 129.81,99.92 129.61,99.72 129.61,98.95 129.69,98.87 130.64,98.87 130.72,98.79 130.72,98.62 130.64,98.54 129.31,98.54 129.13,98.36 129.13,97.77 129.21,97.69 129.5,97.69 129.58,97.77 129.58,98.03 129.66,98.11 129.84,98.11 129.92,98.03 129.92,97.77 130,97.69 130.41,97.69 130.49,97.6 130.49,97.43 130.41,97.35 129.21,97.35 129.13,97.27 129.13,96.32 128.88,96.07 128.88,95.95 129.07,95.76 129.07,95.64 128.95,95.52 128.83,95.52 128.35,96 128.24,96 128.12,95.89 128.12,95.76 128.6,95.28 128.6,95.17 128.47,95.05 128.36,95.05 128.16,95.24 128.05,95.24 127.93,95.12 127.93,95 128.12,94.81 128.12,94.69 128,94.57 127.89,94.57 127.69,94.77 127.58,94.77 127.37,94.56 127.21,94.56 127.13,94.48 127.13,94.25 127.05,94.17 126.88,94.17 126.8,94.25 126.8,94.48 126.71,94.56 126.29,94.56 126.14,94.42 126.14,94.3 126.88,93.57 126.88,93.46 126.75,93.34 126.64,93.34 125.91,94.07 125.79,94.07 125.67,93.94 125.67,93.83 126.4,93.1 126.4,92.98 126.28,92.86 126.16,92.86 125.43,93.59 125.32,93.59 125.2,93.47 125.2,93.36 125.93,92.62 125.93,92.51 125.8,92.39 125.69,92.39 124.96,93.12 124.84,93.12 122.39,90.67 122.39,90.28 122.7,89.97 122.7,83.59 121.47,82.36 121.47,80.25 121.48,80.24 121.48,75.52 121.81,75.19 v1(121.9,75.03)
DDR4_DDIMM_A7: length 74
  L07_SIG3 w0.089: v1(139.69,100.96) 139.22,100.96 138.29,101.89 137.69,101.89 137.53,102.05 137.53,103.3 137.69,103.47 138.72,103.47 139.8,102.38 140.3,102.38 140.49,102.58 140.49,104.49 141.47,105.47 142.51,105.47 142.98,105.94 144.11,105.94 144.58,105.47 148.25,105.47 149.81,103.9 149.81,99.21 149.52,98.92 149.52,97.02 149.27,96.77 148.37,96.77 146.04,94.45 145.48,94.45 144.92,93.89 142.21,93.89 141.82,94.28 141.82,94.63 141.53,94.92 138.13,94.92 138.03,94.82 138.03,94.33 137.94,94.24 137.77,94.24 137.69,94.33 137.69,94.83 137.6,94.92 137.44,94.92 137.34,94.82 137.34,94.33 137.25,94.24 137.09,94.24 137,94.33 137,94.83 136.91,94.92 135.74,94.92 133.8,92.98 129.99,92.98 129.52,92.51 129.52,92.51 122.21,85.21 122.21,82.12 122.32,82.01 122.32,76.26 122.34,76.24 122.34,75.8 121.98,75.44 121.67,75.44 121.1,74.88 v1(121.1,74.57)
DDR4_DDIMM_A8: length 74.7
  L03_SIG1 w0.081: v1(138.84,105.87) 138.84,106.51 139.06,106.72 141.01,106.72 141.25,106.48 141.25,105.6 141.02,105.37 141.02,105.23 141.1,105.15 141.78,105.15 141.87,105.06 141.87,104.89 141.78,104.81 141.1,104.81 141.02,104.73 141.02,104.52 141.1,104.44 142.27,104.44 142.36,104.36 142.36,104.19 142.27,104.1 141.1,104.1 141.02,104.02 141.02,103.85 141.1,103.77 142.27,103.77 142.36,103.69 142.36,103.52 142.27,103.43 141.1,103.43 141.02,103.35 141.02,101.89 140.83,101.7 140.25,101.7 139.89,101.34 139.54,101.34 139.32,101.12 139.32,100.32 139.4,100.23 139.7,100.23 139.78,100.15 139.78,99.98 139.7,99.9 139.4,99.9 139.32,99.82 139.32,99.65 139.4,99.56 139.7,99.56 139.78,99.48 139.78,99.31 139.7,99.23 139.4,99.23 139.32,99.15 139.32,98.73 138.92,98.32 138.92,98.21 139.45,97.67 139.45,97.56 139.33,97.44 139.22,97.44 138.68,97.97 138.57,97.97 137.94,97.35 134.35,97.35 134.26,97.27 134.26,96.93 134.18,96.85 134.01,96.85 133.93,96.93 133.93,97.27 133.85,97.35 133.06,97.35 132.62,96.91 132.62,96.8 132.99,96.43 132.99,96.32 132.87,96.19 132.75,96.19 132.39,96.56 132.27,96.56 132.15,96.44 132.15,96.32 132.52,95.96 132.52,95.84 132.39,95.72 132.28,95.72 131.91,96.08 131.8,96.08 131.68,95.96 131.68,95.85 132.04,95.48 132.04,95.37 131.92,95.24 131.8,95.24 131.44,95.61 131.32,95.61 129.9,94.19 129.37,94.19 129.16,93.98 129.16,93.45 129.16,93.45 129.16,93 127.73,91.57 127.73,91.46 128.16,91.03 128.16,90.91 128.04,90.79 127.93,90.79 127.5,91.22 127.38,91.22 127.26,91.1 127.26,90.99 127.69,90.56 127.69,90.44 127.57,90.32 127.45,90.32 127.02,90.75 126.91,90.75 126.78,90.63 126.78,90.51 127.21,90.08 127.21,89.97 127.09,89.84 126.98,89.84 126.55,90.27 126.43,90.27 126.31,90.15 126.31,90.04 126.74,89.61 126.74,89.49 126.62,89.37 126.5,89.37 126.07,89.8 125.96,89.8 125.84,89.68 125.84,89.56 126.27,89.13 126.27,89.02 126.14,88.9 126.03,88.9 125.6,89.33 125.48,89.33 125.42,89.26 125.42,89.21 125.11,88.9 125.11,88.78 125.47,88.41 125.47,88.3 125.35,88.18 125.24,88.18 124.87,88.54 124.75,88.54 124.63,88.42 124.63,88.31 125,87.94 125,87.82 124.88,87.7 124.76,87.7 124.39,88.07 124.28,88.07 123.85,87.65 123.85,87.4 123.94,87.32 124.49,87.32 124.58,87.24 124.58,87.06 124.49,86.98 123.94,86.98 123.85,86.9 123.85,86.73 123.94,86.65 124.49,86.65 124.58,86.57 124.58,86.39 124.49,86.31 123.94,86.31 123.85,86.23 123.85,86.06 123.94,85.98 124.49,85.98 124.58,85.9 124.58,85.72 124.49,85.64 123.94,85.64 123.85,85.56 123.85,84.76 123.94,84.68 124.55,84.68 124.63,84.6 124.63,84.43 124.55,84.35 123.94,84.35 123.85,84.27 123.85,84.09 123.94,84.01 124.55,84.01 124.63,83.93 124.63,83.76 124.55,83.68 123.94,83.68 123.85,83.6 123.85,82.98 124.15,82.69 124.15,81.73 123.92,81.49 arc(123.92,81.45) 123.91,81.41 123.85,81.19 arc(123.83,80.98) 123.89,80.78 123.91,80.75 arc(123.95,80.54) 123.89,80.32 123.89,80.31 arc(123.83,80.09) 123.89,79.86 arc(123.95,79.63) 123.89,79.4 arc(123.83,79.17) 123.89,78.94 123.89,78.94 arc(123.95,78.71) 123.89,78.48 arc(123.83,78.25) 123.89,78.02 arc(123.95,77.79) 123.89,77.56 123.89,77.56 arc(123.83,77.33) 123.89,77.1 arc(123.95,76.88) 123.9,76.66 123.65,76.17 arc(123.58,76.05) v1(123.49,75.95)
DDR4_DDIMM_A9: length 74.9
  L03_SIG1 w0.081: v1(122.7,76.41) 122.7,76.81 122.33,77.18 122.33,80.85 122.32,80.86 122.32,81.16 122.33,81.17 122.33,82.01 122.22,82.12 122.22,82.48 123.13,83.39 123.13,89.17 123.5,89.53 123.5,89.65 122.73,90.42 122.73,90.53 122.85,90.65 122.97,90.65 123.73,89.89 123.85,89.89 123.97,90.01 123.97,90.12 123.2,90.89 123.2,91 123.33,91.13 123.44,91.13 124.21,90.36 124.32,90.36 124.44,90.48 124.44,90.6 123.68,91.36 123.68,91.48 123.8,91.6 123.91,91.6 124.68,90.83 124.8,90.83 124.92,90.96 124.92,91.07 124.15,91.84 124.15,91.95 124.27,92.08 124.39,92.08 125.16,91.31 125.27,91.31 125.39,91.43 125.39,91.55 124.63,92.31 124.63,92.43 124.75,92.55 124.86,92.55 125.63,91.78 125.74,91.78 130.3,96.34 130.3,96.65 130.82,97.17 130.82,98.15 131.04,98.37 131.27,98.37 132.13,99.23 132.13,99.34 131.27,100.21 131.27,100.32 131.39,100.45 131.5,100.45 132.37,99.58 132.48,99.58 132.61,99.71 132.74,99.71 132.82,99.79 132.82,100.48 132.92,100.58 133.07,100.58 133.16,100.5 133.16,99.79 133.24,99.71 133.41,99.71 133.49,99.79 133.49,100.48 133.59,100.58 133.75,100.58 133.83,100.5 133.83,99.79 133.91,99.71 133.96,99.71 133.96,99.71 134.16,99.71 134.24,99.63 134.24,99.16 134.33,99.08 134.5,99.08 134.58,99.16 134.58,100.58 134.66,100.66 134.82,100.66 134.92,100.57 134.92,99.16 135,99.08 135.17,99.08 135.25,99.16 135.25,100.44 135.33,100.52 136.01,100.52 136.12,100.41 136.12,98.75 136.2,98.67 136.37,98.67 136.45,98.75 136.45,100.2 136.54,100.28 136.69,100.28 136.79,100.18 136.79,98.75 136.87,98.67 137.04,98.67 137.12,98.75 137.12,99.63 137.57,100.07 137.74,100.07 138.07,99.74 138.18,99.74 138.31,99.86 138.31,99.97 137.97,100.31 137.97,100.42 138.47,100.92 138.47,102.2 138.69,102.42 139.92,102.42 140.33,102.83 140.33,103.25 140.18,103.4 139.39,103.4 139.31,103.48 139.31,103.65 139.39,103.73 140.18,103.73 140.27,103.82 140.27,103.99 140.18,104.07 139.39,104.07 139.31,104.15 139.31,104.32 139.39,104.41 140.18,104.41 140.27,104.49 140.27,104.66 140.18,104.74 139.39,104.74 139.31,104.82 139.31,104.99 139.39,105.08 140.18,105.08 140.27,105.16 140.27,105.68 140.48,105.9 v1(140.55,105.9)
DDR4_DDIMM_A10: length 75.1
  L05_SIG2 w0.081: v1(122.69,100.96) 122.36,100.96 122.28,101.05 122.28,101.59 122.19,101.67 122.02,101.67 121.94,101.59 121.94,101.05 121.86,100.96 121.68,100.96 121.42,101.22 121.42,102.03 121.34,102.12 121.15,102.12 121.07,102.03 121.07,101.77 120.99,101.69 120.82,101.69 120.74,101.77 120.74,101.96 120.66,102.04 120.48,102.04 120.4,101.96 120.4,101.77 120.32,101.69 120.15,101.69 120.07,101.77 120.07,101.96 119.99,102.04 119.85,102.04 119.32,101.51 119.32,100.59 119.76,100.15 120.49,100.15 120.72,99.92 120.72,99.62 120.8,99.54 122.26,99.54 122.34,99.46 122.34,99.28 122.26,99.2 122.2,99.2 122.12,99.12 122.12,98.56 122.04,98.48 121.89,98.48 121.79,98.58 121.79,99.12 121.71,99.2 121.53,99.2 121.45,99.12 121.45,98.73 121.37,98.65 121.2,98.65 121.12,98.73 121.12,99.12 121.04,99.2 120.8,99.2 120.72,99.12 120.72,98.57 120.56,98.41 120.55,98.42 120.18,98.42 120.03,98.26 120.03,97.82 120.11,97.74 121.99,97.74 122.37,98.12 122.59,98.12 122.67,98.04 122.67,97.88 122.2,97.41 120.11,97.41 120.03,97.33 120.03,97.15 120.11,97.07 122,97.07 122.08,96.99 122.08,96.82 122,96.74 120.11,96.74 120.03,96.66 120.03,96.48 120.11,96.4 122.56,96.4 122.65,96.32 122.65,96.16 122.55,96.07 120.11,96.07 120.03,95.99 120.03,95.81 120.11,95.73 122.4,95.73 122.48,95.65 122.48,95.49 122.39,95.4 120.11,95.4 120.03,95.32 120.03,94.96 120.16,94.82 120.27,94.82 120.35,94.74 120.35,94.49 120.43,94.41 120.6,94.41 120.68,94.49 120.68,94.92 120.77,95 120.93,95 121.02,94.91 121.02,94.49 121.1,94.41 121.27,94.41 121.35,94.49 121.35,94.74 121.54,94.93 122.25,94.93 122.33,94.85 122.33,94.54 122.41,94.46 122.59,94.46 122.67,94.54 122.67,94.85 122.75,94.93 123.18,94.93 123.31,94.79 123.31,94.08 123.61,93.79 123.61,90.95 122.51,89.86 121.64,89.86 121.56,89.78 121.56,89.12 121.47,89.04 121.3,89.04 121.22,89.12 121.22,89.78 121.14,89.86 120.97,89.86 120.89,89.78 120.89,88.78 121.03,88.64 121.57,88.64 121.65,88.56 121.65,87.89 121.73,87.81 122.62,87.81 122.71,87.73 122.71,87.44 122.63,87.35 122.34,87.35 122.26,87.27 122.26,87.12 122.36,87.02 122.63,87.02 122.71,86.94 122.71,86.76 122.63,86.68 122.34,86.68 122.26,86.6 122.26,86.45 122.36,86.35 122.63,86.35 122.71,86.27 122.71,86.09 122.63,86.01 122.34,86.01 122.26,85.93 122.26,85.78 122.36,85.68 122.63,85.68 122.71,85.6 122.71,85.42 122.63,85.34 122.34,85.34 122.26,85.26 122.26,85.11 122.36,85.01 122.63,85.01 122.71,84.93 122.71,82.78 122.61,82.68 122.45,82.68 122.22,82.45 122.22,81.85 122.31,81.77 122.55,81.77 122.63,81.68 122.63,81.51 122.55,81.43 122.3,81.43 122.22,81.35 122.22,81.08 arc(122.24,80.93) 122.3,80.78 122.31,80.75 arc(122.36,80.53) 122.3,80.32 122.3,80.31 arc(122.24,80.09) 122.3,79.86 arc(122.36,79.63) 122.3,79.4 122.3,79.4 arc(122.24,79.17) 122.3,78.94 arc(122.36,78.71) 122.3,78.48 122.3,78.48 arc(122.24,78.25) 122.3,78.02 arc(122.36,77.79) 122.3,77.56 122.3,77.56 arc(122.24,77.33) 122.3,77.1 arc(122.36,76.88) 122.31,76.66 122.3,76.64 arc(122.26,76.57) 122.24,76.49 122.24,76.27 122.56,75.95 122.7,75.95 arc(122.92,75.89) 123.09,75.73 123.1,75.71 arc(123.16,75.48) 123.09,75.26 v1(122.7,74.57)
DDR4_DDIMM_A11: length 75.6
  L03_SIG1 w0.081: v1(140.54,100.96) 140.97,100.53 143.66,100.53 144.66,101.53 144.66,103.82 144.58,103.9 143.48,103.9 143.4,103.98 143.4,104.15 143.48,104.23 144.58,104.23 144.66,104.32 144.66,104.56 144.38,104.84 144.38,106.09 144.29,106.17 143.42,106.17 143.34,106.25 143.34,106.43 143.42,106.51 144.29,106.51 144.38,106.59 144.38,107.08 144.49,107.2 145.05,107.2 145.19,107.05 145.19,106.27 145.27,106.19 145.53,106.19 145.61,106.11 145.61,105.94 145.53,105.85 145.27,105.85 145.19,105.77 145.19,105.6 145.27,105.52 145.53,105.52 145.61,105.44 145.61,105.27 145.53,105.18 145.27,105.18 145.19,105.1 145.19,104.93 145.27,104.85 145.53,104.85 145.61,104.77 145.61,104.6 145.53,104.51 145.27,104.51 145.19,104.43 145.19,104.26 145.27,104.18 145.53,104.18 145.61,104.1 145.61,103.92 145.53,103.84 145.27,103.84 145.19,103.76 145.19,101.12 144.82,100.75 144.82,100.21 144.32,99.72 143.74,99.72 143.52,99.5 143.52,98.91 143.28,98.67 143.16,98.67 142.57,99.26 142.45,99.26 142.33,99.14 142.33,99.03 142.93,98.43 142.93,98.32 142.16,97.55 142.04,97.55 140.96,98.64 140.84,98.64 140.73,98.52 140.73,98.39 141.81,97.31 141.81,97.2 141.68,97.08 141.57,97.08 140.91,97.74 140.8,97.74 140.67,97.61 140.67,97.5 141.33,96.84 141.33,96.72 141.17,96.56 140.54,96.56 140.45,96.48 140.45,96.27 140.37,96.19 140.2,96.19 140.12,96.27 140.12,96.48 140.04,96.56 139.87,96.56 139.78,96.48 139.78,96.27 139.7,96.19 139.53,96.19 139.45,96.27 139.45,96.48 139.37,96.56 139.19,96.56 139.11,96.48 139.11,96.27 139.03,96.19 138.86,96.19 138.78,96.27 138.78,96.48 138.7,96.56 138.52,96.56 138.44,96.48 138.44,96.27 138.36,96.19 138.19,96.19 138.11,96.27 138.11,96.48 138.03,96.56 137.85,96.56 137.77,96.48 137.77,96.27 137.69,96.19 137.52,96.19 137.44,96.27 137.44,96.48 137.36,96.56 137.18,96.56 137.1,96.48 137.1,96.27 137.02,96.19 136.85,96.19 136.77,96.27 136.77,96.48 136.69,96.56 136.51,96.56 136.43,96.48 136.43,96.27 136.35,96.19 136.18,96.19 136.1,96.27 136.1,96.48 136.01,96.56 134.93,96.56 134.55,96.17 133.88,96.17 132.53,94.82 132.53,94.15 125.75,87.37 125.75,85.62 125.45,85.31 125.45,84.97 125.7,84.72 125.7,83.17 125.21,82.68 125.21,81.56 125.51,81.25 125.51,75.72 125.23,75.44 124.97,75.44 124.56,75.03 v1(123.49,75.03)
DDR4_DDIMM_A12: length 71.2
  L07_SIG3 w0.089: v1(141.39,106.96) 141.39,107.23 141.66,107.5 152.81,107.5 153.67,106.64 153.67,105.23 153.67,105.22 153.67,104.94 153.3,104.57 153.3,104.26 153.67,103.89 153.67,93.06 151.47,90.86 133.34,90.86 125.67,83.19 125.67,81.92 126.28,81.31 126.28,72.45 126.09,72.27 v1(125.09,72.27)
DDR4_DDIMM_A13: length 70.3
  L05_SIG2 w0.081: v1(116.74,100.96) 116.74,101.41 117.06,101.72 117.06,102.32 117.52,102.78 117.52,104.06 117.94,104.48 118.18,104.48 118.37,104.68 118.37,104.91 118.61,105.15 119.6,105.15 119.69,105.25 123.14,105.25 123.24,105.15 123.85,105.15 123.94,105.25 124.97,105.25 125.84,106.12 129.84,106.12 129.92,106.04 129.92,105.41 129.71,105.19 128.89,105.19 128.49,104.78 128.49,98.01 128.28,97.81 128.28,94.62 128.2,94.53 126.14,94.53 126.05,94.45 126.05,94.29 126.14,94.2 128.2,94.2 128.28,94.12 128.28,93.95 128.2,93.86 126.14,93.86 126.05,93.78 126.05,93.62 126.14,93.53 128.2,93.53 128.28,93.45 128.28,93.07 127.81,92.6 127.69,92.6 127.2,93.1 127.08,93.1 126.96,92.97 126.96,92.86 127.46,92.36 127.46,92.25 127.33,92.13 127.22,92.13 126.24,93.1 126.13,93.1 126.02,93 126.02,92.85 126.98,91.89 126.98,91.77 126.72,91.51 126.6,91.51 126.18,91.94 126.06,91.94 125.94,91.81 125.94,91.7 126.37,91.27 126.37,91.16 125.75,90.55 125.75,88.82 125.5,88.57 124.67,88.57 124.58,88.49 124.58,88.32 124.67,88.23 125.03,88.23 125.11,88.15 125.11,87.98 125.03,87.9 124.67,87.9 124.58,87.82 124.58,87.65 124.67,87.56 125.03,87.56 125.11,87.48 125.11,87.31 125.03,87.23 124.67,87.23 124.58,87.15 124.58,86.98 124.67,86.89 125.03,86.89 125.11,86.81 125.11,86.64 125.03,86.56 124.67,86.56 124.58,86.48 124.58,86.3 124.67,86.22 125.03,86.22 125.11,86.14 125.11,81.83 125.28,81.36 125.48,80.78 125.5,80.76 arc(125.55,80.54) 125.49,80.32 125.48,80.31 arc(125.42,80.09) 125.49,79.86 arc(125.55,79.63) 125.49,79.4 125.48,79.4 arc(125.42,79.17) 125.49,78.94 arc(125.55,78.71) 125.49,78.48 125.49,78.48 arc(125.42,78.25) 125.49,78.02 arc(125.65,77.86) 125.86,77.79 125.88,77.79 arc(126.11,77.73) 126.28,77.56 126.28,77.56 arc(126.34,77.33) 126.28,77.1 126.27,77.08 arc(126.22,76.86) 126.28,76.64 arc(126.34,76.42) 126.29,76.19 126.28,76.18 arc(126.22,75.95) 126.28,75.72 126.29,75.71 arc(126.34,75.48) 126.28,75.26 arc(126.22,75.03) 126.28,74.8 126.28,74.8 v1(126.68,74.11)
DDR4_DDIMM_A14: length 70.2
  L05_SIG2 w0.081: v1(125.88,73.65) 125.09,73.65 arc(124.69,73.87) 124.68,74.33 124.7,74.35 arc(124.75,74.58) 124.69,74.8 124.69,74.8 arc(124.63,75.03) 124.69,75.26 arc(124.75,75.48) 124.7,75.71 124.69,75.72 arc(124.63,75.95) 124.69,76.18 124.69,76.19 arc(124.69,76.64) 124.3,76.87 124.27,76.87 arc(123.89,77.11) 123.89,77.56 123.89,77.56 arc(123.95,77.79) 123.89,78.02 arc(123.83,78.25) 123.89,78.48 arc(123.95,78.71) 123.89,78.94 123.89,78.94 arc(123.83,79.17) 123.89,79.4 arc(123.95,79.63) 123.89,79.86 arc(123.83,80.09) 123.89,80.31 123.89,80.32 arc(123.95,80.54) 123.91,80.75 123.6,81.76 123.6,81.85 123.84,82.08 123.84,82.41 123.6,82.64 123.46,82.64 123.38,82.73 123.38,82.92 123.46,83 123.6,83 123.68,83.08 123.68,83.26 123.6,83.34 123.46,83.34 123.38,83.42 123.38,84.87 123.46,84.95 123.77,84.95 123.85,85.03 123.85,85.2 123.77,85.28 123.46,85.28 123.38,85.36 123.38,85.54 123.46,85.62 123.77,85.62 123.85,85.7 123.85,85.87 123.77,85.95 123.46,85.95 123.38,86.03 123.38,89.04 123.46,89.12 124.04,89.12 124.12,89.2 124.12,89.38 124.04,89.46 123.46,89.46 123.38,89.54 123.38,89.78 124.39,90.79 124.39,94.01 123.99,94.41 123.99,94.91 124.19,95.11 125.11,95.11 125.25,95.25 125.25,95.39 125.17,95.47 123.67,95.47 123.59,95.55 123.59,95.72 123.67,95.81 125.17,95.81 125.25,95.89 125.25,96.06 125.17,96.14 123.67,96.14 123.59,96.22 123.59,96.39 123.67,96.48 125.17,96.48 125.25,96.56 125.25,97.45 125.17,97.54 124.05,97.54 123.96,97.62 123.96,97.79 124.05,97.87 125.17,97.87 125.25,97.95 125.25,98.12 125.17,98.21 124.05,98.21 123.96,98.29 123.96,98.46 124.05,98.54 125.17,98.54 125.25,98.62 125.25,98.8 125.35,98.89 127.46,98.89 127.59,99.01 127.59,99.27 127.5,99.35 126.59,99.35 126.51,99.43 126.51,99.6 126.59,99.68 127.5,99.68 127.59,99.76 127.59,99.94 127.5,100.02 126.59,100.02 126.51,100.1 126.51,100.27 126.59,100.35 127.5,100.35 127.59,100.43 127.59,100.61 127.5,100.69 126.59,100.69 126.51,100.77 126.51,100.94 126.59,101.02 127.5,101.02 127.59,101.1 127.59,101.28 127.5,101.36 126.59,101.36 126.51,101.44 126.51,101.61 126.59,101.69 127.5,101.69 127.59,101.77 127.59,101.96 127.5,102.04 126.15,102.04 126.02,101.92 126.02,100.66 125.59,100.23 124.66,100.23 124.58,100.14 124.58,99.13 124.5,99.05 124.32,99.05 124.24,99.13 124.24,100.14 124.16,100.23 123.99,100.23 123.91,100.14 123.91,99.13 123.83,99.05 123.65,99.05 123.57,99.13 123.57,100.14 123.49,100.23 121.36,100.23 120.63,100.96 v1(120.14,100.96)
DDR4_DDIMM_A15: length 71.7
  L05_SIG2 w0.081: v1(126.68,72.27) 126.6,72.27 125.31,70.97 124.83,70.97 124.69,71.12 124.68,71.13 arc(124.51,71.29) 124.29,71.35 arc(124.06,71.41) 123.89,71.58 arc(123.73,71.74) 123.51,71.81 123.49,71.81 arc(123.27,71.75) 123.1,71.59 123.09,71.57 arc(122.92,71.41) 122.7,71.35 arc(122.47,71.41) 122.3,71.58 arc(122.14,71.74) 121.91,71.81 121.9,71.81 arc(121.68,71.87) 121.51,72.03 121.49,72.05 arc(121.33,72.21) 121.1,72.27 121.09,72.27 arc(120.87,72.33) 120.7,72.5 arc(120.54,72.66) 120.32,72.73 120.31,72.73 arc(120.08,72.79) 119.92,72.94 119.9,72.97 arc(119.73,73.13) 119.51,73.19 119.45,73.19 arc(119.26,73.15) 119.11,73.05 118.98,72.92 arc(118.6,72.79) 118.26,73 arc(118.11,73.14) 117.92,73.19 117.91,73.19 arc(117.68,73.25) 117.52,73.42 arc(117.35,73.59) 117.13,73.65 117.12,73.65 arc(116.89,73.71) 116.72,73.87 116.72,73.88 arc(116.55,74.05) 116.33,74.11 116.3,74.11 arc(116.08,74.18) 115.92,74.34 arc(115.76,74.5) 115.55,74.57 115.52,74.57 arc(115.29,74.63) 115.13,74.8 arc(114.96,74.97) 114.73,75.03 114.73,75.03 arc(114.5,75.09) 114.33,75.25 114.33,75.26 arc(114.16,75.43) 113.93,75.49 arc(113.79,75.51) 113.66,75.58 113.53,75.71 113.53,78.84 114.11,79.42 114.11,81.15 114,81.26 114,82.41 112.94,83.47 112.94,84.48 112.94,84.48 112.94,85.01 112.62,85.33 112.62,86.26 112,86.87 112,87.04 110.49,88.56 110.49,90.16 108.61,92.03 108.61,93.54 107.47,94.69 106.83,94.69 105.22,96.3 105.22,97.29 104.93,97.59 102.99,97.59 102.72,97.87 102.72,107.67 102.96,107.91 118.62,107.91 118.8,107.73 118.8,107.19 v1(118.44,106.84)
DDR4_DDIMM_A16: length 72.3
  L05_SIG2 w0.081: v1(125.88,72.73) 125.09,72.73 arc(124.86,72.79) 124.69,72.95 124.68,72.97 arc(124.51,73.13) 124.29,73.19 124.29,73.19 arc(124.06,73.25) 123.89,73.42 arc(123.83,73.65) 123.89,73.88 123.9,73.89 arc(123.95,74.12) 123.89,74.34 arc(123.83,74.56) 123.88,74.79 123.89,74.8 arc(123.95,75.03) 123.89,75.26 123.88,75.27 arc(123.83,75.5) 123.89,75.72 123.89,75.72 arc(123.95,75.95) 123.89,76.18 arc(123.73,76.34) 123.51,76.41 123.49,76.41 arc(123.26,76.47) 123.09,76.64 arc(123.03,76.86) 123.08,77.08 123.1,77.1 arc(123.16,77.33) 123.1,77.56 123.1,77.56 arc(123.03,77.79) 123.1,78.02 arc(123.16,78.25) 123.1,78.48 123.09,78.48 arc(123.03,78.71) 123.1,78.94 arc(123.16,79.17) 123.1,79.4 123.09,79.4 arc(123.03,79.63) 123.1,79.86 arc(123.16,80.08) 123.1,80.31 arc(123.08,80.34) 123.05,80.37 123.07,80.39 123.07,82.06 123.04,82.08 123.04,88.15 122.96,88.23 122.13,88.23 122.05,88.31 122.05,88.49 122.13,88.57 122.96,88.57 123.04,88.65 123.04,88.82 122.96,88.9 122.13,88.9 122.05,88.98 122.05,89.16 122.13,89.24 122.96,89.24 123.04,89.32 123.04,89.92 123.94,90.81 123.94,93.99 123.66,94.27 123.66,94.92 123.23,95.35 123.23,95.86 123.06,96.02 123.06,99.66 122.84,99.89 121.23,99.89 120.63,100.49 120.1,100.49 119.77,100.81 119.77,101.14 119.98,101.35 120.72,101.35 121.5,100.56 125.45,100.56 125.67,100.79 125.67,101.26 125.43,101.5 123.56,101.5 123.15,101.91 123.15,104.62 122.87,104.9 119.82,104.9 119.73,104.81 119.07,104.81 118.07,103.81 118.07,100.69 117.94,100.56 116.58,100.56 116.33,100.81 116.33,101.47 116.73,101.86 116.73,102.46 117.19,102.92 117.19,104.77 117.21,104.77 117.92,105.48 119.46,105.48 119.69,105.72 119.69,106.48 120.17,106.96 120.64,106.96 120.72,106.88 120.72,106.38 120.8,106.29 120.97,106.29 121.06,106.38 121.06,106.88 121.14,106.96 v1(121.84,106.96)
DDR4_DDIMM_A17: length 73.6
  TOP w0.149: J2.234 115.04,102.72 115.2,102.88 115.24,102.88 115.44,103.08 v1(116.82,103.08)
  L05_SIG2 w0.081: v1(128.27,74.11) 127.88,74.8 127.87,74.8 arc(127.81,75.03) 127.88,75.26 arc(127.94,75.48) 127.88,75.71 127.87,75.72 arc(127.81,75.95) 127.88,76.18 127.88,76.19 arc(127.94,76.41) 127.88,76.64 arc(127.81,76.86) 127.87,77.08 127.88,77.1 arc(127.94,77.33) 127.88,77.56 127.88,77.56 arc(127.81,77.79) 127.88,78.02 arc(127.94,78.25) 127.88,78.48 127.87,78.5 arc(127.7,78.65) 127.48,78.71 arc(127.25,78.77) 127.09,78.92 127.08,78.94 127.08,79.4 arc(127.14,79.61) 127.1,79.83 arc(127.06,79.92) 127.05,80.03 127.05,80.94 arc(127.04,81.02) 126.99,81.09 126.93,81.15 arc(126.86,81.25) 126.81,81.36 arc(126.79,81.43) 126.78,81.51 126.78,82.12 arc(126.78,82.16) 126.75,82.2 126.3,82.65 126.3,83.67 126.43,83.8 126.43,90.27 128.95,92.8 128.95,94.65 129.03,94.73 129.38,94.73 129.46,94.81 129.46,94.99 129.38,95.07 129.03,95.07 128.95,95.15 128.95,95.32 129.03,95.4 129.38,95.4 129.46,95.48 129.46,95.66 129.38,95.74 129.03,95.74 128.95,95.82 128.95,95.99 129.03,96.07 129.38,96.07 129.46,96.15 129.46,96.33 129.38,96.41 129.03,96.41 128.95,96.49 128.95,97.24 129.03,97.32 129.27,97.32 129.35,97.41 129.35,97.52 129.16,97.72 129.16,103.01 129.68,103.53 132.35,103.53 132.46,103.65 132.46,107.5 132.26,107.7 131.75,107.7 131.67,107.78 131.67,108.1 131.59,108.18 131.42,108.18 131.33,108.1 131.33,107.78 131.25,107.7 131.08,107.7 131,107.78 131,108.1 130.92,108.18 130.74,108.18 130.66,108.1 130.66,107.78 130.58,107.7 130.41,107.7 130.33,107.78 130.33,108.1 130.25,108.18 130.07,108.18 129.99,108.1 129.99,107.78 129.91,107.7 129.74,107.7 129.66,107.78 129.66,108.1 129.58,108.18 129.4,108.18 129.32,108.1 129.32,107.78 129.24,107.7 129.07,107.7 128.99,107.78 128.99,108.1 128.91,108.18 128.73,108.18 128.65,108.1 128.65,107.78 128.57,107.7 128.4,107.7 128.32,107.78 128.32,108.1 128.24,108.18 128.06,108.18 127.98,108.1 127.98,107.78 127.9,107.7 127.73,107.7 127.65,107.78 127.65,108.1 127.56,108.18 127.39,108.18 127.31,108.1 127.31,107.78 127.23,107.7 127.06,107.7 126.98,107.78 126.98,108.1 126.89,108.18 126.72,108.18 126.64,108.1 126.64,107.78 126.56,107.7 126.39,107.7 126.31,107.78 126.31,108.1 126.22,108.18 126.05,108.18 125.97,108.1 125.97,107.78 125.89,107.7 125.72,107.7 125.63,107.78 125.63,108.1 125.55,108.18 125.38,108.18 125.3,108.1 125.3,107.78 125.22,107.7 125.05,107.7 124.84,107.49 124.84,106.5 124.52,106.17 123.83,106.17 123.69,106.31 123.69,107.18 123.45,107.42 120.09,107.42 118.65,105.98 117.94,105.98 117.11,105.15 116.61,105.15 116.41,104.95 116.41,103.41 116.75,103.08 v1(116.82,103.08)
DDR4_DDIMM_ACT_N: length 71.4
  L03_SIG1 w0.081: v1(119.51,72.73) 119.51,72.92 120.15,73.56 120.28,73.56 120.74,74.02 121.09,74.02 121.56,74.48 122.09,74.48 122.54,74.94 122.88,74.94 123.44,75.5 123.62,75.5 124.16,76.04 124.44,76.04 124.72,76.31 124.72,80.7 125.02,81.01 125.02,81.27 124.87,81.42 124.87,82.82 125.02,82.97 125.02,87.29 128.81,91.08 128.81,91.2 128.39,91.62 128.39,91.74 128.51,91.86 128.62,91.86 129.05,91.43 129.16,91.43 129.28,91.56 129.28,91.67 128.86,92.1 128.86,92.21 128.98,92.33 129.1,92.33 129.52,91.91 129.64,91.91 129.76,92.03 129.76,92.15 129.34,92.57 129.34,92.68 129.46,92.81 129.57,92.81 130,92.38 130.11,92.38 130.23,92.5 130.23,92.62 129.81,93.04 129.81,93.16 129.93,93.28 130.05,93.28 130.47,92.86 130.59,92.86 130.8,93.07 130.8,93.59 131.03,93.82 131.55,93.82 132.19,94.47 132.19,94.96 133.74,96.51 134.41,96.51 134.8,96.89 139.39,96.89 140.13,97.63 140.13,99.71 140.21,99.79 143.15,99.79 143.24,99.87 143.24,100.04 143.15,100.12 140.21,100.12 140.13,100.2 140.13,101.1 140.39,101.37 142.57,101.37 142.76,101.55 142.76,101.76 142.84,101.84 143.45,101.84 143.53,101.92 143.53,102.1 143.45,102.18 142.84,102.18 142.76,102.26 142.76,102.43 142.84,102.51 143.61,102.51 143.69,102.6 143.69,102.77 143.61,102.85 142.84,102.85 142.76,102.93 142.76,103.1 142.84,103.18 143.45,103.18 143.53,103.27 143.53,103.44 143.45,103.52 142.84,103.52 142.76,103.6 142.76,104.52 142.84,104.6 143.93,104.6 144.01,104.68 144.01,104.86 143.93,104.94 142.84,104.94 142.64,105.14 142.64,106.06 142.25,106.45 142.25,107.12 142.38,107.25 142.63,107.25 142.71,107.17 142.71,106.58 143.01,106.28 143.01,105.56 143.16,105.4 v1(143.89,105.4)
DDR4_DDIMM_ALERT_N: length 67.1
  L05_SIG2 w0.081: v1(127.48,71.81) 127.48,71.58 127.59,71.47 128.11,71.47 128.67,72.04 arc(128.83,72.2) 129.05,72.26 129.13,72.26 arc(129.36,72.32) 129.52,72.48 129.53,72.49 arc(129.7,72.66) 129.93,72.72 arc(130.08,72.77) 130.21,72.88 130.27,72.96 arc(130.27,72.96) 130.27,72.97 arc(130.33,73.19) 130.27,73.42 arc(130.2,73.65) 130.26,73.88 130.27,73.88 arc(130.33,74.11) 130.27,74.34 arc(130.2,74.56) 130.26,74.79 130.27,74.8 arc(130.33,75.03) 130.27,75.26 130.26,75.27 arc(130.2,75.49) 130.27,75.72 130.27,75.72 arc(130.33,75.95) 130.27,76.18 arc(130.2,76.4) 130.26,76.63 130.28,76.66 arc(130.33,76.88) 130.27,77.1 arc(130.2,77.33) 130.26,77.56 130.27,77.56 arc(130.33,77.79) 130.27,78.02 arc(130.2,78.25) 130.27,78.48 arc(130.33,78.7) 130.28,78.92 130.26,78.95 129.55,79.66 129.55,82.04 128.72,82.88 128.72,86.52 128.52,86.71 128.52,90.01 131.66,93.15 131.66,100.73 132.78,101.86 134.1,101.86 134.52,101.44 135.49,101.44 135.62,101.31 135.63,101.31 136.42,100.52 144.68,100.52 145.32,99.89 149.89,99.89 150.14,100.13 150.14,103 149.91,103.24 147.8,103.24 147.68,103.11 147.68,100.83 147.48,100.63 146.94,100.63 146.85,100.54 146.06,100.54 145.64,100.96 v1(142.24,100.96)
DDR4_DDIMM_BA0: length 72.4
  L05_SIG2 w0.081: v1(127.48,73.65) 127.08,74.34 arc(127.02,74.56) 127.07,74.79 127.08,74.8 arc(127.14,75.03) 127.08,75.26 127.07,75.27 arc(127.02,75.5) 127.08,75.72 127.08,75.72 arc(127.14,75.95) 127.08,76.18 arc(127.02,76.4) 127.07,76.63 127.09,76.66 arc(127.14,76.88) 127.08,77.1 arc(127.02,77.33) 127.08,77.56 127.08,77.56 arc(127.14,77.79) 127.08,78.02 arc(126.92,78.18) 126.7,78.25 126.68,78.25 arc(126.46,78.31) 126.29,78.46 126.28,78.48 arc(126.22,78.71) 126.28,78.94 arc(126.34,79.17) 126.29,79.4 126.28,79.4 arc(126.22,79.63) 126.28,79.86 arc(126.34,80.09) 126.29,80.31 126.28,80.32 arc(126.27,80.34) 126.27,80.36 126.27,81.19 125.45,82.01 125.45,82.84 125.53,82.92 125.86,82.92 125.94,83 125.94,83.17 125.86,83.25 125.53,83.25 125.45,83.33 125.45,83.51 125.53,83.59 125.86,83.59 125.94,83.67 125.94,83.84 125.86,83.92 125.53,83.92 125.45,84 125.45,84.18 125.53,84.26 126.01,84.26 126.09,84.34 126.09,84.52 126.01,84.59 125.53,84.59 125.45,84.68 125.45,85.71 125.53,85.79 125.96,85.79 126.04,85.87 126.04,86.04 125.96,86.12 125.53,86.12 125.45,86.2 125.45,86.38 125.53,86.46 125.96,86.46 126.04,86.54 126.04,86.71 125.96,86.79 125.53,86.79 125.45,86.87 125.45,87.05 125.53,87.13 125.96,87.13 126.04,87.21 126.04,87.38 125.96,87.46 125.53,87.46 125.45,87.55 125.45,87.92 126.09,88.56 126.09,90.41 128.62,92.93 128.62,97.38 128.82,97.59 128.82,103.21 129.55,103.94 130.18,103.94 130.26,104.02 130.26,104.44 130.18,104.52 129.55,104.52 129.47,104.6 129.47,104.77 129.55,104.85 130.18,104.85 130.26,104.94 130.26,105.09 130.34,105.17 130.52,105.17 130.6,105.09 130.6,104.02 130.68,103.94 130.85,103.94 130.93,104.02 130.93,105.09 131.02,105.17 131.19,105.17 131.27,105.09 131.27,104.02 131.35,103.94 131.51,103.94 131.69,104.11 131.69,104.65 131.77,104.74 132.03,104.74 132.11,104.82 132.11,104.99 132.03,105.07 131.77,105.07 131.69,105.15 131.69,105.32 131.77,105.41 132.03,105.41 132.11,105.49 132.11,105.66 132.03,105.74 131.77,105.74 131.69,105.82 131.69,107.18 131.51,107.35 129.8,107.35 129.72,107.27 129.72,106.72 129.64,106.64 129.47,106.64 129.39,106.72 129.39,107.27 129.3,107.35 129.13,107.35 129.05,107.27 129.05,106.72 128.97,106.64 128.8,106.64 128.71,106.72 128.71,107.27 128.63,107.35 128.46,107.35 128.38,107.27 128.38,106.72 128.3,106.64 128.13,106.64 128.04,106.72 128.04,107.27 127.96,107.35 127.79,107.35 127.71,107.27 127.71,106.72 127.63,106.64 127.45,106.64 127.37,106.72 127.37,107.27 127.29,107.35 127.12,107.35 127.04,107.27 127.04,106.72 126.96,106.64 126.78,106.64 126.7,106.72 126.7,107.27 126.62,107.35 126.45,107.35 126.37,107.27 126.37,106.72 126.29,106.64 126.11,106.64 126.03,106.72 126.03,107.27 125.95,107.35 125.78,107.35 125.62,107.2 125.62,106.55 124.65,105.58 123.81,105.58 123.71,105.48 123.38,105.48 123.28,105.58 121.98,105.58 121.72,105.84 121.72,106.08 121.91,106.28 122.12,106.28 122.31,106.09 122.42,106.09 122.55,106.21 122.55,106.32 122.36,106.51 122.36,106.63 v1(122.69,106.96)
DDR4_DDIMM_BA1: length 72.3
  L05_SIG2 w0.081: v1(127.48,72.73) 127.08,73.42 arc(126.91,73.59) 126.69,73.65 126.68,73.65 arc(126.45,73.71) 126.29,73.87 126.28,73.88 arc(126.12,74.05) 125.89,74.11 125.87,74.11 arc(125.65,74.17) 125.49,74.34 arc(125.42,74.56) 125.48,74.79 125.49,74.8 arc(125.55,75.03) 125.49,75.26 125.48,75.27 arc(125.42,75.5) 125.49,75.72 125.49,75.72 arc(125.55,75.95) 125.49,76.18 arc(125.42,76.4) 125.48,76.63 125.5,76.66 arc(125.55,76.88) 125.49,77.1 arc(125.33,77.26) 125.11,77.33 125.09,77.33 arc(124.87,77.39) 124.7,77.54 124.69,77.56 arc(124.63,77.79) 124.69,78.02 arc(124.75,78.25) 124.69,78.48 arc(124.63,78.71) 124.69,78.94 124.69,78.94 arc(124.75,79.17) 124.69,79.4 arc(124.63,79.63) 124.69,79.86 arc(124.75,80.09) 124.69,80.31 124.67,80.35 arc(124.63,80.56) 124.69,80.78 arc(124.73,80.89) 124.75,81.01 124.78,81.04 124.78,81.57 124.7,81.65 124.27,81.65 124.19,81.73 124.19,81.9 124.27,81.98 124.7,81.98 124.78,82.07 124.78,82.24 124.7,82.32 124.27,82.32 124.19,82.4 124.19,82.57 124.27,82.66 124.7,82.66 124.78,82.74 124.78,83.48 124.7,83.57 123.88,83.57 123.79,83.66 123.79,83.82 123.87,83.9 124.7,83.9 124.78,83.98 124.78,84.15 124.7,84.24 123.88,84.24 123.79,84.33 123.79,84.49 123.87,84.57 124.7,84.57 124.78,84.65 124.78,85.57 124.67,85.68 124.55,85.68 124.47,85.6 124.36,85.6 124.24,85.72 124.24,85.84 124.32,85.92 124.32,86.03 124.23,86.12 124.23,86.28 124.14,86.36 123.83,86.36 123.75,86.45 123.75,86.62 123.83,86.7 124.14,86.7 124.23,86.78 124.23,86.95 124.14,87.03 123.83,87.03 123.75,87.12 123.75,87.29 123.83,87.37 124.14,87.37 124.23,87.45 124.23,87.62 124.14,87.71 123.83,87.71 123.75,87.79 123.75,87.96 123.83,88.04 124.14,88.04 124.23,88.12 124.23,88.29 124.14,88.38 123.83,88.38 123.75,88.46 123.75,88.63 123.83,88.71 124.11,88.71 124.38,88.98 125.18,88.98 125.42,89.21 125.42,89.63 125.42,89.64 125.42,89.75 125.34,89.83 124.26,89.83 124.16,89.92 124.16,90.08 124.25,90.16 124.65,90.16 124.74,90.24 124.74,90.62 124.82,90.7 124.99,90.7 125.07,90.62 125.07,90.24 125.15,90.16 125.34,90.16 125.42,90.24 125.42,90.69 125.6,90.87 125.6,91.02 125.52,91.1 124.86,91.1 124.77,91.18 124.77,91.35 124.86,91.43 125.52,91.43 125.6,91.52 125.6,91.69 125.52,91.77 124.86,91.77 124.77,91.85 124.77,92.02 124.86,92.11 125.52,92.11 125.6,92.19 125.6,92.36 125.52,92.44 124.86,92.44 124.77,92.52 124.77,92.69 124.86,92.78 125.52,92.78 125.6,92.86 125.6,93.03 125.52,93.11 124.86,93.11 124.77,93.19 124.77,93.36 124.86,93.45 125.52,93.45 125.6,93.53 125.6,93.7 125.52,93.78 124.86,93.78 124.77,93.86 124.77,94.04 124.86,94.12 125.52,94.12 125.6,94.2 125.6,97.7 126.04,98.14 127.9,98.14 128.09,98.33 128.09,105.28 127.58,105.78 126.17,105.78 125.12,104.73 123.73,104.73 123.54,104.54 123.54,104.35 123.63,104.25 124.45,104.25 124.53,104.17 124.53,104 124.45,103.92 123.62,103.92 123.54,103.84 123.54,103.68 123.63,103.58 124.7,103.58 124.78,103.5 124.78,103.33 124.7,103.25 123.62,103.25 123.54,103.17 123.54,103 123.63,102.91 125.2,102.91 125.33,102.79 125.33,102.67 125.23,102.58 123.62,102.58 123.54,102.5 v1(123.54,102.2)
