# Allegro board FM85_AGILEX_PCIE_DK_CMC_ADI_REVC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_COMP_CH1_CLK_N: length 85.2
  L05_SIG2 w0.081: v1(128.47,21.68) 128.69,21.46 132.58,21.46 133.34,22.22 138.07,22.22 v1(138.63,21.66) 138.63,21.55 138.76,21.42 139.24,21.42 139.9,22.08 143.43,22.08 143.56,22.22 144.51,22.22 144.63,22.09 144.94,22.09 145.06,22.22 145.52,22.22 145.53,22.22 147.69,22.22 147.9,22.01 148.21,22.01 148.55,21.66 v1(148.79,21.66) 148.95,21.5 153.07,21.5 153.83,22.26 158.14,22.26 158.71,21.7 v1(158.95,21.7) 159.18,21.47 163.07,21.47 163.83,22.23 164.64,22.23 164.82,22.04 165.29,22.04 165.46,22.22 167.87,22.22 168.07,22.01 168.45,22.01 168.8,21.66 v1(169.11,21.66)
  L12_SIG4 w0.076: 127.12,37.45 127.12,37.47 127.12,37.47 arc(127.12,37.49) 127.12,37.5 127.12,37.66 arc(127.12,37.68) 127.11,37.71 arc(127.11,37.72) 127.1,37.73 arc(127.1,37.75) 127.1,37.76 arc(127.11,37.84) 127.13,37.91 127.17,37.99 arc(127.27,38.1) 127.41,38.14 arc(127.42,38.14) 127.44,38.14 arc(127.44,38.14) 127.44,38.14 arc(127.44,38.14) 127.45,38.13 arc(127.46,38.13) 127.47,38.13 arc(127.49,38.13) 127.5,38.13 arc(127.52,38.13) 127.53,38.13 arc(127.58,38.14) 127.63,38.14 arc(127.8,38.23) 127.92,38.38 arc(127.92,38.38) 127.93,38.39 arc(127.93,38.39) 127.93,38.39 127.97,38.48 arc(127.98,38.5) 127.99,38.52 arc(128,38.57) 128.01,38.62 arc(128.01,38.63) 128.01,38.64 arc(128.01,38.65) 128.01,38.65 arc(128.01,38.65) 128.01,38.65 128.01,38.66 arc(128.01,38.67) 128.01,38.68 arc(128.01,38.68) 128.01,38.69 128.01,38.69 arc(128.01,38.71) 128.01,38.73 arc(128,38.77) 127.99,38.8 127.93,38.91 arc(127.91,38.95) 127.9,38.98 arc(127.89,39.04) 127.89,39.09 arc(127.89,39.1) 127.89,39.11 arc(127.9,39.22) 127.95,39.33 arc(128.02,39.55) 127.99,39.79 arc(127.97,39.85) 127.93,39.91 arc(127.93,39.92) 127.92,39.93 arc(127.9,40) 127.89,40.07 arc(127.89,40.14) 127.91,40.2 arc(127.94,40.25) 127.98,40.3 128.01,40.33 arc(128.15,40.43) 128.32,40.47 128.36,40.48 arc(128.4,40.48) 128.44,40.49 arc(128.66,40.63) 128.79,40.86 arc(128.81,40.92) 128.81,40.99 arc(128.81,40.99) 128.81,40.99 128.81,41.06 arc(128.8,41.16) 128.76,41.25 arc(128.7,41.44) 128.75,41.63 arc(128.79,41.73) 128.81,41.85 arc(128.8,41.87) 128.8,41.9 arc(128.8,41.91) 128.8,41.93 128.79,42.01 128.79,42.02 arc(128.78,42.11) 128.75,42.19 arc(128.7,42.36) 128.74,42.53 arc(128.77,42.6) 128.8,42.67 arc(128.82,42.73) 128.83,42.8 arc(128.84,42.97) 128.79,43.12 arc(128.75,43.2) 128.74,43.29 128.74,43.33 arc(128.75,43.4) 128.79,43.48 arc(128.86,43.63) 128.86,43.79 128.86,43.83 arc(128.83,43.9) 128.79,43.96 arc(128.77,44) 128.74,44.03 arc(128.74,44.04) 128.73,44.05 arc(128.73,44.05) 128.73,44.05 arc(128.72,44.06) 128.72,44.06 arc(128.71,44.08) 128.7,44.1 arc(128.68,44.19) 128.7,44.27 arc(128.71,44.29) 128.72,44.31 arc(128.74,44.38) 128.78,44.44 128.79,44.45 128.81,44.49 arc(128.83,44.56) 128.83,44.64 arc(128.83,44.71) 128.81,44.78 arc(128.8,44.82) 128.79,44.85 arc(128.79,44.86) 128.78,44.86 arc(128.77,44.89) 128.76,44.92 128.74,44.95 arc(128.74,44.96) 128.73,44.97 128.72,45 arc(128.72,45.03) 128.71,45.06 128.71,45.07 arc(128.7,45.18) 128.72,45.29 128.75,45.35 arc(128.8,45.56) 128.75,45.76 128.75,45.77 128.74,45.8 128.73,45.81 128.72,45.82 arc(128.63,45.95) 128.5,46.04 arc(128.49,46.05) 128.48,46.05 arc(128.44,46.07) 128.4,46.09 arc(128.32,46.11) 128.24,46.11 arc(128.1,46.09) 127.98,46.01 127.65,45.7 arc(127.61,45.68) 127.57,45.67 127.39,45.67 arc(127.1,45.56) 126.93,45.29 126.92,45.28 126.92,45.22 126.91,45.21 126.91,45.2
  L12_SIG4 w0.089: 127.12,37.45 127.12,37.36 arc(127.16,37.2) 127.25,37.06 127.39,36.92 arc(127.68,36.48) 127.79,35.96 127.79,35.83 127.79,35.82 127.79,35.45 127.88,35.37 129.44,35.37 129.68,35.13 129.68,34.84 129.48,34.64 127.88,34.64 127.79,34.55 127.79,33.56 arc(127.79,33.52) 127.79,33.47 127.79,33.34 arc(127.79,33.29) 127.8,33.24 arc(127.82,33.19) 127.85,33.16 128.17,32.84 arc(128.2,32.82) 128.25,32.81 128.79,32.81 arc(129.02,32.71) 129.11,32.48 129.11,31.9 arc(129.1,31.86) 129.08,31.82 128.86,31.6 127.91,31.6 127.76,31.45 127.76,30.28 127.87,30.18 128.21,30.18 128.3,30.27 128.3,31.02 128.51,31.23 128.8,31.23 129.02,31.01 129.02,30.27 129.11,30.18 129.42,30.18 129.62,29.98 129.62,29.65 129.42,29.45 128.07,29.45 127.96,29.34 127.96,28.27 127.34,27.65 arc(127.25,27.52) 127.22,27.35 127.22,23.32 arc(127.22,23.28) 127.24,23.26 127.97,22.53 arc(128.12,22.31) 128.17,22.05 128.17,22.01 arc(128.18,21.98) 128.2,21.95 v1(128.47,21.68) ; 126.91,45.2 126.91,44.82 arc(126.9,44.78) 126.88,44.75 arc(126.79,44.69) v1(126.68,44.67)
  BOTTOM w0.149: R74.2 167.96,22.25 168.14,22.07 168.7,22.07 v1(169.11,21.66)
DDR4_COMP_CH1_CLK_P: length 85.2
  L05_SIG2 w0.081: v1(168.31,21.66) 168.31,21.74 168.23,21.83 168,21.83 167.79,22.03 165.54,22.03 165.36,21.86 164.75,21.86 164.56,22.04 163.9,22.04 163.15,21.29 158.83,21.29 158.41,21.7 v1(158.15,21.7) 157.77,22.08 153.91,22.08 153.14,21.31 148.64,21.31 148.29,21.66 v1(147.99,21.66) 147.62,22.03 145.45,22.03 145.45,22.03 145.14,22.03 145.01,21.9 144.57,21.9 144.43,22.03 143.64,22.03 143.51,21.9 139.98,21.9 139.31,21.23 138.2,21.23 137.83,21.61 v1(137.83,21.66) 137.83,21.96 137.75,22.04 133.42,22.04 132.66,21.28 128.23,21.28 127.82,21.68 v1(127.67,21.68)
  L12_SIG4 w0.076: 126.93,37.45 126.93,37.47 126.94,37.47 126.94,37.61 arc(126.94,37.65) 126.93,37.69 arc(126.92,37.73) 126.92,37.76 arc(126.94,37.88) 126.97,37.99 127.01,38.07 arc(127.13,38.21) 127.3,38.3 arc(127.35,38.31) 127.41,38.32 arc(127.43,38.31) 127.45,38.31 arc(127.46,38.31) 127.47,38.31 arc(127.49,38.31) 127.52,38.31 arc(127.55,38.31) 127.59,38.32 arc(127.69,38.37) 127.76,38.45 arc(127.76,38.47) 127.77,38.48 arc(127.77,38.48) 127.77,38.48 127.82,38.56 arc(127.82,38.57) 127.82,38.58 arc(127.83,38.6) 127.83,38.62 arc(127.83,38.64) 127.83,38.66 arc(127.83,38.67) 127.83,38.67 127.84,38.69 arc(127.84,38.7) 127.83,38.7 arc(127.83,38.71) 127.83,38.72 127.77,38.83 arc(127.75,38.88) 127.73,38.94 arc(127.72,39.01) 127.71,39.08 arc(127.71,39.1) 127.71,39.11 arc(127.73,39.27) 127.79,39.42 arc(127.83,39.51) 127.84,39.61 arc(127.84,39.67) 127.82,39.73 arc(127.82,39.74) 127.81,39.76 arc(127.8,39.79) 127.78,39.81 arc(127.78,39.82) 127.77,39.84 arc(127.77,39.84) 127.76,39.85 arc(127.76,39.85) 127.76,39.85 arc(127.72,39.96) 127.71,40.07 arc(127.72,40.17) 127.75,40.26 arc(127.79,40.35) 127.86,40.43 127.88,40.45 arc(128.07,40.59) 128.3,40.65 128.35,40.65 arc(128.36,40.65) 128.38,40.66 arc(128.53,40.76) 128.62,40.91 arc(128.63,40.95) 128.63,40.99 arc(128.64,40.99) 128.63,40.99 arc(128.64,40.99) 128.64,40.99 128.64,41.06 arc(128.63,41.11) 128.61,41.16 arc(128.52,41.43) 128.59,41.71 arc(128.62,41.78) 128.63,41.85 arc(128.63,41.86) 128.63,41.87 arc(128.63,41.88) 128.63,41.88 arc(128.62,41.89) 128.62,41.91 arc(128.62,41.91) 128.62,41.92 arc(128.62,41.92) 128.62,41.92 128.61,41.99 arc(128.61,42) 128.61,42.01 128.61,42.02 arc(128.61,42.06) 128.59,42.11 arc(128.59,42.11) 128.59,42.11 arc(128.52,42.36) 128.58,42.61 arc(128.61,42.67) 128.63,42.72 arc(128.64,42.78) 128.66,42.84 arc(128.66,42.94) 128.63,43.03 arc(128.58,43.15) 128.56,43.29 128.56,43.33 arc(128.58,43.46) 128.64,43.58 arc(128.68,43.67) 128.69,43.77 128.68,43.8 arc(128.67,43.83) 128.66,43.85 128.66,43.85 arc(128.63,43.88) 128.6,43.92 arc(128.59,43.93) 128.59,43.94 arc(128.59,43.94) 128.58,43.95 arc(128.58,43.95) 128.58,43.95 arc(128.58,43.96) 128.57,43.96 arc(128.55,43.99) 128.54,44.03 arc(128.5,44.19) 128.54,44.35 arc(128.54,44.35) 128.55,44.36 arc(128.59,44.46) 128.64,44.55 128.64,44.55 arc(128.65,44.59) 128.65,44.64 arc(128.65,44.68) 128.64,44.73 arc(128.63,44.76) 128.62,44.78 arc(128.62,44.79) 128.62,44.8 arc(128.61,44.82) 128.6,44.84 128.58,44.87 arc(128.57,44.89) 128.56,44.92 128.55,44.95 arc(128.54,44.98) 128.53,45.02 128.53,45.02 arc(128.52,45.19) 128.56,45.36 128.59,45.42 arc(128.62,45.56) 128.59,45.69 arc(128.59,45.69) 128.59,45.69 128.58,45.7 arc(128.58,45.71) 128.57,45.72 128.57,45.72 arc(128.57,45.73) 128.57,45.74 arc(128.51,45.82) 128.42,45.88 arc(128.41,45.89) 128.39,45.9 arc(128.37,45.91) 128.35,45.92 arc(128.35,45.92) 128.35,45.92 arc(128.3,45.93) 128.24,45.94 arc(128.17,45.92) 128.1,45.88 127.77,45.57 arc(127.68,45.51) 127.57,45.49 127.39,45.49 arc(127.19,45.41) 127.1,45.2
  L12_SIG4 w0.089: v1(127.48,45.13) 127.48,44.96 arc(127.47,44.93) 127.45,44.9 127.44,44.89 arc(127.38,44.85) 127.32,44.84 127.25,44.84 arc(127.15,44.88) 127.1,44.99 127.1,45.2 ; v1(127.67,21.68) 127.67,21.68 127.79,21.73 arc(127.92,21.84) 127.97,22.01 127.97,22.01 127.98,22.02 127.98,22.05 arc(127.94,22.23) 127.84,22.39 127.11,23.12 arc(127.05,23.21) 127.03,23.32 127.03,27.35 arc(127.07,27.59) 127.21,27.79 127.77,28.35 127.77,29.42 127.99,29.64 129.34,29.64 129.43,29.73 129.43,29.9 129.34,29.99 129.03,29.99 128.83,30.19 128.83,30.93 128.72,31.04 128.59,31.04 128.49,30.94 128.49,30.19 128.29,29.99 127.79,29.99 127.57,30.2 127.57,31.53 127.83,31.79 128.78,31.79 128.92,31.93 128.92,32.48 arc(128.88,32.58) 128.79,32.62 128.25,32.62 arc(128.13,32.64) 128.03,32.71 127.71,33.02 arc(127.65,33.1) 127.62,33.19 arc(127.6,33.26) 127.6,33.33 arc(127.6,33.33) 127.6,33.34 127.6,33.47 arc(127.6,33.52) 127.6,33.56 127.6,34.63 127.8,34.83 129.4,34.83 129.49,34.92 129.49,35.05 129.36,35.17 127.8,35.17 127.6,35.38 127.6,35.82 127.6,35.83 127.6,35.96 arc(127.51,36.41) 127.26,36.78 127.12,36.92 arc(126.98,37.13) 126.93,37.36 126.93,37.45
  BOTTOM w0.149: R73.2 166.68,22.15 167.17,21.66 v1(168.31,21.66)
DDR4_COMP_CH1_CS_N: length 82
  TOP w0.149: U9.L7 v1(147.48,20.86) ; U11.L7 v1(167.67,20.86) ; U7.L7 v1(127.16,20.86) ; U10.L7 v1(157.64,20.9)
  L03_SIG1 w0.081: v1(127.16,20.86) 127.84,20.86 128.22,21.25 136.93,21.25 137.32,20.86 v1(137.83,20.86)
  L14_SIG5 w0.081: v1(127.16,20.86) 127.58,21.29 128.6,21.29 128.84,21.53 128.84,29.4 128.76,29.49 127.78,29.49 127.7,29.57 127.7,29.74 127.78,29.82 128.76,29.82 128.84,29.9 128.84,30.07 128.76,30.16 127.63,30.16 127.54,30.25 127.54,30.41 127.62,30.49 128.76,30.49 128.84,30.57 128.84,30.75 128.76,30.83 127.72,30.83 127.64,30.91 127.64,31.07 127.73,31.16 128.76,31.16 128.84,31.24 128.84,31.42 128.76,31.5 127.72,31.5 127.64,31.58 127.64,31.74 127.73,31.83 128.76,31.83 128.84,31.91 128.84,37.47 128.7,37.61 128.7,37.92 128.8,38.02 128.8,38.43 128.7,38.53 128.7,38.84 128.8,38.94 128.8,39.14 128.25,39.7 128.12,39.7 127.88,39.94 127.88,40.53 arc(127.85,40.64) 127.79,40.74 127.63,40.9 127.29,40.9 126.83,41.36 126.5,41.36 126.04,41.82 125.91,41.82 125.46,42.27 125.46,44.82 125.24,45.04 125.11,45.04 124.29,45.86 v1(124.29,46.05)
  L16_SIG6 w0.081: v1(167.67,20.86) 167.26,21.28 158.01,21.28 v1(157.64,20.9) 157.52,20.78 156.42,20.78 155.92,21.28 147.89,21.28 v1(147.48,20.86) 147.4,20.94 arc(147.08,21.16) 146.7,21.23 145.45,21.23 145.45,21.23 145.14,21.23 145.14,21.23 144.14,21.23 144.14,21.23 143.83,21.23 143.83,21.23 143.34,21.23 143.34,21.23 138.58,21.23 arc(138.23,21.16) 137.93,20.97 v1(137.83,20.86)
DDR4_COMP_CH1_DBI_N0: length 54
  L07_SIG3 w0.089: v1(168.31,25.66) 168.31,25.43 167.88,25 167.67,25 167.27,25.41 167.27,25.84 167.35,25.93 167.85,25.93 167.94,26.02 167.94,26.18 167.85,26.27 167.35,26.27 167.27,26.36 167.27,26.53 167.35,26.62 167.85,26.62 167.94,26.7 167.94,26.87 167.85,26.96 167.35,26.96 167.27,27.05 167.27,27.21 167.35,27.3 167.85,27.3 167.94,27.39 167.94,27.55 167.85,27.64 167.35,27.64 167.27,27.73 167.27,28.56 167.35,28.65 167.5,28.65 167.59,28.74 167.59,28.9 167.5,28.99 167.35,28.99 167.27,29.08 167.27,29.42 166.89,29.79 166.77,29.79 166.47,29.5 166.34,29.5 166.23,29.61 166.23,29.74 166.53,30.04 166.53,30.16 166.41,30.28 166.28,30.28 165.98,29.98 165.86,29.98 165.74,30.1 165.74,30.22 166.04,30.52 166.04,30.65 165.92,30.76 165.8,30.76 165.5,30.47 165.37,30.47 165.26,30.58 165.26,30.71 165.56,31.01 165.56,31.13 165.31,31.37 164.83,31.37 164.38,31.82 164.26,31.82 164.2,31.76 164.07,31.76 163.96,31.88 163.96,32.01 164.01,32.06 164.01,32.19 163.9,32.31 163.77,32.31 163.71,32.25 163.59,32.25 163.47,32.37 163.47,32.49 163.53,32.55 163.53,32.67 163.41,32.79 163.29,32.79 163.23,32.73 163.1,32.73 162.99,32.85 162.99,32.98 163.04,33.03 163.04,33.16 162.28,33.93 162.15,33.93 161.75,33.53 161.63,33.53 161.51,33.64 161.51,33.77 161.91,34.17 161.91,34.29 161.79,34.41 161.67,34.41 161.27,34.01 161.14,34.01 161.03,34.13 161.03,34.25 161.43,34.65 161.43,34.78 158.17,38.04 157.1,38.04 152.78,42.36 147.63,42.36 147.39,42.11 147.39,41.99 147.4,41.98 147.4,41.85 147.28,41.74 147.16,41.74 147.15,41.75 147.02,41.75 146.9,41.63 146.9,41.5 146.91,41.5 146.91,41.37 146.8,41.25 146.67,41.25 146.66,41.26 146.54,41.26 146.35,41.07 146.23,41.07 146.14,40.98 146.14,40.77 146.05,40.69 145.89,40.69 145.8,40.77 145.8,40.98 145.71,41.07 145.54,41.07 145.45,40.98 145.45,40.77 145.37,40.69 145.2,40.69 145.11,40.77 145.11,40.98 145.02,41.07 144.86,41.07 144.77,40.98 144.77,40.77 144.68,40.69 144.51,40.69 144.43,40.77 144.43,40.98 144.34,41.07 143.24,41.07 142.78,41.53 142.46,41.53 142.17,41.82 141.24,41.82 140.37,40.95 139.92,40.95 139.42,40.44 139.09,40.44 138.63,39.98 v1(138.63,39.61)
DDR4_COMP_CH1_DBI_N1: length 28.7
  L03_SIG1 w0.081: v1(129.07,39.61) 128.64,40.03 128.64,40.22 128.43,40.44 128.09,40.44 127.63,40.9 127.32,40.9 127.11,40.68 127.11,40.37 127.38,40.1 127.66,40.1 128.07,39.7 128.25,39.7 128.64,39.3 128.64,38.59 128.92,38.32 129.25,38.32 129.53,38.04 129.53,37.07 132.48,34.13 132.48,34.01 132.13,33.66 132.13,33.55 132.25,33.43 132.36,33.43 132.71,33.77 132.83,33.77 136.26,30.34 136.26,29.98 136.18,29.9 135.99,29.9 135.91,29.82 135.91,29.65 135.99,29.57 136.18,29.57 136.26,29.48 136.26,27.69 136.63,27.31 136.63,24.86 136.78,24.71 137.34,24.71 137.45,24.82 137.45,24.99 137.39,25.05 137.06,25.05 136.97,25.13 136.97,25.27 137.07,25.36 137.24,25.36 137.31,25.43 137.31,25.58 137.24,25.64 137.05,25.64 136.97,25.72 136.97,26.1 137.06,26.18 137.31,26.18 v5(137.83,25.66)
DDR4_COMP_CH1_DBI_N2: length 30.3
  L03_SIG1 w0.081: v1(124.29,41.45) 124.69,41.04 124.69,37.54 124.12,36.97 124.12,36.05 124.47,35.7 124.47,35.03 124.55,34.95 124.8,34.95 124.88,34.87 124.88,34.69 124.8,34.61 124.55,34.61 124.47,34.53 124.47,34.36 124.55,34.28 124.8,34.28 124.88,34.2 124.88,34.02 124.8,33.94 124.55,33.94 124.47,33.86 124.47,33.69 124.55,33.61 124.8,33.61 124.88,33.52 124.88,33.35 124.8,33.27 124.55,33.27 124.47,33.19 124.47,33.02 124.55,32.94 124.8,32.94 124.88,32.85 124.88,32.68 124.8,32.6 124.55,32.6 124.47,32.52 124.47,32.29 126.14,30.63 126.14,29.93 126.22,29.85 126.83,29.85 126.91,29.77 126.91,29.6 126.83,29.52 126.22,29.52 126.14,29.44 126.14,28.77 126.24,28.67 126.81,28.67 126.9,28.59 126.9,28.42 126.81,28.33 125.96,28.33 125.88,28.25 125.88,27.91 125.98,27.81 126.55,27.81 126.63,27.73 126.63,26.59 126.71,26.51 126.88,26.51 126.97,26.59 126.97,27.73 127.05,27.81 127.66,27.81 127.75,27.9 127.75,29.24 127.84,29.32 127.99,29.32 128.09,29.23 128.09,25.76 127.99,25.66 v5(127.67,25.66)
DDR4_COMP_CH1_DBI_N3: length 41.2
  L05_SIG2 w0.081: v1(133.83,25.66) 134.23,26.07 139.58,26.07 141.03,27.52 141.03,30.6 138.23,33.4 136.95,33.4 134.77,35.58 134.77,36.53 134.22,37.08 134.22,37.92 134,38.14 133.67,38.14 133.21,38.6 132.87,38.6 132.41,39.06 132.23,39.06 131.59,39.7 131.31,39.7 131.03,39.98 130.51,39.98 130.14,39.61 129.8,39.61 129.39,40.02 128.84,40.02 128.41,39.6 128.09,39.6 127.56,40.12 127.22,40.12 126.81,40.53 126.39,40.53 126.26,40.67 126.26,43.53 125.99,43.79 125.65,43.79 125.27,44.17 124.99,44.17 124.57,44.59 124.3,44.59 123.83,45.05 123.18,45.05 122.87,44.75 122.37,44.75 122,45.13 121.66,45.13 121.1,44.57 v1(121.1,44.21)
DDR4_COMP_CH1_DBI_N4: length 52.2
  L07_SIG3 w0.089: v1(143.99,25.66) 144.36,25.29 145.15,25.29 145.27,25.17 145.27,23.82 145.4,23.69 150.65,23.69 150.84,23.5 151.23,23.5 152.88,25.14 152.88,28.79 149.41,32.26 147.74,32.26 144.74,35.26 138.91,35.26 138.43,35.73 136.41,35.73 134.23,37.92 134.23,38.56 134.23,42.25 133.23,43.24 133.03,43.24 132.44,43.83 132.1,43.83 131.75,44.19 131.41,44.19 130.93,44.66 130.55,44.66 130.11,45.1 129.73,45.1 129.38,44.75 128.92,44.75 128.63,45.04 127.92,45.04 127.63,44.75 127.12,44.75 126.84,45.04 126.52,45.04 125.88,44.4 v1(125.88,44.21)
DDR4_COMP_CH1_DBI_N5: length 32.8
  L03_SIG1 w0.081: v5(158.15,25.7) 158.53,26.08 158.53,31.7 157.94,32.29 148.7,32.29 146.42,34.57 146.42,36.58 144.57,38.43 144.57,38.76 144.65,38.85 145.09,38.85 145.18,38.93 145.18,39.1 145.09,39.18 144.65,39.18 144.57,39.26 144.57,39.43 144.65,39.52 145.16,39.52 145.24,39.6 145.24,39.77 145.16,39.85 144.65,39.85 144.57,39.93 144.57,41.29 143.68,42.18 143.68,42.18 143.63,42.23 143.38,42.23 143.32,42.28 142.28,42.28 141.82,41.82 v1(141.82,41.45)
DDR4_COMP_CH1_DBI_N6: length 48.3
  TOP w0.149: U9.E7 v1(147.48,25.66)
  L14_SIG5 w0.081: v1(147.48,25.66) 147.26,25.44 147.26,24.64 147.11,24.49 147.11,24.1 147.03,24.02 146.9,24.02 146.81,23.94 146.81,23.77 146.9,23.69 147.03,23.69 147.11,23.61 147.11,23.43 147.03,23.35 146.9,23.35 146.81,23.27 146.81,23.1 146.9,23.02 147.03,23.02 147.11,22.94 147.11,20.87 146.98,20.74 145.86,20.74 145.73,20.87 145.73,21.37 145.81,21.45 146.67,21.45 146.76,21.54 146.76,21.84 146.68,21.93 145.56,21.93 145.45,22.03 145.45,22.2 145.53,22.29 145.94,22.29 146.05,22.4 146.05,22.51 145.94,22.63 145.39,22.63 145.31,22.71 145.31,22.88 145.39,22.96 145.94,22.96 146.02,23.04 146.02,23.21 145.91,23.33 145.31,23.33 145.22,23.42 145.22,23.69 145.3,23.77 145.94,23.77 146.8,24.63 146.8,27.3 146.75,27.36 146.75,28.86 143.87,31.75 140.47,31.75 140.42,31.69 132.79,31.69 132.68,31.8 132.68,35.99 132.79,36.1 133.61,36.1 133.91,35.79 134.17,35.79 134.44,36.06 134.44,36.39 134.19,36.64 134.19,38.15 134.11,38.23 133.61,38.23 133.24,38.61 133.24,38.8 133.65,39.22 134.14,39.22 134.23,39.3 134.23,39.52 134.14,39.6 v1(133.82,39.6)
DDR4_COMP_CH1_DBI_N7: length 46.1
  L16_SIG6 w0.081: v1(123.67,25.66) 123.39,25.66 123.3,25.57 123.3,22.29 123.04,22.03 122.65,22.03 122.39,21.78 122.39,21.39 122.16,21.16 122.16,20.24 122.04,20.12 118.29,20.12 118.2,20.22 118.2,31.5 118.06,31.63 117.66,31.63 117.58,31.72 117.58,31.89 117.66,31.97 118.16,31.97 118.34,32.14 118.34,32.71 118.08,32.96 118.08,33.31 118.34,33.56 118.34,34.02 118.14,34.21 117.54,34.21 116.82,34.93 116.44,34.93 115.15,36.23 115.15,36.91 115.07,36.99 114.72,36.99 114.64,37.08 114.64,37.25 114.72,37.33 115.07,37.33 115.15,37.41 115.15,43.94 115.51,44.3 115.68,44.3 115.96,44.58 116.49,44.58 117.13,45.22 117.35,45.22 117.65,45.51 118.11,45.51 118.56,45.96 118.83,45.96 119.46,46.59 121.21,46.59 121.33,46.47 121.33,46.27 v1(121.1,46.05)
DDR4_COMP_CH1_DBI_N8: length 59.1
  L14_SIG5 w0.081: v1(154.15,25.7) 153.75,25.3 153.75,24.75 154.88,23.61 154.88,22.42 155.17,22.13 157.12,22.13 157.28,22.29 157.28,23.54 157.14,23.68 156.63,23.68 156.55,23.76 156.55,23.94 156.63,24.02 157.51,24.02 157.62,24.12 157.62,24.26 157.52,24.35 156.63,24.35 156.55,24.43 156.55,24.61 156.63,24.69 157.36,24.69 157.54,24.87 157.54,25.81 157.35,26 156.79,26 156.7,26.1 156.7,26.24 156.8,26.34 157.11,26.34 157.19,26.42 157.19,27.5 156.35,28.34 156.35,30.61 156.27,30.7 155.91,30.7 155.83,30.78 155.83,30.95 155.91,31.03 156.27,31.03 156.35,31.11 156.35,31.62 156.17,31.81 152.08,31.81 151.88,32.01 148.12,32.01 143.51,36.62 143.14,36.62 143.01,36.75 143.01,40.31 142.78,40.54 142.47,40.54 141.93,41.08 141.62,41.08 141.27,41.43 140.73,41.43 140.38,41.08 139.86,41.08 139.4,41.54 138.99,41.54 138.47,42.06 138.2,42.06 137.56,42.7 137.12,42.7 136.84,42.98 136.44,42.98 135.84,43.58 133.96,43.58 133.76,43.38 132.86,43.38 132.58,43.66 132.1,43.66 131.78,43.33 131.25,43.33 130.75,43.84 130.47,43.84 130.16,44.15 129.85,44.15 129.47,44.53 129.47,45.78 129.74,46.05 v1(130.66,46.05)
DDR4_COMP_CH1_DQ0: length 52.8
  L07_SIG3 w0.089: v1(164.31,23.26) 163.9,23.67 163.22,23.67 163.06,23.83 163.06,29.5 162.49,30.08 156.59,30.08 156.5,30.17 156.5,30.69 156.41,30.78 156.24,30.78 156.16,30.69 156.16,30.17 156.07,30.08 155.9,30.08 155.81,30.17 155.81,30.69 155.72,30.78 155.56,30.78 155.47,30.69 155.47,30.17 155.38,30.08 155.22,30.08 155.13,30.17 155.13,30.69 155.04,30.78 154.87,30.78 154.78,30.69 154.78,30.17 154.7,30.08 154.35,30.08 154.07,30.37 154.07,31.52 154.15,31.61 155.53,31.61 155.62,31.7 155.62,31.86 155.53,31.95 154.15,31.95 154.07,32.04 154.07,32.38 154.43,32.75 157.16,32.75 157.4,32.98 157.4,35.17 152.03,40.54 148.68,40.54 145.96,37.82 142.3,37.82 141.98,38.14 140.24,38.14 139.85,38.53 139.85,38.72 v1(139.43,39.15)
DDR4_COMP_CH1_DQ1: length 53.6
  L07_SIG3 w0.089: v1(168.31,24.86) 168.49,24.68 168.61,24.68 168.73,24.8 168.73,28.34 168.63,28.44 168.05,28.44 167.93,28.55 167.93,29.25 165.46,31.72 164.98,31.72 158.3,38.4 157.27,38.4 152.34,43.33 152.12,43.33 152.03,43.24 152.03,42.79 151.94,42.7 151.78,42.7 151.69,42.79 151.69,43.24 151.6,43.33 151.43,43.33 151.34,43.24 151.34,42.79 151.25,42.7 151.09,42.7 151,42.79 151,43.24 150.91,43.33 150.75,43.33 150.66,43.24 150.66,42.79 150.57,42.7 150.4,42.7 150.31,42.79 150.31,43.24 150.23,43.33 148.11,43.33 146.57,41.8 145.94,41.8 145.85,41.88 145.85,42.4 145.76,42.49 145.6,42.49 145.51,42.4 145.51,41.88 145.42,41.8 145.26,41.8 145.17,41.88 145.17,42.4 145.08,42.49 144.91,42.49 144.82,42.4 144.82,41.8 144.72,41.7 144.57,41.7 144.48,41.79 144.48,42.4 144.39,42.49 144.23,42.49 144.14,42.4 144.14,41.88 144.05,41.8 143.71,41.8 143.2,42.31 142.04,42.31 141.9,42.16 141.1,42.16 140.76,41.82 139.98,41.82 139.66,41.51 138.86,41.51 138.21,40.86 138.21,39.91 138,39.7 138,39.51 138.21,39.3 138.21,38.87 138.11,38.77 137.68,38.77 137.29,38.38 137.29,38.01 v1(137.04,37.77)
DDR4_COMP_CH1_DQ2: length 52.6
  L07_SIG3 w0.089: v1(139.44,38.23) 139.44,38.21 139.63,38.02 139.63,37.79 140.18,37.24 145.85,37.24 146.7,36.38 146.7,34.05 148.02,32.73 151.97,32.73 152.31,32.39 152.31,32.05 152.39,31.96 153.5,31.96 153.59,31.87 153.59,31.71 153.5,31.62 152.39,31.62 152.31,31.53 152.31,31.37 152.39,31.28 153.5,31.28 153.59,31.19 153.59,31.02 153.5,30.93 152.39,30.93 152.31,30.85 152.31,30.16 152.75,29.72 153,29.72 153.08,29.63 153.08,29.37 153.17,29.28 153.34,29.28 153.43,29.37 153.43,29.63 153.52,29.72 153.68,29.72 153.77,29.63 153.77,29.35 153.86,29.26 154.02,29.26 154.11,29.35 154.11,29.63 154.2,29.72 154.37,29.72 154.46,29.63 154.46,29.35 154.54,29.26 154.71,29.26 154.8,29.35 154.8,29.63 154.89,29.72 155.05,29.72 155.14,29.63 155.14,29.35 155.23,29.26 155.4,29.26 155.48,29.35 155.48,29.63 155.57,29.72 155.74,29.72 155.83,29.63 155.83,29.35 155.92,29.26 156.08,29.26 156.17,29.35 156.17,29.63 156.26,29.72 156.42,29.72 156.51,29.63 156.51,29.35 156.6,29.26 156.77,29.26 156.86,29.35 156.86,29.63 156.95,29.72 157.11,29.72 157.2,29.63 157.2,29.35 157.29,29.26 157.45,29.26 157.54,29.35 157.54,29.63 157.63,29.72 157.8,29.72 157.88,29.63 157.88,29.37 157.97,29.28 158.14,29.28 158.23,29.37 158.23,29.63 158.32,29.72 158.48,29.72 158.57,29.63 158.57,29.35 158.66,29.26 158.82,29.26 158.91,29.35 158.91,29.63 159,29.72 159.17,29.72 159.26,29.63 159.26,29.35 159.35,29.26 159.51,29.26 159.6,29.35 159.6,29.63 159.69,29.72 159.85,29.72 159.94,29.63 159.94,29.35 160.03,29.26 160.2,29.26 160.29,29.35 160.29,29.63 160.37,29.72 160.54,29.72 160.63,29.63 160.63,29.35 160.72,29.26 160.88,29.26 160.97,29.35 160.97,29.63 161.06,29.72 161.23,29.72 161.31,29.63 161.31,29.35 161.4,29.26 161.57,29.26 161.66,29.35 161.66,29.63 161.75,29.72 162.28,29.72 162.57,29.44 162.57,23.45 163.18,22.84 164.54,22.84 164.91,22.46 v1(165.11,22.46)
DDR4_COMP_CH1_DQ3: length 55.1
  L07_SIG3 w0.089: v1(168.31,22.46) 168.69,22.85 170.36,22.85 170.7,23.19 arc(171.09,23.77) 171.22,24.45 171.22,27.48 arc(171.1,28.4) 170.75,29.26 arc(170.72,29.29) 170.69,29.33 170.2,29.82 arc(170,29.95) 169.77,30 168.64,30 165.84,32.81 165.35,32.81 158.72,39.44 157.69,39.44 151.8,45.32 145.24,45.32 144.64,44.72 143.93,44.72 143.68,44.97 143.52,44.97 143.04,45.25 142.82,45.47 142.51,45.47 142.01,44.97 141.64,44.97 141.28,44.61 140.6,44.61 140.22,44.22 139.85,44.22 139.28,43.65 138.91,43.65 138.49,43.22 138.35,43.22 137.35,42.22 136.65,42.22 135.87,41.44 135.87,39.52 v1(136.24,39.15)
DDR4_COMP_CH1_DQ4: length 53.1
  L07_SIG3 w0.089: v1(165.11,23.26) 165.34,23.26 165.43,23.17 165.43,22.99 165.34,22.9 164.96,22.9 164.68,23.18 164.68,25.92 164.79,26.04 165.43,26.04 165.57,26.19 165.57,27.42 165.98,27.82 165.98,28.29 165.86,28.41 165.6,28.41 165.48,28.29 165.48,27.91 165.26,27.69 164.83,27.69 164.68,27.83 164.68,29.02 164.44,29.27 164.44,29.39 164.57,29.53 164.57,29.65 164.46,29.77 164.33,29.77 164.2,29.63 164.07,29.63 163.95,29.75 163.95,29.88 164.09,30.01 164.09,30.14 163.97,30.25 163.84,30.25 163.71,30.12 163.59,30.12 163.47,30.24 163.47,30.36 163.6,30.5 163.6,30.62 163.49,30.74 163.36,30.74 163.23,30.6 163.1,30.6 162.8,30.9 162.21,30.9 161.97,31.14 161.97,31.57 161.65,31.89 160.54,31.89 160.46,31.98 160.46,32.88 160.37,32.97 160.2,32.97 160.11,32.88 160.11,31.98 160.02,31.89 159.86,31.89 159.77,31.98 159.77,32.88 159.68,32.97 159.52,32.97 159.43,32.88 159.43,31.98 159.34,31.89 158.53,31.89 158.21,32.21 158.21,32.42 158.33,32.54 158.59,32.54 158.68,32.63 158.68,32.79 158.59,32.88 158.3,32.88 158.21,32.97 158.21,33.1 158.33,33.23 158.59,33.23 158.68,33.31 158.68,33.48 158.59,33.57 158.3,33.57 158.21,33.66 158.21,33.79 158.33,33.91 158.59,33.91 158.68,34 158.68,34.17 158.59,34.25 158.3,34.25 158.21,34.34 158.21,34.47 158.33,34.6 158.59,34.6 158.68,34.69 158.68,34.85 158.59,34.94 158.3,34.94 158.21,35.03 158.21,35.33 152.31,41.23 148.4,41.23 146.34,39.16 146.05,39.16 145.92,39.3 145.92,39.43 145.83,39.52 145.66,39.52 145.57,39.43 145.57,39.3 145.49,39.21 145.32,39.21 145.23,39.3 145.23,39.43 145.14,39.52 144.98,39.52 144.89,39.43 144.89,39.3 144.8,39.21 144.63,39.21 144.55,39.3 144.55,39.43 144.46,39.52 144.29,39.52 144.2,39.43 144.2,39.3 144.11,39.21 143.28,39.21 142.93,39.56 142.46,39.56 142.03,39.98 141.61,39.98 141.24,39.61 v1(140.23,39.61)
DDR4_COMP_CH1_DQ5: length 54.6
  L07_SIG3 w0.089: v1(136.24,38.23) 136.66,38.64 136.66,41.6 136.94,41.88 138.22,41.88 139.03,42.69 139.63,42.69 140.14,43.2 140.4,43.2 140.67,43.47 141.14,43.47 141.67,44 141.92,44 142.27,43.65 143,43.65 143.34,44 143.69,44 144.04,43.65 144.55,43.65 145.2,44.3 145.54,44.3 145.63,44.39 145.63,44.64 145.72,44.72 145.88,44.72 145.97,44.64 145.97,44.39 146.06,44.3 146.22,44.3 146.31,44.39 146.31,44.64 146.4,44.72 146.57,44.72 146.66,44.64 146.66,44.39 146.75,44.3 146.91,44.3 147,44.39 147,44.64 147.09,44.72 147.25,44.72 147.34,44.64 147.34,44.39 147.43,44.3 147.6,44.3 147.69,44.39 147.69,44.64 147.77,44.72 147.94,44.72 148.03,44.64 148.03,44.39 148.13,44.29 148.8,44.29 148.87,44.22 149.2,44.22 149.26,44.29 152.35,44.29 157.54,39.1 158.58,39.1 165.21,32.46 165.7,32.46 168.52,29.63 169.83,29.63 170.4,29.06 170.4,23.92 170.13,23.65 169.5,23.65 v1(169.11,23.26)
DDR4_COMP_CH1_DQ6: length 53.2
  L07_SIG3 w0.089: v1(164.31,24.06) 163.88,24.49 163.88,29.17 162.49,30.56 161.41,30.56 161.32,30.65 161.32,31.44 161.24,31.52 161.07,31.52 160.98,31.44 160.98,30.65 160.89,30.56 160.72,30.56 160.63,30.65 160.63,31.44 160.54,31.53 160.38,31.53 160.29,31.44 160.29,30.65 160.2,30.56 160.03,30.56 159.94,30.65 159.94,31.44 159.86,31.53 159.69,31.53 159.6,31.44 159.6,30.65 159.51,30.56 159.35,30.56 159.26,30.65 159.26,31.44 159.17,31.53 159,31.53 158.92,31.44 158.92,30.65 158.83,30.56 158.66,30.56 158.57,30.65 158.57,31.44 158.48,31.53 158.32,31.53 158.23,31.44 158.23,30.65 158.14,30.56 157.97,30.56 157.85,30.69 157.85,31.2 157.76,31.29 156.1,31.29 156.01,31.38 156.01,31.54 156.1,31.63 157.76,31.63 157.85,31.72 157.85,31.89 157.76,31.98 156.1,31.98 156.01,32.07 156.01,32.23 156.1,32.32 157.76,32.32 157.85,32.41 157.85,35.21 152.17,40.88 148.54,40.88 145.92,38.26 145.57,38.26 145.48,38.35 145.48,38.51 145.39,38.6 145.23,38.6 145.14,38.51 145.14,38.35 145.05,38.26 143.31,38.26 142.97,38.6 142.47,38.6 141.92,39.15 141.03,39.15 v1(141,39.12)
DDR4_COMP_CH1_DQ7: length 54.7
  L07_SIG3 w0.089: v1(137.04,39.61) 137.46,40.03 137.46,41.14 137.71,41.39 138.22,41.39 139.17,42.34 139.79,42.34 139.93,42.2 140.65,42.2 141.59,43.14 141.95,43.14 142.45,42.65 142.91,42.65 143.36,43.11 143.68,43.11 143.93,42.86 145.32,42.86 145.41,42.95 145.41,43.85 145.5,43.94 145.67,43.94 145.76,43.85 145.76,42.92 145.85,42.83 146.01,42.83 146.1,42.92 146.1,43.85 146.19,43.94 146.35,43.94 146.44,43.85 146.44,42.92 146.53,42.83 146.7,42.83 146.79,42.92 146.79,43.85 146.87,43.94 147.22,43.94 147.31,43.85 147.31,43.5 147.4,43.42 147.56,43.42 147.65,43.5 147.65,43.85 147.74,43.94 148.08,43.94 148.17,43.85 148.17,43.76 148.26,43.67 149.8,43.67 149.88,43.76 149.88,43.85 149.97,43.94 150.14,43.94 150.23,43.85 150.23,43.76 150.32,43.67 150.48,43.67 150.57,43.76 150.57,43.85 150.66,43.94 150.82,43.94 150.91,43.85 150.91,43.76 151,43.67 151.17,43.67 151.26,43.76 151.26,43.85 151.35,43.94 152.21,43.94 157.4,38.75 158.43,38.75 165.1,32.09 165.58,32.09 168.44,29.24 169.31,29.24 169.5,29.05 169.5,24.67 169.32,24.48 168.92,24.48 168.68,24.25 168.68,23.64 v1(168.31,23.26)
DDR4_COMP_CH1_DQ8: length 26.6
  L03_SIG1 w0.081: v1(130.66,39.61) 130.66,39.21 131.27,38.61 131.58,38.61 131.59,38.6 131.61,38.6 131.83,38.38 131.83,37.55 138.4,30.98 138.4,29.44 138.61,29.23 140.16,29.23 141.31,28.09 141.31,22.41 141,22.1 139.58,22.1 139.58,22.09 139.27,22.09 139.27,22.1 138.78,22.1 138.78,22.09 138.47,22.09 138.47,22.1 137.92,22.1 137.83,22.19 v5(137.83,22.46)
DDR4_COMP_CH1_DQ9: length 28.8
  L03_SIG1 w0.081: v1(127.48,37.77) 127.56,37.68 127.56,36.96 127.88,36.64 127.88,35.8 127.96,35.71 128.39,35.71 128.48,35.63 128.48,35.47 128.39,35.39 127.96,35.39 127.88,35.31 127.88,35.15 127.96,35.06 128.39,35.06 128.48,34.98 128.48,34.82 128.39,34.74 127.96,34.74 127.88,34.66 127.88,34.5 127.96,34.41 128.39,34.41 128.48,34.33 128.48,34.17 128.39,34.09 127.96,34.09 127.88,34.01 127.88,33.4 128.37,32.91 128.48,32.91 128.8,33.22 128.91,33.22 129.03,33.1 129.03,32.99 128.72,32.67 128.72,32.56 128.84,32.44 128.96,32.44 129.27,32.75 129.38,32.75 129.51,32.63 129.51,32.51 129.19,32.2 129.19,32.08 129.32,31.96 129.43,31.96 129.74,32.27 129.86,32.27 129.98,32.15 129.98,32.04 129.67,31.72 129.67,31.61 129.79,31.49 129.9,31.49 130.22,31.8 130.33,31.8 130.45,31.68 130.45,31.56 130.14,31.25 130.14,31.14 130.26,31.01 130.38,31.01 130.69,31.33 130.81,31.33 130.93,31.2 130.93,31.09 130.62,30.78 130.62,30.66 130.74,30.54 130.85,30.54 131.17,30.85 131.28,30.85 131.4,30.73 131.4,30.62 131.09,30.3 131.09,30.19 131.21,30.07 131.33,30.07 131.64,30.38 131.75,30.38 131.88,30.26 131.88,30.14 131.56,29.83 131.56,29.71 131.69,29.59 131.8,29.59 132,29.79 132.12,29.79 132.24,29.67 132.24,29.56 132.04,29.35 132.04,29.24 132.84,28.43 133.18,28.43 133.4,28.22 133.4,23.97 133.69,23.68 134.21,23.68 v5(134.63,23.26)
DDR4_COMP_CH1_DQ10: length 27.2
  L03_SIG1 w0.081: v1(130.66,37.77) 130.55,37.77 130.28,37.5 130.28,37.27 130.62,36.92 130.74,36.92 131.07,37.25 131.18,37.25 131.3,37.13 131.3,37.02 130.98,36.69 130.98,36.57 131.1,36.45 131.21,36.45 131.54,36.78 131.66,36.78 131.78,36.66 131.78,36.54 131.45,36.21 131.45,36.1 131.57,35.98 131.69,35.98 132.02,36.3 132.13,36.3 132.25,36.18 132.25,36.07 131.93,35.74 131.93,35.62 132.05,35.5 132.16,35.5 132.49,35.83 132.61,35.83 132.73,35.71 132.73,35.59 132.4,35.27 132.4,35.15 132.52,35.03 132.64,35.03 132.96,35.36 133.08,35.36 133.2,35.23 133.2,35.12 132.87,34.79 132.87,34.68 133,34.55 133.11,34.55 133.44,34.88 133.55,34.88 133.68,34.76 133.68,34.64 133.35,34.32 133.35,34.2 133.47,34.08 133.58,34.08 133.91,34.41 134.03,34.41 137.69,30.75 137.69,28.45 138.51,27.63 139.58,27.63 139.8,27.42 139.8,23.91 139.58,23.69 139.06,23.69 v5(138.63,23.26)
DDR4_COMP_CH1_DQ11: length 26.8
  L03_SIG1 w0.081: v5(137.83,24.86) 137.83,24.53 137.91,24.45 138.9,24.45 139,24.55 139,26.78 138.9,26.88 137.09,26.88 136.97,27 136.97,27.52 136.6,27.88 136.6,28.91 136.73,29.03 136.73,29.24 136.6,29.36 136.6,29.58 136.9,29.87 136.9,30.24 136.37,30.76 136.37,30.88 136.67,31.18 136.67,31.29 136.55,31.41 136.43,31.41 136.11,31.09 135.99,31.09 135.87,31.21 135.87,31.32 136.2,31.65 136.2,31.77 136.07,31.89 135.96,31.89 135.63,31.56 135.52,31.56 135.39,31.68 135.39,31.8 135.72,32.12 135.72,32.24 135.6,32.36 135.48,32.36 135.16,32.03 135.04,32.03 134.92,32.16 134.92,32.27 135.25,32.6 135.25,32.71 135.13,32.84 135.01,32.84 134.68,32.51 134.57,32.51 134.45,32.63 134.45,32.75 134.77,33.07 134.77,33.19 134.65,33.31 134.54,33.31 134.21,32.98 134.09,32.98 133.97,33.1 133.97,33.22 134.31,33.55 134.31,33.65 134.18,33.78 134.06,33.78 133.73,33.46 133.62,33.46 129.87,37.21 v1(129.87,38.23)
DDR4_COMP_CH1_DQ12: length 29.8
  L03_SIG1 w0.081: v1(127.48,39.61) 127.9,39.19 127.9,37.14 128.81,36.22 128.81,35.21 128.89,35.12 128.92,35.12 129,35.04 129,34.87 128.92,34.79 128.89,34.79 128.81,34.71 128.81,33.95 129.09,33.67 129.21,33.67 129.93,34.39 130.04,34.39 130.17,34.27 130.17,34.16 129.44,33.43 129.44,33.32 129.57,33.2 129.68,33.2 130.4,33.92 130.52,33.92 130.64,33.8 130.64,33.68 129.92,32.96 129.92,32.85 130.16,32.61 130.27,32.61 130.58,32.91 130.69,32.91 130.81,32.79 130.81,32.68 130.51,32.37 130.51,32.26 131.2,31.57 131.31,31.57 131.45,31.7 131.56,31.7 131.69,31.58 131.69,31.47 131.55,31.33 131.55,31.22 131.79,30.98 131.9,30.98 132.44,31.51 132.55,31.51 132.67,31.39 132.67,31.28 132.14,30.74 132.14,30.63 132.26,30.5 132.38,30.5 132.91,31.04 133.03,31.04 133.15,30.92 133.15,30.8 132.61,30.27 132.61,30.15 132.73,30.03 132.85,30.03 133.38,30.57 133.5,30.57 133.62,30.44 133.62,30.33 133.09,29.79 133.09,29.68 133.46,29.3 133.93,29.3 134.2,29.03 134.2,27.55 134.2,27.55 134.2,24.44 v5(133.83,24.06)
DDR4_COMP_CH1_DQ13: length 28.9
  L03_SIG1 w0.081: v5(134.63,22.46) 134.23,22.86 132.51,22.86 131.33,24.04 131.33,25.78 131.25,25.87 130.78,25.87 130.7,25.95 130.7,26.12 130.78,26.2 131.25,26.2 131.33,26.28 131.33,26.45 131.25,26.54 130.64,26.54 130.56,26.62 130.56,26.79 130.64,26.87 131.25,26.87 131.33,26.95 131.33,27.12 131.25,27.21 130.64,27.21 130.56,27.29 130.56,27.46 130.64,27.54 131.25,27.54 131.33,27.62 131.33,27.8 131.25,27.88 130.64,27.88 130.56,27.96 130.56,28.13 130.64,28.21 131.08,28.21 131.16,28.29 131.16,28.79 131.01,28.95 130.89,28.95 130.6,28.66 130.49,28.66 130.37,28.78 130.37,28.9 130.66,29.19 130.66,29.3 130.53,29.42 130.42,29.42 130.13,29.13 130.01,29.13 129.89,29.26 129.89,29.37 130.18,29.66 130.18,29.78 130.06,29.9 129.94,29.9 129.65,29.61 129.54,29.61 129.42,29.73 129.42,29.85 129.71,30.13 129.71,30.25 129.06,30.9 127.65,30.9 126.35,32.19 126.35,33.14 126.49,33.28 126.49,34.96 126.68,35.15 v1(126.68,38.23)
DDR4_COMP_CH1_DQ14: length 26.9
  L03_SIG1 w0.081: v5(137.83,23.26) 138.1,23.26 138.2,23.17 138.2,22.91 138.28,22.83 140.03,22.83 140.4,23.2 140.4,25.27 140.48,25.35 140.88,25.35 140.96,25.43 140.96,25.6 140.87,25.68 140.48,25.68 140.4,25.77 140.4,25.94 140.48,26.02 140.83,26.02 140.91,26.1 140.91,26.27 140.83,26.36 140.48,26.36 140.4,26.44 140.4,26.61 140.48,26.69 140.83,26.69 140.91,26.77 140.91,26.94 140.83,27.03 140.48,27.03 140.4,27.11 140.4,27.44 139.95,27.9 139.95,28.07 139.58,28.43 138.47,28.43 138.07,28.83 138.07,30.84 131.09,37.82 131.09,38.19 130.96,38.32 130.48,38.32 129.87,38.93 v1(129.87,39.15)
DDR4_COMP_CH1_DQ15: length 30.3
  L03_SIG1 w0.081: v1(126.68,39.15) 127.11,38.72 127.11,36.94 127.55,36.5 127.55,35.75 127.46,35.67 127.1,35.67 127.01,35.58 127.01,35.34 127.1,35.26 127.46,35.26 127.55,35.18 127.55,34.08 127.46,34 126.94,34 126.85,33.92 126.85,33.75 126.94,33.67 127.46,33.67 127.55,33.59 127.55,33.14 127,32.59 127,32.48 127.15,32.34 127.26,32.34 127.79,32.87 127.93,32.87 128.52,32.28 128.52,32.17 128.2,31.85 128.2,31.74 128.32,31.61 128.44,31.61 128.75,31.93 128.87,31.93 131.97,28.83 131.97,28.71 131.72,28.47 131.72,28.35 131.88,28.19 132.02,28.19 132.26,28.43 132.38,28.43 132.62,28.18 132.62,26.89 132.54,26.81 131.92,26.81 131.84,26.73 131.84,26.56 131.92,26.48 132.54,26.48 132.62,26.4 132.62,26.22 132.54,26.14 131.92,26.14 131.84,26.06 131.84,25.89 131.92,25.81 132.54,25.81 132.62,25.73 132.62,25.55 132.54,25.47 131.92,25.47 131.84,25.39 131.84,25.22 131.92,25.14 132.54,25.14 132.62,25.06 132.62,24.88 132.54,24.8 131.92,24.8 131.84,24.72 131.84,24.55 131.92,24.47 132.54,24.47 132.62,24.38 132.62,23.79 132.72,23.69 133.14,23.69 133.57,23.26 v5(133.83,23.26)
DDR4_COMP_CH1_DQ16: length 28.6
  L03_SIG1 w0.081: v1(125.09,40.07) 125.51,39.64 125.51,37.92 125.01,37.42 125.01,36.05 125.26,35.79 125.26,32.05 127.37,29.94 127.37,29.8 127.46,29.72 127.63,29.72 127.71,29.8 127.71,29.94 127.79,30.02 127.96,30.02 128.04,29.94 128.04,29.8 128.13,29.72 128.46,29.72 128.9,29.28 128.9,27.83 129.03,27.69 129.53,27.69 129.83,27.39 129.83,26.76 129.64,26.57 129.64,26.4 129.83,26.2 129.83,26.06 129.64,25.87 129.64,25.73 129.82,25.55 129.82,25.43 129.64,25.25 129.64,25.06 129.83,24.86 129.83,24.71 129.64,24.52 129.64,24.39 129.83,24.19 129.83,23.77 129.75,23.69 129.34,23.69 129.26,23.61 129.26,23.43 129.34,23.35 129.75,23.35 129.83,23.27 129.83,22.94 129.73,22.83 128.94,22.83 128.86,22.91 128.86,23.52 128.75,23.63 128.18,23.63 128.04,23.77 128.04,24.34 128.19,24.49 128.76,24.49 128.84,24.57 128.84,25.15 128.75,25.24 127.75,25.24 127.67,25.16 v5(127.67,24.86)
DDR4_COMP_CH1_DQ17: length 30.3
  L03_SIG1 w0.081: v1(121.9,41.91) 121.01,41.91 120.46,41.36 120.13,41.36 119.67,40.9 119.35,40.9 119.14,40.68 119.14,36.96 120.41,35.69 120.41,22.92 122.1,21.24 126.92,21.24 127.3,21.62 127.3,21.84 127.67,22.21 v5(127.67,22.46)
DDR4_COMP_CH1_DQ18: length 28.2
  L03_SIG1 w0.081: v5(124.47,23.26) 124.2,23.26 124.1,23.37 124.1,27.57 123.98,27.69 123.33,27.69 123.25,27.77 123.25,28.41 123.34,28.49 124,28.49 124.1,28.59 124.1,30.6 122.98,31.71 122.98,37.4 123.07,37.48 123.07,37.92 123.07,40.47 123.21,40.62 123.65,40.62 123.86,40.83 123.86,41.81 123.95,41.89 124.54,41.89 125.06,41.37 125.21,41.37 125.8,41.96 126.06,41.96 126.54,42.45 126.86,42.45 127.29,42.02 127.29,41.79 126.86,41.36 126.53,41.36 126.18,41.01 125.87,41.01 125.78,41.1 125.78,41.35 v1(125.88,41.45)
DDR4_COMP_CH1_DQ19: length 29.6
  L03_SIG1 w0.081: v1(122.7,41.45) 121.82,41.45 121.29,40.92 120.98,40.92 120.67,40.62 120.22,40.62 119.91,40.3 119.91,36.66 120.75,35.83 120.75,23.2 122.02,21.94 122.62,21.94 122.75,22.08 124.13,22.08 124.63,21.57 126.78,21.57 126.96,21.76 126.96,21.97 127.3,22.31 127.3,22.62 127.67,22.99 v5(127.67,23.26)
DDR4_COMP_CH1_DQ20: length 28.4
  L03_SIG1 w0.081: v1(125.88,40.53) 126.27,40.14 126.27,37.43 125.81,36.98 125.81,35.45 125.61,35.25 125.61,32.26 127.51,30.36 128.3,30.36 129.79,28.87 129.79,27.91 130.17,27.53 130.17,23.59 130.64,23.12 131.85,23.12 131.96,23 131.96,22.86 131.83,22.73 130.8,22.73 130.72,22.65 130.72,22.18 130.64,22.1 130.4,22.1 130.32,22.01 130.32,21.64 130.24,21.55 130.06,21.55 129.98,21.64 129.98,22.01 129.9,22.09 128.31,22.09 128.1,22.31 128.1,22.89 128.46,23.26 v5(128.47,23.26)
DDR4_COMP_CH1_DQ21: length 28.3
  L03_SIG1 w0.081: v1(125.09,41.91) 125.27,41.91 125.49,42.12 125.49,42.35 125.38,42.46 124.92,42.46 124.46,42.92 124.11,42.92 123.65,42.46 123.18,42.46 123.1,42.37 123.1,41.08 122.91,40.9 122.54,40.9 122.14,40.5 121.8,40.5 121.35,40.04 120.99,40.04 120.69,39.74 120.69,39.72 120.68,39.71 120.68,36.37 121.08,35.97 121.08,23.34 121.59,22.84 124.36,22.84 124.47,22.73 124.47,22.51 v5(124.44,22.49)
DDR4_COMP_CH1_DQ22: length 30.6
  L03_SIG1 w0.081: v5(123.67,24.06) 123.67,24.34 123.3,24.71 123.3,25.02 123.3,25.82 123.3,26.31 123.3,26.31 123.3,26.62 123.3,26.75 123.16,26.89 122.7,26.89 122.39,27.2 122.39,27.52 122.28,27.64 121.9,27.64 121.83,27.7 121.83,28.14 121.9,28.21 122.22,28.21 122.31,28.3 122.31,29.19 122.4,29.29 123.38,29.29 123.46,29.37 123.46,29.8 123.19,30.08 123.19,31.01 123.11,31.09 121.84,31.09 121.75,31.17 121.75,31.5 121.89,31.64 122.54,31.64 122.65,31.74 122.65,31.95 122.58,32.01 121.92,32.01 121.81,32.12 121.81,32.79 121.89,32.88 122.56,32.88 122.64,32.96 122.64,33.13 122.56,33.21 121.89,33.21 121.81,33.29 121.81,36.97 121.97,37.13 122.11,37.13 122.3,36.94 122.3,34.15 122.38,34.08 122.59,34.08 122.65,34.13 122.65,37.2 122.29,37.55 122.29,39.75 122.7,40.15 v1(122.7,40.53)
DDR4_COMP_CH1_DQ23: length 30.5
  L03_SIG1 w0.081: v5(123.67,23.26) 123.32,23.26 123.24,23.34 123.24,23.55 123.16,23.63 122.71,23.63 122.25,23.17 121.73,23.17 121.44,23.46 121.44,25.03 121.52,25.11 121.86,25.11 121.94,25.03 121.94,24.39 121.99,24.34 122.22,24.34 122.27,24.39 122.27,25.03 122.35,25.11 122.59,25.11 122.7,25.22 122.7,25.31 122.56,25.45 121.52,25.45 121.42,25.55 121.42,25.71 121.5,25.79 122.39,25.79 122.47,25.87 122.47,26.04 122.39,26.12 121.52,26.12 121.42,26.22 121.42,26.42 121.46,26.46 122.39,26.46 122.47,26.54 122.47,26.65 122.33,26.79 121.52,26.79 121.44,26.87 121.44,28.56 121.52,28.64 121.89,28.64 121.98,28.72 121.98,28.89 121.89,28.97 121.52,28.97 121.44,29.05 121.44,29.23 121.52,29.31 121.89,29.31 121.98,29.39 121.98,29.56 121.89,29.64 121.52,29.64 121.44,29.72 121.44,29.9 121.52,29.98 121.95,29.98 122.03,30.06 122.03,30.21 121.92,30.31 121.52,30.31 121.42,30.42 121.42,36.1 121.01,36.51 121.01,37.22 121.09,37.31 121.41,37.31 121.47,37.37 121.47,37.92 121.47,39.46 121.59,39.58 121.81,39.58 121.9,39.66 121.9,40.06 v1(121.93,40.09)
DDR4_COMP_CH1_DQ24: length 40
  L05_SIG2 w0.081: v1(121.9,43.75) 121.9,43.56 122.47,42.99 122.47,42.73 122.32,42.58 122.32,42.2 122.59,41.93 122.88,41.93 123.07,41.75 123.07,37.21 123.26,37.03 124.65,37.03 124.75,37.13 124.75,37.56 124.87,37.69 125.39,37.69 126.04,37.03 131.14,37.03 131.55,36.62 131.55,36.29 131.47,36.21 130.81,36.21 130.73,36.12 130.73,35.95 130.81,35.87 131.47,35.87 131.55,35.79 131.55,35.62 131.47,35.54 130.81,35.54 130.73,35.45 130.73,35.28 130.81,35.2 131.47,35.2 131.55,35.12 131.55,34.95 131.47,34.87 130.81,34.87 130.73,34.78 130.73,34.61 130.81,34.53 131.42,34.53 131.52,34.42 131.52,31.82 131.66,31.68 131.99,31.68 132.07,31.77 132.07,32.04 132.15,32.12 132.33,32.12 132.41,32.04 132.41,31.77 132.49,31.68 132.66,31.68 132.74,31.77 132.74,32.04 132.8,32.09 133.02,32.09 133.08,32.04 133.08,31.77 133.16,31.68 133.33,31.68 133.41,31.77 133.41,32.04 133.47,32.09 133.69,32.09 133.75,32.04 133.75,31.77 133.83,31.68 134,31.68 134.08,31.77 134.08,32.04 134.14,32.09 134.37,32.09 134.42,32.04 134.42,31.77 134.5,31.68 134.67,31.68 134.75,31.77 134.75,32.04 134.81,32.09 135.04,32.09 135.09,32.04 135.09,31.77 135.17,31.68 135.34,31.68 135.42,31.77 135.42,32.04 135.48,32.09 135.71,32.09 135.76,32.04 135.76,31.77 135.84,31.68 136.87,31.68 139.04,29.51 139.04,28.75 138.63,28.33 v1(138.63,28.06)
DDR4_COMP_CH1_DQ25: length 42.2
  L05_SIG2 w0.081: v1(118.71,42.83) 118.71,42.43 119.09,42.06 119.09,36.8 119.55,36.33 119.74,36.33 119.93,36.14 119.93,30.61 120.44,30.09 125.72,30.09 126.16,30.53 126.16,31.45 126.08,31.53 125.36,31.53 125.28,31.61 125.28,31.78 125.36,31.87 126.08,31.87 126.16,31.95 126.16,32.12 126.08,32.2 125.36,32.2 125.28,32.28 125.28,32.45 125.36,32.54 126.08,32.54 126.16,32.62 126.16,32.79 126.08,32.87 125.36,32.87 125.28,32.95 125.28,33.12 125.36,33.21 126.08,33.21 126.16,33.29 126.16,33.73 126.41,33.98 128.67,33.98 128.89,33.76 128.89,27.83 129.09,27.63 134.26,27.63 v1(134.63,27.26)
DDR4_COMP_CH1_DQ26: length 39.7
  L05_SIG2 w0.081: v1(137.83,27.26) 137.88,27.26 138.26,27.64 138.76,27.64 139.06,27.94 139.06,28.22 139.27,28.43 139.62,28.43 139.8,28.61 139.8,29.23 136.98,32.05 136.3,32.05 135.9,32.45 135.19,32.45 135.11,32.54 135.11,32.9 135.03,32.98 134.86,32.98 134.78,32.9 134.78,32.54 134.7,32.45 134.52,32.45 134.44,32.54 134.44,32.9 134.36,32.98 134.19,32.98 134.11,32.9 134.11,32.54 134.03,32.45 133.85,32.45 133.77,32.54 133.77,32.9 133.69,32.98 133.52,32.98 133.44,32.9 133.44,32.54 133.36,32.45 132.23,32.45 132.01,32.67 132.01,33.24 132.17,33.39 132.79,33.39 132.87,33.47 132.87,33.65 132.79,33.73 132.01,33.73 131.93,33.81 131.93,33.98 132.01,34.06 132.79,34.06 132.87,34.15 132.87,34.32 132.79,34.4 132.01,34.4 131.93,34.48 131.93,34.65 132.01,34.73 132.79,34.73 132.87,34.82 132.87,34.99 132.79,35.07 132.01,35.07 131.93,35.15 131.93,35.32 132.01,35.4 132.79,35.4 132.87,35.49 132.87,35.66 132.79,35.74 132.01,35.74 131.93,35.82 131.93,36.72 131.28,37.36 126.86,37.36 126.07,38.16 123.97,38.16 123.87,38.26 123.87,42.15 123.65,42.37 v1(122.7,42.37)
DDR4_COMP_CH1_DQ27: length 42.4
  L05_SIG2 w0.081: v1(119.51,42.37) 119.51,42.08 119.93,41.66 119.93,40.22 119.88,40.17 119.88,39.45 119.66,39.24 119.66,39.06 119.88,38.84 119.88,38.53 119.66,38.32 119.66,38.14 119.91,37.88 119.91,36.98 120.3,36.59 120.3,35.49 120.85,34.94 121.6,34.94 121.69,34.86 121.69,34.69 121.6,34.61 120.85,34.61 120.77,34.53 120.77,34.36 120.85,34.27 121.6,34.27 121.69,34.19 121.69,34.02 121.6,33.94 120.85,33.94 120.77,33.86 120.77,33.68 120.85,33.6 121.6,33.6 121.69,33.52 121.69,33.35 121.6,33.27 120.85,33.27 120.77,33.19 120.77,33.01 120.85,32.93 121.6,32.93 121.69,32.85 121.69,32.68 121.6,32.6 120.85,32.6 120.77,32.52 120.77,32.34 120.85,32.26 121.6,32.26 121.69,32.18 121.69,32.01 121.6,31.93 120.85,31.93 120.77,31.85 120.77,31.34 121.03,31.08 124.42,31.08 124.69,31.35 124.69,34.11 124.99,34.4 128.96,34.4 129.24,34.12 129.24,29.57 130.38,28.43 134.2,28.43 v1(134.63,28.86)
DDR4_COMP_CH1_DQ28: length 40.5
  L05_SIG2 w0.081: v1(122.7,44.21) 123.71,44.21 124.13,43.79 124.47,43.79 124.88,43.38 125.12,43.38 125.48,43.01 125.48,40.37 125.72,40.13 125.93,40.13 126.45,39.61 126.85,39.61 127.24,39.21 127.58,39.21 128.08,38.71 128.43,38.71 128.84,39.12 129.37,39.12 129.78,38.71 130.17,38.71 130.51,39.06 130.87,39.06 131.15,38.78 131.45,38.78 132.09,38.14 132.41,38.14 132.99,37.56 133.27,37.56 134.44,36.39 134.44,34.66 134.52,34.58 135.14,34.58 135.22,34.5 135.22,34.32 135.14,34.24 134.52,34.24 134.44,34.16 134.44,33.82 134.58,33.67 135.97,33.67 136.57,33.07 137.93,33.07 138.17,32.83 138.17,32.71 137.81,32.35 137.81,32.23 137.93,32.11 138.04,32.11 138.41,32.48 138.52,32.48 138.65,32.35 138.65,32.24 138.28,31.87 138.28,31.76 138.4,31.64 138.52,31.64 138.88,32 139,32 139.12,31.88 139.12,31.77 138.75,31.4 138.75,31.29 138.88,31.16 138.99,31.16 139.36,31.53 139.47,31.53 139.59,31.41 139.59,31.29 139.23,30.93 139.23,30.81 139.35,30.69 139.47,30.69 139.83,31.05 139.95,31.05 140.07,30.93 140.07,30.82 139.7,30.45 139.7,30.34 139.82,30.21 139.94,30.21 140.31,30.58 140.42,30.58 140.69,30.31 140.69,27.88 139.66,26.86 138.22,26.86 v1(137.83,26.46)
DDR4_COMP_CH1_DQ29: length 40.3
  L05_SIG2 w0.081: v1(118.71,43.75) 120.12,43.75 120.95,42.92 121.2,42.92 121.6,42.51 121.6,42.13 121.53,42.06 121.53,41.71 121.79,41.45 122.07,41.45 122.32,41.19 122.32,37.49 123.12,36.69 130.07,36.69 130.38,36.38 130.38,31.61 130.64,31.35 136.73,31.35 138.25,29.84 138.25,28.28 137.56,27.59 136.53,27.59 136.4,27.73 136.4,28.72 136.21,28.91 135.41,28.91 135.27,28.77 135.27,26.95 135.19,26.87 134.45,26.87 134.05,27.26 v1(133.83,27.26)
DDR4_COMP_CH1_DQ30: length 39
  L05_SIG2 w0.081: v1(121.9,42.83) 121.53,43.2 121.53,44.01 121.71,44.19 121.98,44.19 122.51,43.66 122.97,43.66 123.33,43.3 123.59,43.3 124.03,42.86 124.36,42.86 124.71,42.51 124.71,38.63 124.82,38.52 125.11,38.52 125.67,39.08 126.13,39.08 126.54,38.66 126.83,38.66 127.26,38.24 127.56,38.24 128.02,37.77 128.46,37.77 128.9,38.21 129.36,38.21 129.74,37.83 130.2,37.83 130.51,38.14 130.98,38.14 131.41,37.7 131.42,37.7 132.26,36.86 132.26,36.85 132.26,36.5 132.34,36.42 133.06,36.42 133.21,36.27 133.21,35.71 133.29,35.63 133.98,35.63 134.07,35.55 134.07,35.37 133.98,35.29 133.29,35.29 133.21,35.21 133.21,35.04 133.29,34.96 133.98,34.96 134.07,34.88 134.07,34.7 133.98,34.62 133.29,34.62 133.21,34.54 133.21,34.37 133.29,34.29 133.98,34.29 134.07,34.21 134.07,34.03 133.98,33.95 133.29,33.95 133.21,33.87 133.21,33.54 133.41,33.34 135.83,33.34 136.43,32.73 136.83,32.73 140.15,29.42 140.15,28.49 139.8,28.14 139.8,27.74 139.69,27.63 139.27,27.63 138.9,27.26 v1(138.63,27.26)
DDR4_COMP_CH1_DQ31: length 40.4
  L05_SIG2 w0.081: v1(119.51,44.21) 118.58,44.21 118.34,43.97 118.34,42.06 118.34,36.38 118.83,35.89 118.83,30.09 119.65,29.27 125.5,29.27 127.11,30.88 127.11,32.66 127.32,32.87 128.17,32.87 128.37,32.66 128.37,29.93 128.04,29.59 128.04,27.1 128.29,26.85 133.99,26.85 134.37,26.46 v1(134.63,26.46)
DDR4_COMP_CH1_DQ32: length 48.7
  L07_SIG3 w0.089: v1(126.68,42.83) 127.1,42.41 127.1,41.1 127.31,40.89 127.32,40.9 127.63,40.9 128.09,40.44 128.43,40.44 128.84,40.03 129.18,40.03 129.73,40.59 130.12,40.59 130.29,40.42 130.29,38.53 130.29,37.43 130.46,37.26 130.97,37.26 135.11,33.12 135.11,31.47 135.24,31.34 135.54,31.34 135.63,31.43 135.63,31.79 135.74,31.9 140.34,31.9 140.5,31.74 140.68,31.74 140.84,31.9 141.02,31.9 141.18,31.74 141.36,31.74 141.53,31.9 142.66,31.9 142.78,31.78 142.78,31.46 142.69,31.37 141.87,31.37 141.78,31.28 141.78,31.12 141.87,31.03 142.63,31.03 142.84,30.83 142.84,30.35 142.93,30.26 143.11,30.26 143.2,30.35 143.2,31.8 143.3,31.9 143.47,31.9 143.54,31.83 143.54,30.35 143.63,30.26 143.8,30.26 143.89,30.35 143.89,31.8 143.99,31.9 144.16,31.9 144.23,31.83 144.23,30.35 144.32,30.26 144.66,30.26 144.75,30.35 144.75,31.82 144.83,31.9 145.01,31.9 145.09,31.82 145.09,30.46 145.18,30.37 148.86,30.37 150.05,29.18 150.05,27.86 149.85,27.66 148.88,27.66 148.79,27.57 v1(148.79,27.26)
DDR4_COMP_CH1_DQ33: length 50.7
  L07_SIG3 w0.089: v1(123.49,42.83) 123.9,42.42 123.9,39.47 124.13,39.23 124.3,39.23 125.01,38.53 125.01,35.68 125.26,35.43 127.28,35.43 127.37,35.34 127.37,34.48 127.46,34.4 127.62,34.4 127.71,34.48 127.71,35.34 127.8,35.43 127.96,35.43 128.05,35.34 128.05,34.48 128.14,34.4 128.31,34.4 128.4,34.48 128.4,35.34 128.49,35.43 128.65,35.43 128.74,35.34 128.74,34.48 128.83,34.4 128.99,34.4 129.08,34.48 129.08,35.34 129.17,35.43 129.34,35.43 129.43,35.34 129.43,34.48 129.51,34.4 129.68,34.4 129.77,34.48 129.77,35.34 129.86,35.43 130.24,35.43 131.55,34.12 131.55,26.45 131.93,26.07 140.15,26.07 140.24,25.98 140.24,25.23 140.33,25.14 140.5,25.14 140.59,25.23 140.59,25.98 140.67,26.07 140.84,26.07 140.93,25.98 140.93,25.23 141.02,25.14 141.18,25.14 141.27,25.23 141.27,25.98 141.36,26.07 141.53,26.07 141.61,25.98 141.61,25.1 141.72,25 141.87,25 141.96,25.09 141.96,25.98 142.05,26.07 142.21,26.07 142.3,25.98 142.3,25.1 142.4,25 142.55,25 142.64,25.09 142.64,25.98 142.73,26.07 143.37,26.07 143.61,26.31 143.61,26.89 v1(143.99,27.26)
DDR4_COMP_CH1_DQ34: length 48.5
  L07_SIG3 w0.089: v1(127.48,42.37) 127.87,41.98 127.87,41.75 128.25,41.36 128.43,41.36 128.73,41.06 129.28,41.06 129.58,41.36 130.22,41.36 130.68,40.9 130.82,40.9 131.04,40.68 131.04,37.92 131.43,37.53 131.43,37.29 135.49,33.23 135.49,32.39 135.64,32.25 135.98,32.25 136.07,32.33 136.07,32.58 136.16,32.66 136.32,32.66 136.41,32.58 136.41,32.33 136.5,32.25 140.64,32.25 140.73,32.33 140.73,33.28 140.81,33.36 140.99,33.36 141.08,33.27 141.08,32.33 141.16,32.25 141.33,32.25 141.42,32.33 141.42,33.3 141.48,33.36 141.67,33.36 141.76,33.27 141.76,32.33 141.85,32.25 142.01,32.25 142.1,32.33 142.1,32.67 142.19,32.76 142.36,32.76 142.45,32.67 142.45,32.33 142.54,32.25 142.7,32.25 142.79,32.33 142.79,32.67 142.88,32.76 143.04,32.76 143.13,32.67 143.13,32.33 143.22,32.25 143.39,32.25 143.48,32.33 143.48,32.67 143.56,32.76 143.73,32.76 143.82,32.67 143.82,32.33 143.91,32.25 144.07,32.25 144.16,32.33 144.16,32.67 144.25,32.76 144.42,32.76 144.5,32.67 144.5,32.33 144.59,32.25 145.7,32.25 145.79,32.16 145.79,30.8 145.88,30.71 149.01,30.71 150.85,28.87 150.85,26.96 150.73,26.84 150.42,26.84 150.33,26.75 150.33,26.47 150.24,26.38 150.08,26.38 149.99,26.47 149.99,26.75 149.9,26.84 149.43,26.84 149.34,26.75 149.03,26.75 148.94,26.84 147.24,26.84 147.07,27.01 147.07,27.41 147.16,27.5 147.9,27.5 147.99,27.41 v1(147.99,27.26)
