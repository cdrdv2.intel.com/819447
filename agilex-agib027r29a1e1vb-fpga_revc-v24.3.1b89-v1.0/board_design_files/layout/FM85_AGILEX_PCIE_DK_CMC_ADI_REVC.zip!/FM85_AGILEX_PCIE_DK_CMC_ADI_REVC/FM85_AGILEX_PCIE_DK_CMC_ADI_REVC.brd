# Allegro board FM85_AGILEX_PCIE_DK_CMC_ADI_REVC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
QSFPDD0_TX3_N: length 57.9
  L03_SIG1 w0.079: v2(49.1,84.84) 49.35,84.59 arc(49.39,84.56) 49.42,84.56 49.6,84.56 arc(49.96,84.41) 50.11,84.04 50.11,83.27 arc(50.33,82.74) 50.86,82.53 51.66,82.53 arc(52.03,82.58) 52.38,82.73 arc(52.75,82.89) 53.16,82.94 57.61,82.94 arc(57.87,82.89) 58.09,82.74 58.23,82.6 arc(58.26,82.58) 58.29,82.58 63.2,82.58 arc(64.23,82.76) 65.12,83.3 arc(65.19,83.36) 65.26,83.42 65.26,83.42 65.25,83.43 65.3,83.47 arc(65.91,83.88) 66.63,84.03 68.42,84.03 arc(68.74,83.96) 69.01,83.78 arc(69.11,83.69) 69.22,83.61 arc(69.26,83.6) 69.3,83.59 76.38,83.59 arc(76.42,83.6) 76.46,83.61 arc(76.95,83.86) 77.38,84.2 78.16,84.98 arc(80.14,86.3) 82.48,86.77 84.46,86.77 arc(88.02,86.06) 91.05,84.04 92.86,82.23 arc(93.38,81.88) 93.99,81.76 94.42,81.76 arc(94.9,81.64) 95.27,81.3 95.53,80.9 arc(95.64,80.8) 95.79,80.76 95.82,80.76 arc(96.09,80.68) 96.28,80.48 96.35,80.34 arc(96.41,80.1) 96.35,79.85 96.29,79.74 arc(96.26,79.61) 96.31,79.48 96.35,79.43 arc(96.43,79.21) 96.38,78.98 96.27,78.79 arc(96.23,78.66) 96.26,78.53 96.36,78.32 arc(96.42,78.07) 96.39,77.81 96.34,77.67 arc(96.33,77.54) 96.4,77.43 96.42,77.4 arc(96.44,77.38) 96.47,77.36 arc(96.51,77.34) 96.55,77.34 96.76,77.34 arc(97.03,77.27) 97.23,77.07 97.36,76.85 arc(97.4,76.72) 97.41,76.59 97.4,76.53 arc(97.43,76.31) v2(97.56,76.14)
QSFPDD0_TX3_P: length 57.9
  L03_SIG1 w0.079: v2(96.69,76.64) 96.99,76.46 arc(97.11,76.46) 97.17,76.55 97.18,76.62 arc(97.18,76.68) 97.16,76.73 97.03,76.95 arc(96.92,77.07) 96.76,77.11 96.55,77.11 arc(96.44,77.12) 96.35,77.17 arc(96.3,77.2) 96.26,77.24 96.24,77.26 arc(96.11,77.49) 96.12,77.74 96.17,77.88 arc(96.19,78.05) 96.15,78.22 96.05,78.44 arc(96.01,78.68) 96.07,78.91 96.18,79.1 arc(96.21,79.2) 96.17,79.29 96.13,79.34 arc(96.03,79.59) 96.09,79.84 96.15,79.96 arc(96.19,80.1) 96.15,80.23 96.08,80.38 arc(95.97,80.49) 95.82,80.53 95.79,80.53 arc(95.53,80.59) 95.34,80.77 95.08,81.17 arc(94.79,81.44) 94.42,81.53 93.99,81.53 arc(93.29,81.67) 92.7,82.07 91.76,83 91.58,83 91.4,83.18 91.4,83.36 90.88,83.88 arc(87.94,85.85) 84.46,86.54 84.02,86.54 83.93,86.45 83.69,86.45 83.59,86.54 83.35,86.54 83.26,86.45 83.02,86.45 82.93,86.54 82.48,86.54 arc(80.23,86.09) 78.32,84.82 77.54,84.04 arc(77.07,83.66) 76.54,83.39 arc(76.46,83.37) 76.38,83.36 69.3,83.36 arc(69.2,83.38) 69.1,83.42 arc(68.97,83.51) 68.85,83.62 arc(68.65,83.75) 68.42,83.8 66.63,83.8 arc(66,83.67) 65.46,83.31 65.41,83.26 arc(65.4,83.25) 65.4,83.24 arc(65.33,83.18) 65.27,83.13 arc(64.31,82.55) 63.2,82.35 58.29,82.35 arc(58.17,82.37) 58.07,82.44 57.93,82.58 arc(57.78,82.68) 57.61,82.71 53.16,82.71 arc(52.81,82.67) 52.49,82.54 arc(52.09,82.36) 51.66,82.3 50.86,82.3 arc(50.17,82.58) 49.89,83.27 49.89,84.04 arc(49.8,84.24) 49.6,84.33 49.42,84.33 arc(49.39,84.32) 49.35,84.3 v2(49.1,84.04)
QSFPDD0_TX4_N: length 48.7
  L16_SIG6 w0.079: v1(94.96,75.64) 94.71,75.49 arc(94.63,75.49) 94.58,75.53 94.54,75.59 arc(94.52,75.67) 94.53,75.76 94.61,75.93 arc(94.67,76.18) 94.62,76.43 94.6,76.48 arc(94.57,76.64) 94.61,76.79 94.62,76.81 arc(94.7,77.08) 94.66,77.36 94.6,77.5 arc(94.58,77.66) 94.62,77.81 arc(94.69,78.09) 94.65,78.37 94.6,78.49 arc(94.56,78.63) 94.55,78.78 94.55,78.92 arc(94.47,79.29) 94.27,79.59 94.24,79.62 arc(94.14,79.7) 94.03,79.75 arc(93.89,79.81) 93.78,79.92 93.68,80.05 arc(93.5,80.2) 93.27,80.26 93.16,80.26 arc(93.04,80.28) 92.95,80.36 92.83,80.51 arc(92.63,80.68) 92.37,80.75 92.34,80.75 arc(92.18,80.79) 92.06,80.9 91.99,81 arc(91.87,81.18) 91.73,81.33 87.44,85.62 arc(85.19,87.09) 82.53,87.52 arc(82.53,87.52) 82.52,87.52 arc(81.58,87.43) 80.64,87.26 arc(79.78,87.02) 78.93,86.71 arc(78.11,86.34) 77.34,85.89 arc(77.21,85.82) 77.09,85.74 arc(76.99,85.66) 76.9,85.58 arc(76.14,85.11) 75.27,84.94 66.43,84.94 arc(65.88,85.05) 65.41,85.36 64.28,86.49 arc(62.88,87.43) 61.22,87.76 59.65,87.76 arc(59.21,87.67) 58.84,87.42 arc(58.76,87.37) 58.66,87.35 55.32,87.35 arc(55.26,87.36) 55.2,87.4 v1(54.96,87.64)
QSFPDD0_TX4_P: length 48.7
  L16_SIG6 w0.079: v1(94.09,75.14) 94.33,75.28 arc(94.38,75.34) 94.37,75.43 94.34,75.47 arc(94.29,75.66) 94.33,75.85 94.41,76.03 arc(94.44,76.18) 94.41,76.34 94.39,76.39 arc(94.34,76.65) 94.41,76.9 94.42,76.92 arc(94.47,77.1) 94.45,77.28 94.39,77.42 arc(94.35,77.67) 94.42,77.91 94.42,77.91 arc(94.47,78.1) 94.43,78.29 94.39,78.41 arc(94.34,78.59) 94.32,78.78 94.32,78.92 arc(94.26,79.2) 94.11,79.43 94.08,79.46 arc(94.03,79.5) 93.97,79.53 arc(93.76,79.63) 93.6,79.78 93.5,79.91 arc(93.39,80) 93.27,80.03 93.16,80.03 arc(92.94,80.08) 92.77,80.22 92.65,80.37 arc(92.53,80.48) 92.37,80.52 92.34,80.52 arc(92.08,80.59) 91.87,80.77 91.8,80.88 arc(91.69,81.03) 91.57,81.17 91.34,81.4 91.14,81.4 90.96,81.58 90.96,81.78 90.78,81.96 90.57,81.96 90.4,82.13 90.4,82.34 87.28,85.46 arc(85.11,86.88) 82.54,87.29 arc(82.54,87.29) 82.53,87.29 arc(81.61,87.21) 80.7,87.04 arc(79.85,86.81) 79.02,86.5 arc(78.22,86.13) 77.46,85.7 arc(77.34,85.62) 77.22,85.55 arc(77.13,85.48) 77.05,85.41 arc(76.23,84.89) 75.27,84.71 66.43,84.71 arc(65.79,84.84) 65.25,85.2 64.12,86.33 arc(62.79,87.22) 61.22,87.53 59.65,87.53 arc(59.3,87.46) 59,87.26 arc(58.84,87.16) 58.66,87.12 55.3,87.12 arc(55.24,87.11) 55.19,87.07 v1(54.96,86.84)
QSFPDD0_TX5_N: length 60
  L16_SIG6 w0.079: v1(52.03,87.24) 52.31,86.96 52.55,86.96 arc(52.74,87.03) 52.81,87.22 52.81,88.18 arc(53.65,90.21) 55.68,91.05 59.07,91.05 arc(61.14,91.46) 62.9,92.64 arc(63.66,93.14) 64.55,93.32 66.8,93.32 arc(67.7,93.14) 68.46,92.64 arc(68.71,92.47) 69.01,92.41 72.19,92.41 arc(72.69,92.31) 73.1,92.03 74.33,90.81 arc(74.58,90.64) 74.88,90.58 77.28,90.58 arc(77.67,90.5) 77.99,90.28 arc(78.56,89.9) 79.23,89.77 85.74,89.77 arc(85.79,89.77) 85.85,89.76 arc(87.58,89.23) 89.04,88.17 95.13,82.09 arc(95.36,81.76) 95.45,81.37 arc(95.45,81.36) 95.45,81.36 arc(95.45,81.34) 95.45,81.32 95.45,81.04 arc(95.53,80.83) 95.75,80.74 95.87,80.74 arc(96.09,80.68) 96.25,80.53 96.33,80.38 arc(96.41,80.13) 96.37,79.88 96.31,79.72 arc(96.3,79.57) 96.37,79.44 97.02,78.75 arc(97.35,78.04) 97.2,77.27 97.19,77.25 arc(97.16,77.13) 97.18,77.02 97.24,76.88 arc(97.29,76.61) 97.23,76.34 97.23,76.32 arc(97.18,76.13) 97.22,75.93 97.28,75.81 arc(97.32,75.58) 97.24,75.36 97.22,75.32 arc(97.18,75.16) 97.24,75 97.3,74.93 arc(97.37,74.73) 97.33,74.51 97.26,74.4 arc(97.25,74.34) 97.29,74.29 v1(97.56,74.14)
QSFPDD0_TX5_P: length 60
  L16_SIG6 w0.079: v1(96.69,74.64) 96.96,74.49 arc(97.02,74.48) 97.06,74.51 97.13,74.63 arc(97.15,74.71) 97.12,74.79 97.06,74.86 arc(96.96,75.14) 97.02,75.44 97.05,75.48 97.05,75.48 arc(97.09,75.6) 97.07,75.71 97.01,75.84 arc(96.95,76.13) 97.02,76.41 97.03,76.43 arc(97.07,76.61) 97.03,76.79 96.97,76.93 arc(96.93,77.14) 96.99,77.36 97,77.38 arc(97.12,78.01) 96.85,78.59 96.2,79.28 arc(96.08,79.52) 96.1,79.8 96.16,79.96 arc(96.18,80.11) 96.14,80.26 96.05,80.41 arc(95.98,80.49) 95.87,80.51 95.75,80.51 arc(95.37,80.67) 95.22,81.04 95.22,81.32 arc(95.22,81.34) 95.22,81.36 arc(95.15,81.66) 94.97,81.92 94.55,82.34 94.35,82.34 94.22,82.47 94.22,82.68 94.08,82.81 93.88,82.81 93.75,82.94 93.75,83.15 93.61,83.28 93.41,83.28 93.28,83.41 93.28,83.62 93.14,83.75 92.94,83.75 92.81,83.88 92.81,84.09 88.88,88.01 arc(87.47,89.03) 85.82,89.54 arc(85.78,89.54) 85.74,89.54 79.23,89.54 arc(78.47,89.69) 77.83,90.12 arc(77.58,90.29) 77.28,90.35 74.88,90.35 arc(74.49,90.43) 74.17,90.65 72.94,91.87 arc(72.6,92.1) 72.19,92.18 69.01,92.18 arc(68.63,92.26) 68.3,92.47 arc(67.61,92.93) 66.8,93.09 64.55,93.09 arc(63.74,92.93) 63.06,92.47 arc(61.23,91.25) 59.07,90.82 55.68,90.82 arc(53.81,90.05) 53.04,88.18 53.04,87.22 arc(52.9,86.87) 52.55,86.73 52.31,86.73 v1(52.03,86.44)
QSFPDD0_TX6_N: length 50.3
  L16_SIG6 w0.079: v1(94.96,73.64) 94.76,73.52 arc(94.64,73.51) 94.54,73.58 94.53,73.6 arc(94.38,73.75) 94.18,73.81 93.95,73.81 arc(93.86,73.83) 93.8,73.89 93.75,73.97 arc(93.7,74.11) 93.73,74.27 93.75,74.31 arc(93.81,74.6) 93.73,74.88 93.68,74.98 arc(93.64,75.13) 93.67,75.27 93.77,75.47 arc(93.83,75.72) 93.76,75.96 93.74,75.99 arc(93.71,76.15) 93.75,76.31 93.78,76.35 arc(93.85,76.5) 93.87,76.66 93.87,77.65 arc(93.85,77.76) 93.81,77.87 93.75,77.95 arc(93.7,78.1) 93.73,78.26 93.83,78.45 arc(93.87,78.74) 93.76,79.02 93.74,79.05 arc(93.55,79.2) 93.31,79.26 93.07,79.26 arc(92.98,79.29) 92.92,79.36 92.92,79.37 arc(92.71,79.64) 92.38,79.75 92.32,79.75 arc(92.14,79.8) 92.01,79.94 92.01,79.95 arc(91.81,80.17) 91.52,80.26 91.48,80.26 arc(91.29,80.31) 91.15,80.44 91.14,80.46 arc(90.92,80.68) 90.62,80.76 90.6,80.76 arc(90.46,80.79) 90.35,80.88 90.3,80.94 arc(90.12,81.15) 89.94,81.36 arc(89.88,81.42) 89.82,81.48 86.35,84.95 arc(84.39,86.27) 82.08,86.74 arc(82.02,86.74) 81.97,86.74 arc(79.82,86.19) 77.91,85.06 arc(77.87,85.02) 77.83,84.99 77.58,84.73 arc(77.54,84.7) 77.51,84.66 77.2,84.36 arc(76.78,83.98) 76.31,83.67 arc(76.28,83.65) 76.24,83.64 69.57,83.64 arc(69.2,83.72) 68.89,83.93 arc(68.77,84.01) 68.63,84.03 66.92,84.03 arc(66.35,83.92) 65.87,83.6 65.77,83.49 arc(65.48,83.3) 65.14,83.23 61.48,83.23 arc(60.3,83.47) 59.3,84.13 58.92,84.51 arc(58.43,84.84) 57.85,84.96 55.31,84.96 arc(55.25,84.97) 55.2,85 v1(54.96,85.24)
QSFPDD0_TX6_P: length 50.3
  L16_SIG6 w0.079: v1(54.96,84.44) 55.2,84.68 arc(55.25,84.72) 55.31,84.73 57.85,84.73 arc(58.34,84.63) 58.76,84.35 59.14,83.97 arc(60.22,83.25) 61.48,83 65.14,83 arc(65.56,83.09) 65.93,83.33 66.04,83.44 arc(66.44,83.71) 66.92,83.81 68.63,83.81 arc(68.68,83.79) 68.73,83.76 arc(69.11,83.51) 69.57,83.42 76.24,83.42 arc(76.34,83.43) 76.43,83.47 arc(76.92,83.8) 77.36,84.19 77.67,84.5 arc(77.7,84.53) 77.74,84.57 78,84.83 arc(78.02,84.85) 78.05,84.88 arc(79.91,85.98) 82,86.51 arc(82.03,86.51) 82.07,86.51 arc(84.3,86.06) 86.19,84.79 88.58,82.39 88.58,82.2 88.73,82.06 88.91,82.06 89.06,81.92 89.06,81.73 89.2,81.59 89.38,81.59 89.66,81.32 arc(89.72,81.26) 89.77,81.2 arc(89.95,81) 90.12,80.8 90.18,80.73 arc(90.37,80.59) 90.6,80.53 90.62,80.53 arc(90.81,80.48) 90.95,80.34 90.95,80.33 arc(91.18,80.11) 91.48,80.03 91.52,80.03 arc(91.69,79.98) 91.8,79.85 91.81,79.84 arc(92.02,79.6) 92.32,79.52 92.38,79.52 arc(92.58,79.46) 92.7,79.29 92.71,79.28 arc(92.85,79.1) 93.07,79.03 93.31,79.03 arc(93.45,79) 93.56,78.91 93.58,78.87 arc(93.65,78.72) 93.62,78.55 93.53,78.36 arc(93.47,78.09) 93.56,77.83 93.61,77.74 arc(93.63,77.7) 93.64,77.65 93.64,76.66 arc(93.63,76.56) 93.59,76.47 93.56,76.43 arc(93.48,76.16) 93.54,75.88 93.56,75.85 arc(93.6,75.72) 93.57,75.58 93.46,75.38 arc(93.41,75.12) 93.48,74.87 93.54,74.76 arc(93.59,74.59) 93.55,74.41 93.53,74.37 arc(93.47,74.1) 93.56,73.84 93.61,73.76 arc(93.75,73.63) 93.95,73.58 94.18,73.58 arc(94.27,73.56) 94.33,73.49 94.39,73.4 arc(94.39,73.34) 94.36,73.29 v1(94.09,73.14)
QSFPDD0_TX7_N: length 61.7
  L16_SIG6 w0.079: v1(52.03,84.84) 52.27,84.6 arc(52.32,84.57) 52.38,84.56 52.89,84.56 arc(53.6,84.85) 53.9,85.56 53.9,88.03 arc(54.2,88.77) 54.93,89.07 61.79,89.07 arc(62.89,88.85) 63.82,88.23 65.93,86.12 arc(66.31,85.87) 66.76,85.78 67.57,85.78 arc(67.97,85.86) 68.31,86.08 arc(68.48,86.2) 68.68,86.24 75.19,86.24 arc(76.08,86.41) 76.84,86.92 77.14,87.22 arc(78.58,88.18) 80.27,88.52 arc(80.63,88.54) 80.98,88.55 83.11,88.55 arc(86.58,87.86) 89.51,85.9 arc(89.52,85.89) 89.53,85.88 93,82.41 arc(93.29,82.02) 93.45,81.56 arc(93.47,81.46) 93.5,81.36 arc(93.58,81.19) 93.69,81.03 93.82,80.87 arc(93.92,80.8) 94.04,80.77 94.04,80.77 arc(94.37,80.68) 94.61,80.44 95.33,79.24 95.48,78.94 arc(95.6,78.8) 95.78,78.75 95.85,78.75 arc(96.17,78.64) 96.38,78.37 96.4,78.32 arc(96.43,78.06) 96.35,77.81 96.35,77.81 arc(96.31,77.66) 96.33,77.5 96.38,77.37 arc(96.43,77.09) 96.35,76.81 arc(96.31,76.66) 96.34,76.5 96.4,76.33 arc(96.44,76.1) 96.38,75.87 96.31,75.73 arc(96.29,75.65) 96.31,75.56 96.38,75.41 arc(96.42,75.16) 96.35,74.93 96.23,74.73 arc(96.21,74.64) 96.23,74.55 96.36,74.33 arc(96.42,74.14) 96.39,73.94 96.39,73.93 arc(96.36,73.85) 96.35,73.76 96.35,73.57 arc(96.43,73.38) 96.62,73.31 96.79,73.31 arc(96.98,73.26) 97.13,73.14 97.26,72.99 arc(97.36,72.73) 97.3,72.46 97.27,72.41 arc(97.26,72.34) 97.3,72.28 v1(97.56,72.14)
QSFPDD0_TX7_P: length 61.7
  L16_SIG6 w0.079: v1(96.69,72.64) 96.95,72.49 arc(97.01,72.48) 97.07,72.52 97.1,72.57 arc(97.13,72.71) 97.08,72.84 96.96,73 arc(96.88,73.06) 96.79,73.08 96.62,73.08 arc(96.27,73.22) 96.13,73.57 96.13,73.76 arc(96.14,73.89) 96.17,74.01 96.18,74.03 arc(96.19,74.12) 96.17,74.21 96.03,74.44 arc(95.98,74.64) 96.03,74.84 96.15,75.04 arc(96.19,75.18) 96.17,75.32 96.1,75.47 arc(96.06,75.65) 96.11,75.83 96.18,75.97 arc(96.21,76.11) 96.19,76.25 96.12,76.42 arc(96.08,76.67) 96.15,76.91 96.15,76.91 arc(96.2,77.1) 96.17,77.29 96.12,77.42 arc(96.08,77.68) 96.15,77.92 96.16,77.93 arc(96.2,78.08) 96.18,78.24 96.17,78.29 arc(96.04,78.46) 95.85,78.52 95.78,78.52 arc(95.48,78.6) 95.27,78.84 95.13,79.14 94.42,80.33 arc(94.26,80.48) 94.04,80.54 94.04,80.54 arc(93.82,80.59) 93.64,80.73 93.51,80.89 arc(93.39,81.08) 93.29,81.28 arc(93.25,81.39) 93.22,81.51 arc(93.09,81.91) 92.84,82.25 92.56,82.53 92.35,82.53 92.22,82.66 92.22,82.87 92.09,83 91.88,83 91.75,83.13 91.75,83.34 91.62,83.47 91.41,83.47 91.28,83.6 91.28,83.81 91.14,83.94 90.94,83.94 90.81,84.07 90.81,84.28 89.36,85.72 arc(89.36,85.73) 89.35,85.73 arc(86.49,87.65) 83.11,88.32 80.98,88.32 arc(80.63,88.31) 80.28,88.29 arc(78.67,87.97) 77.3,87.06 77,86.76 arc(76.17,86.2) 75.19,86.01 68.68,86.01 arc(68.56,85.98) 68.47,85.92 arc(68.06,85.65) 67.57,85.55 66.76,85.55 arc(66.22,85.66) 65.77,85.96 63.66,88.07 arc(62.8,88.64) 61.79,88.84 54.93,88.84 arc(54.36,88.6) 54.13,88.03 54.13,85.56 arc(53.76,84.69) 52.89,84.33 52.38,84.33 arc(52.32,84.32) 52.27,84.28 v1(52.03,84.04)
QSFPDD0_VCC:
  vias: v1(54.11,82.04) v1(54.96,82.04) v1(56.69,82.04) v1(57.54,82.04)
QSFPDD0_VCCR:
  vias: v1(48.46,80.85) v1(49.09,80.85) v1(50.83,80.84) v1(51.68,80.84)
QSFPDD0_VCCT:
  vias: v1(54.11,81.24) v1(54.96,81.24) v1(56.69,81.24) v1(57.54,81.24)
QSFPDD1_3V3_INT_L: length 53.9
  L03_SIG1 w0.081: v2(56.57,55.65) 50.12,55.65 48.96,54.5 48.14,54.5 46.92,53.27 46.92,52.66 v1(46.37,52.12)
  L16_SIG6 w0.081: v1(28.54,82.87) 29.06,82.34 29.06,81.43 28.87,81.24 28.87,79.04 30.92,76.99 33.38,76.99 33.39,77 34.52,77 43.66,67.86 43.66,53.53 44.51,52.68 45.82,52.68 v1(46.37,52.12)
  BOTTOM w0.149: U14.55 28.51,82.9 28.54,82.88 v1(28.54,82.87)
QSFPDD1_3V3_LPMODE: length 55.3
  TOP w0.149: J4.31 58.19,58.05 v1(58.4,57.84)
  L12_SIG4 w0.089: v1(26.61,80.98) 25.24,80.98 24.44,80.18 24.44,78.56 24.93,78.07 27,78.07 27.29,77.78 27.67,77.78 27.9,77.54 27.9,77.16 31.45,73.61 31.45,63.21 34.55,60.12 34.56,60.12 34.8,59.88 34.8,59.87 37.31,57.35 52.63,57.35 53.11,57.84 v1(58.4,57.84)
  BOTTOM w0.149: U14.2 v1(26.61,80.98)
QSFPDD1_3V3_MODPRS_L: length 59.7
  L03_SIG1 w0.081: v2(56.67,54.85) 49.72,54.85 48.93,54.06 48.04,54.06 47.16,53.18 47.16,51.89 v1(46.37,51.11)
  L12_SIG4 w0.089: v1(46.37,51.11) 45.76,51.73 45.32,51.73 45.09,51.96 45.09,52.39 41.78,55.7 37.57,55.7 31.1,62.17 31.1,73.45 27.8,76.75 25.23,76.75 24.16,77.83 24.16,80.52 25.23,81.6 v1(27.52,81.6)
  BOTTOM w0.149: v1(27.52,81.6) 27.46,81.66 U14.1
QSFPDD1_3V3_RESET_L: length 39.4
  L03_SIG1 w0.081: v1(47.38,68.79) 47.12,68.52 47.12,57.62 v2(47.89,56.85)
  L12_SIG4 w0.089: v1(28.46,81.59) 28.46,79.47 31.77,76.16 36.48,76.16 43.08,69.56 46.71,69.56 47.38,68.89 v1(47.38,68.79)
  BOTTOM w0.149: v1(28.46,81.59) 28.49,81.59 v1(28.46,81.59) ; v1(28.46,81.59) 28.65,81.78 28.65,81.99 28.24,82.4 U14.56
QSFPDD1_FPGA_LED0: length 236.9
  TOP w0.149: U32.2 16.17,100.95 v1(16.52,101.3)
  L03_SIG1 w0.081: v1(15.72,15.87) 15.56,15.71 10.09,15.71 9.37,16.43 9.37,21.71 8.02,23.06 8.02,24.14 7.78,24.38 7.78,24.69 6.57,25.9 6.57,25.96 6.57,25.96 6.57,31.62 6.24,31.95 6.24,34.58 3.4,37.42 3.4,54.6 16.02,67.22 16.02,70.23 10.11,76.14 10.11,95.2 16.2,101.3 v1(16.52,101.3)
  L07_SIG3 w0.089: v1(121.1,37.77) 121.1,37.34 120.41,36.65 120.41,34.26 120.65,34.02 120.65,33.12 120.65,33.09 120.65,32.06 120.32,31.73 120.32,30.48 119.58,29.74 119.58,21.96 118.96,21.34 118.96,16.91 119.09,16.77 119.09,16.46 118.96,16.33 118.96,15.46 116.85,13.36 66.09,13.36 65.35,14.09 v1(62.41,14.09)
  L12_SIG4 w0.089: v1(62.41,14.09) 61.89,13.58 60.21,13.58 60.19,13.6 57.86,13.6 57.13,12.87 54.84,12.87 54.73,12.76 54.71,12.76 53.69,11.74 53.02,11.74 52.85,11.91 47.52,11.91 45.99,13.44 44.8,13.44 44.35,13.89 43.56,13.89 43.47,13.91 42.88,13.91 42.79,13.89 41.78,13.89 41.4,13.51 34.68,13.51 34.21,13.97 20.75,13.97 18.85,15.88 15.73,15.88 v1(15.72,15.87)
QSFPDD1_FPGA_LED1: length 240
  TOP w0.149: U32.3 v1(15.52,101.28)
  L03_SIG1 w0.081: v1(15.52,101.28) 9.85,95.61 9.85,76.07 15.78,70.14 15.78,67.37 3.17,54.75 3.17,45.9 1.42,44.16 1.42,35.37 3.1,33.7 3.1,30.22 6.33,26.99 6.33,25.86 6.33,25.86 6.33,25.81 7.55,24.59 7.55,24.28 7.77,24.05 7.77,22.86 9.14,21.5 9.14,16.33 10.22,15.25 v1(15.23,15.25)
  L07_SIG3 w0.089: v1(120.3,38.23) 120.3,37.25 119.93,36.87 119.93,34.06 120.17,33.82 120.17,33.11 120.17,33.09 120.17,32.26 119.84,31.93 119.84,30.79 118.42,29.38 118.42,19.03 118.13,18.75 118.13,15.39 116.62,13.88 68.71,13.88 68.18,14.42 65.88,14.42 64.64,15.66 64.06,15.66 63.08,16.63 62.56,16.63 v1(62.42,16.77)
  L12_SIG4 w0.089: v1(62.42,16.77) 59.86,14.21 57.34,14.21 56.87,13.74 54.22,13.74 52.66,12.18 47.59,12.18 46.09,13.68 44.9,13.68 44.45,14.13 43.58,14.13 43.49,14.15 42.86,14.15 42.77,14.13 41.68,14.13 41.3,13.75 34.78,13.75 34.31,14.21 20.97,14.21 18.94,16.24 15.57,16.24 15.23,15.9 v1(15.23,15.25)
QSFPDD1_FPGA_LED2: length 243.3
  TOP w0.149: v1(14.49,101.3) 14.87,100.92 U32.4
  L03_SIG1 w0.081: v1(14.49,101.3) 9.61,96.43 9.61,75.97 15.55,70.04 15.55,67.49 2.93,54.87 2.93,45.99 1.19,44.25 1.19,35.28 2.86,33.6 2.86,30.12 5.42,27.56 5.42,26.35 6.92,24.86 7.15,24.3 7.15,24.3 6.92,24.06 6.92,23.72 7.54,23.1 7.54,22.76 8.9,21.4 8.9,16.23 10.27,14.87 15.54,14.87 v1(15.89,15.22)
  L07_SIG3 w0.089: v1(121.1,39.61) 121.1,39.27 120.71,38.87 120.71,37.29 120.17,36.76 120.17,34.16 120.41,33.92 120.41,33.12 120.41,33.09 120.41,32.16 120.08,31.83 120.08,30.62 118.63,29.17 118.63,18.95 118.55,18.86 118.55,18.78 118.34,18.58 118.34,15.26 116.68,13.6 66.31,13.6 64.59,15.32 63.7,15.32 v1(62.84,16.18)
  L12_SIG4 w0.089: v1(62.84,16.18) 62.84,14 62.18,13.33 59.67,13.33 59.65,13.35 57.96,13.35 56.77,12.16 56.77,12.16 56.6,11.99 54.29,11.99 53.29,11 48.97,11 48.86,11.11 47.9,11.11 45.82,13.19 44.72,13.19 44.67,13.22 44.25,13.65 43.53,13.65 43.45,13.67 42.9,13.67 42.82,13.65 41.88,13.65 41.5,13.27 34.58,13.27 34.18,13.67 17.43,13.67 v1(15.89,15.22)
QSFPDD1_I2C_SCL: length 43.8
  L03_SIG1 w0.081: v2(48.5,55.25) 48.5,57.56 47.46,58.6 47.46,67.85 v1(48.39,68.79)
  L12_SIG4 w0.089: v1(25.88,79.9) 27.76,78.02 27.77,78.02 28.14,77.64 28.14,77.63 30.2,75.58 35.61,75.58 42.94,68.25 47.86,68.25 v1(48.39,68.79)
  BOTTOM w0.149: U14.4 25.61,80.17 v1(25.88,79.9)
QSFPDD1_I2C_SDA: length 44
  TOP w0.149: v2(47.33,54.96) 47.33,54.95 47.83,54.45 J4.12
  L03_SIG1 w0.081: v1(46.36,68.79) 46.79,68.36 46.79,56.29 47.33,55.75 v2(47.33,54.96)
  L12_SIG4 w0.089: v1(24.88,79.9) 25.31,80.33 26.86,80.33 29.41,77.78 29.57,77.78 29.8,77.54 29.8,77.39 31.3,75.89 35.89,75.89 42.99,68.79 v1(46.36,68.79)
  BOTTOM w0.149: v1(24.88,79.9) 25.11,80.13 U14.5
QSFPDD1_LED0: length 31.9
  TOP w0.149: v1(16.52,92.92) 16.17,93.27 U32.13
  L07_SIG3 w0.089: v1(16.52,92.92) 17.03,93.42 20.71,93.42 20.99,93.7 23.35,93.7 23.88,93.17 23.88,91.26 24.26,90.88 24.26,87.07 25.41,85.93 25.41,78.56 27.82,76.15 28.46,76.15 29.09,75.52 29.09,73.93 v1(28.52,73.36)
QSFPDD1_LED1: length 33.5
  TOP w0.149: U32.12 v1(15.52,92.93)
  L07_SIG3 w0.089: v1(15.52,92.93) 15.52,94.48 15.86,94.82 26.5,94.82 28.06,93.26 28.06,80.38 31.06,77.38 v1(31.31,77.38)
QSFPDD1_LED2: length 32.4
  TOP w0.149: v1(14.49,92.92) 14.87,93.3 U32.11
  L07_SIG3 w0.089: v1(27.5,77.38) 27.06,77.83 27.06,93.35 25.97,94.44 16.47,94.44 16.03,94.01 16.03,92.64 15.81,92.41 14.99,92.41 v1(14.49,92.92)
QSFPDD1_RX0_N: length 63.7
  L16_SIG6 w0.079: v1(92.36,72.14) 92.15,72.26 arc(92.08,72.35) 92.1,72.46 92.13,72.51 arc(92.18,72.73) 92.1,72.94 91.94,73.12 arc(91.77,73.26) 91.56,73.31 91.37,73.31 arc(91.14,73.25) 90.98,73.08 90.87,72.9 arc(90.79,72.82) 90.69,72.79 90.63,72.79 arc(90.43,72.75) 90.27,72.64 90,72.38 arc(89.91,72.32) 89.81,72.29 89.71,72.29 arc(89.59,72.32) 89.48,72.39 89.35,72.52 arc(89.16,72.65) 88.94,72.7 88.79,72.7 arc(88.57,72.65) 88.38,72.52 88.24,72.38 arc(88.09,72.28) 87.91,72.24 78.55,72.24 arc(78.36,72.28) 78.2,72.39 arc(77.98,72.53) 77.73,72.58 75.22,72.58 arc(74.66,72.35) 74.43,71.79 74.43,71.61 arc(74.36,71.44) 74.19,71.37 62.35,71.37 arc(62.3,71.37) 62.25,71.37 arc(55.84,69.71) 50.4,65.92 50.28,65.8 arc(50.26,65.79) 50.24,65.78 arc(50.13,65.68) 50.02,65.57 48.69,64.24 arc(48.25,63.58) 48.09,62.79 48.09,57.25 arc(48.1,57.14) 48.13,57.04 48.28,56.69 arc(48.3,56.63) 48.3,56.57 48.3,55.95 arc(48.3,55.87) 48.27,55.8 48.13,55.46 arc(48.1,55.36) 48.09,55.25 48.09,50.38 arc(48.22,50.07) 48.54,49.94 48.75,49.94 arc(48.81,49.93) 48.86,49.89 v1(49.1,49.65)
QSFPDD1_RX0_P: length 63.7
  L16_SIG6 w0.079: v1(49.1,50.45) 48.86,50.21 arc(48.81,50.18) 48.75,50.17 48.54,50.17 arc(48.38,50.23) 48.32,50.38 48.32,50.77 48.47,50.92 48.47,51.17 48.32,51.32 48.32,51.57 48.47,51.72 48.47,51.98 48.32,52.13 48.32,52.38 48.44,52.5 48.44,52.81 48.32,52.93 48.32,55.25 arc(48.33,55.31) 48.35,55.37 48.48,55.71 arc(48.52,55.83) 48.53,55.95 48.53,56.57 arc(48.52,56.67) 48.49,56.77 48.35,57.12 arc(48.33,57.18) 48.32,57.25 48.32,60.64 48.45,60.76 48.45,61.01 48.32,61.14 48.32,62.79 arc(48.46,63.49) 48.85,64.08 49.12,64.35 49.33,64.35 49.51,64.53 49.51,64.74 50.18,65.41 arc(50.37,65.59) 50.56,65.76 arc(55.93,69.5) 62.27,71.14 arc(62.31,71.14) 62.35,71.14 74.19,71.14 arc(74.52,71.28) 74.66,71.61 74.66,71.79 arc(74.82,72.19) 75.22,72.35 77.73,72.35 arc(77.89,72.32) 78.03,72.23 arc(78.27,72.07) 78.55,72.01 81.68,72.01 81.78,71.91 82.01,71.91 82.12,72.01 82.34,72.01 82.45,71.91 82.68,71.91 82.78,72.01 83.96,72.01 84.1,71.88 84.3,71.88 84.43,72.01 84.63,72.01 84.77,71.88 84.96,71.88 85.1,72.01 85.29,72.01 85.43,71.88 85.63,71.88 85.76,72.01 85.96,72.01 86.1,71.88 86.29,71.88 86.43,72.01 87.91,72.01 arc(88.18,72.07) 88.4,72.22 88.54,72.36 arc(88.66,72.44) 88.79,72.47 88.93,72.47 arc(89.07,72.44) 89.19,72.36 89.32,72.23 arc(89.5,72.11) 89.71,72.07 89.81,72.07 arc(90,72.1) 90.17,72.22 90.43,72.48 arc(90.52,72.54) 90.63,72.56 90.69,72.56 arc(90.91,72.62) 91.07,72.78 91.17,72.96 arc(91.26,73.05) 91.37,73.08 91.56,73.08 arc(91.68,73.05) 91.77,72.98 91.92,72.79 arc(91.95,72.71) 91.93,72.63 91.9,72.57 arc(91.81,72.5) 91.7,72.52 v1(91.49,72.64)
QSFPDD1_RX1_N: length 51.5
  L03_SIG1 w0.079: v2(89.77,71.64) 89.51,71.49 arc(89.46,71.42) 89.49,71.34 89.49,71.34 89.6,71.22 arc(89.63,71.2) 89.67,71.19 89.94,71.19 arc(90.05,71.18) 90.14,71.13 arc(90.18,71.1) 90.22,71.06 90.39,70.87 arc(90.5,70.78) 90.63,70.76 90.68,70.76 arc(90.91,70.69) 91.07,70.51 91.17,70.29 arc(91.22,70.1) 91.18,69.91 91.16,69.84 arc(91.16,69.84) 91.16,69.84 91.12,69.76 arc(91.1,69.67) 91.11,69.58 91.2,69.34 arc(91.22,69.13) 91.16,68.94 91.05,68.74 arc(90.89,68.58) 90.67,68.53 90.62,68.53 arc(90.48,68.49) 90.36,68.4 90.24,68.26 arc(90.07,68.13) 89.87,68.08 89.62,68.08 arc(89.44,68.12) 89.3,68.23 89.17,68.39 arc(89.09,68.45) 89,68.47 88.77,68.47 arc(88.66,68.45) 88.57,68.39 88.37,68.19 arc(88.19,68.07) 87.98,68.03 86.52,68.03 arc(86.27,68.06) 86.04,68.17 arc(85.92,68.23) 85.78,68.25 81.52,68.25 arc(80.6,67.87) 80.22,66.96 80.22,65.83 arc(80.1,65.22) 79.75,64.7 79.48,64.43 arc(78.92,64.05) 78.25,63.92 64.84,63.92 arc(64.51,63.89) 64.18,63.83 63.84,63.75 arc(62.89,63.41) 62.08,62.8 arc(61.55,62) 61.36,61.05 61.36,54.28 arc(61.13,53.14) 60.48,52.16 58.89,50.58 arc(58.63,50.4) 58.32,50.34 58.21,50.34 arc(58.18,50.33) 58.14,50.31 v2(57.89,50.05)
QSFPDD1_RX1_P: length 51.5
  L03_SIG1 w0.079: v2(57.89,50.85) 58.14,50.6 arc(58.18,50.57) 58.21,50.57 58.32,50.57 arc(58.54,50.61) 58.73,50.74 60.32,52.32 arc(60.92,53.22) 61.13,54.28 61.13,61.05 arc(61.34,62.09) 61.92,62.96 arc(62.78,63.61) 63.79,63.98 64.13,64.05 arc(64.48,64.11) 64.83,64.15 78.25,64.15 arc(78.83,64.26) 79.32,64.59 79.59,64.86 arc(79.89,65.31) 79.99,65.83 79.99,66.96 arc(80.44,68.03) 81.52,68.48 82.13,68.48 82.29,68.64 82.47,68.64 82.63,68.48 83.29,68.48 83.46,68.65 83.64,68.65 83.8,68.48 84.06,68.48 84.22,68.64 84.4,68.64 84.56,68.48 85.78,68.48 arc(85.99,68.45) 86.17,68.36 arc(86.34,68.28) 86.52,68.25 87.03,68.25 87.16,68.38 87.45,68.38 87.57,68.25 87.98,68.25 arc(88.1,68.28) 88.21,68.35 88.41,68.55 arc(88.57,68.66) 88.77,68.7 89,68.7 arc(89.19,68.66) 89.35,68.53 89.48,68.38 arc(89.54,68.33) 89.62,68.31 89.87,68.31 arc(89.98,68.33) 90.06,68.4 90.18,68.55 arc(90.38,68.7) 90.62,68.76 90.67,68.76 arc(90.77,68.78) 90.85,68.86 90.96,69.05 arc(90.99,69.15) 90.98,69.26 90.9,69.51 arc(90.87,69.68) 90.91,69.86 90.95,69.93 90.97,70 arc(90.99,70.1) 90.97,70.2 90.86,70.41 arc(90.79,70.5) 90.68,70.53 90.63,70.53 arc(90.41,70.58) 90.22,70.72 90.05,70.91 arc(90.03,70.93) 90.02,70.94 arc(89.98,70.96) 89.94,70.97 89.67,70.97 arc(89.55,70.99) 89.44,71.06 89.25,71.26 arc(89.19,71.28) 89.12,71.27 v2(88.9,71.14)
QSFPDD1_RX2_N: length 69.1
  L03_SIG1 w0.079: v2(49.1,52.05) 49.38,52.34 49.52,52.34 arc(49.76,52.24) 49.86,51.99 49.86,48.95 arc(49.97,48.45) 50.25,48.02 50.45,47.82 arc(51.65,47.02) 53.06,46.74 56.17,46.74 arc(59.07,47.31) 61.53,48.96 62.22,49.65 arc(63.33,51.3) 63.71,53.25 63.71,60.77 arc(63.74,60.91) 63.82,61.03 64.29,61.5 arc(64.43,61.59) 64.61,61.63 76.88,61.63 arc(77.42,61.52) 77.88,61.21 78.28,60.82 arc(78.65,60.57) 79.08,60.49 83.18,60.49 arc(83.29,60.46) 83.38,60.4 arc(83.61,60.25) 83.87,60.2 84.39,60.2 arc(85.13,60.34) 85.75,60.76 86.33,61.34 arc(86.52,61.47) 86.75,61.51 88.92,61.51 arc(89.19,61.58) 89.39,61.76 89.46,61.87 arc(89.59,61.98) 89.75,62.02 89.77,62.02 arc(90.04,62.08) 90.25,62.27 90.32,62.37 arc(90.44,62.48) 90.6,62.52 90.68,62.52 arc(90.94,62.6) 91.13,62.8 91.17,62.87 arc(91.29,62.99) 91.45,63.03 91.59,63.03 arc(91.83,63.1) 92,63.3 92.05,63.39 arc(92.1,63.45) 92.18,63.47 92.43,63.47 arc(92.69,63.54) 92.89,63.73 92.97,63.86 arc(93.05,64.1) 93,64.34 92.9,64.56 arc(92.86,64.72) 92.9,64.88 92.94,64.95 arc(93,65.2) 92.9,65.44 arc(92.85,65.54) 92.87,65.65 93,65.96 arc(93.04,66.23) 92.93,66.48 92.88,66.55 arc(92.84,66.64) 92.85,66.74 92.95,66.98 arc(92.98,67.23) 92.88,67.46 92.86,67.48 arc(92.83,67.55) 92.85,67.63 92.99,67.9 arc(93.05,68.15) 92.98,68.4 92.87,68.59 arc(92.85,68.66) 92.86,68.73 92.96,69 arc(92.98,69.25) 92.87,69.47 92.84,69.51 arc(92.72,69.61) 92.57,69.68 arc(92.52,69.69) 92.47,69.7 arc(92.43,69.7) 92.39,69.71 92.26,69.71 arc(92.22,69.71) 92.18,69.72 arc(92.09,69.77) 92.02,69.86 92,69.88 arc(91.97,69.96) 91.98,70.05 92,70.14 arc(92.08,70.23) 92.21,70.23 92.34,70.15 v2(92.36,70.15)
QSFPDD1_RX2_P: length 69.2
  L03_SIG1 w0.079: v2(49.1,52.85) 49.38,52.57 49.52,52.57 arc(49.93,52.4) 50.09,51.99 50.09,48.95 arc(50.18,48.53) 50.41,48.18 50.61,47.98 arc(51.74,47.23) 53.06,46.96 56.17,46.96 arc(58.98,47.52) 61.37,49.12 62.06,49.81 arc(63.11,51.39) 63.48,53.25 63.48,60.77 arc(63.53,61) 63.66,61.19 64.13,61.66 arc(64.35,61.81) 64.61,61.86 76.88,61.86 arc(77.51,61.73) 78.04,61.38 78.44,60.98 arc(78.73,60.78) 79.08,60.71 83.18,60.71 arc(83.38,60.67) 83.54,60.56 arc(83.69,60.46) 83.87,60.43 84.39,60.43 arc(85.04,60.56) 85.59,60.92 86.17,61.5 arc(86.44,61.68) 86.75,61.74 87.13,61.74 87.26,61.88 87.52,61.88 87.65,61.74 87.91,61.74 88.04,61.87 88.3,61.87 88.43,61.74 88.92,61.74 arc(89.08,61.78) 89.2,61.89 89.28,62 arc(89.48,62.18) 89.75,62.25 89.77,62.25 arc(89.93,62.29) 90.06,62.4 90.13,62.5 arc(90.33,62.69) 90.6,62.75 90.68,62.75 arc(90.83,62.79) 90.93,62.91 90.97,62.97 arc(91.17,63.18) 91.45,63.26 91.59,63.26 arc(91.71,63.29) 91.8,63.39 91.84,63.48 arc(91.98,63.64) 92.18,63.7 92.43,63.7 arc(92.58,63.74) 92.69,63.85 92.78,63.98 arc(92.82,64.11) 92.79,64.25 92.69,64.46 arc(92.63,64.72) 92.7,64.99 92.74,65.06 arc(92.77,65.18) 92.72,65.29 arc(92.63,65.51) 92.66,65.74 92.79,66.05 arc(92.81,66.2) 92.75,66.34 92.7,66.4 arc(92.61,66.61) 92.64,66.83 92.74,67.07 arc(92.76,67.19) 92.7,67.31 92.68,67.34 arc(92.6,67.53) 92.64,67.73 92.79,68.01 arc(92.82,68.15) 92.78,68.29 92.67,68.48 arc(92.62,68.64) 92.64,68.81 92.74,69.08 arc(92.75,69.21) 92.7,69.32 92.67,69.36 arc(92.59,69.42) 92.51,69.46 arc(92.47,69.47) 92.43,69.47 arc(92.41,69.48) 92.39,69.48 92.26,69.48 arc(92.18,69.48) 92.1,69.51 arc(91.94,69.6) 91.82,69.74 91.81,69.76 arc(91.75,69.93) 91.76,70.1 arc(91.74,70.39) 91.55,70.6 91.51,70.62 v2(91.5,70.65)
QSFPDD1_RX3_N: length 50
  L03_SIG1 w0.079: v2(89.76,69.64) 89.51,69.5 arc(89.47,69.44) 89.48,69.36 89.49,69.34 arc(89.51,69.3) 89.54,69.27 89.6,69.22 arc(89.65,69.2) 89.7,69.19 89.74,69.19 arc(89.74,69.19) 89.75,69.19 89.81,69.2 89.82,69.2 89.9,69.21 arc(89.91,69.21) 89.92,69.22 arc(89.97,69.24) 90.02,69.26 arc(90.12,69.33) 90.19,69.42 90.19,69.42 arc(90.23,69.51) 90.24,69.61 arc(90.24,69.61) 90.24,69.61 arc(90.24,69.63) 90.24,69.66 90.24,69.74 arc(90.19,69.92) 90.04,70.04 90.04,70.04 arc(90.03,70.05) 90.03,70.05 89.94,70.07 arc(89.87,70.08) 89.8,70.09 89.66,70.09 arc(89.47,70.13) 89.3,70.24 89.13,70.41 arc(89.06,70.45) 88.98,70.47 88.84,70.47 arc(88.75,70.45) 88.68,70.4 88.44,70.16 arc(88.27,70.05) 88.08,70.01 87.96,70.01 arc(87.85,69.99) 87.76,69.93 87.53,69.71 arc(87.34,69.58) 87.12,69.53 86.87,69.53 86.74,69.4 86.54,69.4 86.41,69.53 86.21,69.53 86.07,69.4 85.87,69.4 85.74,69.53 85.54,69.53 85.41,69.4 85.21,69.4 85.07,69.53 84.48,69.53 84.33,69.38 84.09,69.38 83.93,69.53 83.68,69.53 83.53,69.39 83.28,69.39 83.13,69.53 82.53,69.53 82.37,69.37 82.14,69.37 81.98,69.53 81.72,69.53 81.56,69.38 81.33,69.38 81.17,69.53 80.69,69.53 arc(80.09,69.42) 79.58,69.08 arc(79.22,68.52) 79.08,67.88 79.08,67.42 79.22,67.29 79.22,67.09 79.08,66.95 79.08,65.74 arc(79.03,65.45) 78.86,65.2 78.68,65.02 arc(78.33,64.78) 77.91,64.7 60.72,64.7 arc(60.49,64.66) 60.3,64.53 60.03,64.26 arc(59.88,64.03) 59.83,63.77 59.83,63.25 arc(59.73,62.62) 59.44,62.05 59.41,62 arc(59.19,61.55) 59.11,61.06 59.11,53.52 arc(58.88,52.97) 58.33,52.74 58.21,52.74 arc(58.18,52.73) 58.14,52.71 v2(57.89,52.45)
QSFPDD1_RX3_P: length 50
  L03_SIG1 w0.079: v2(57.89,53.25) 58.14,53 arc(58.18,52.97) 58.21,52.97 58.33,52.97 arc(58.72,53.13) 58.88,53.52 58.88,61.06 arc(58.97,61.62) 59.22,62.13 59.26,62.18 arc(59.51,62.69) 59.6,63.25 59.6,63.77 arc(59.67,64.12) 59.87,64.42 60.14,64.69 arc(60.41,64.87) 60.72,64.93 77.91,64.93 arc(78.24,65) 78.52,65.18 78.7,65.36 arc(78.82,65.53) 78.86,65.74 78.86,67.88 arc(79.01,68.61) 79.42,69.24 arc(80,69.63) 80.69,69.76 87.12,69.76 arc(87.26,69.79) 87.37,69.87 87.6,70.1 arc(87.76,70.2) 87.96,70.24 88.08,70.24 arc(88.19,70.26) 88.28,70.33 88.52,70.57 arc(88.66,70.66) 88.84,70.7 88.98,70.7 arc(89.15,70.67) 89.29,70.57 89.46,70.4 arc(89.55,70.34) 89.66,70.32 89.8,70.32 arc(89.9,70.31) 89.99,70.29 arc(89.99,70.29) 89.99,70.29 90.08,70.27 arc(90.11,70.26) 90.13,70.25 90.13,70.25 arc(90.38,70.05) 90.47,69.74 90.47,69.66 arc(90.47,69.64) 90.47,69.63 arc(90.47,69.63) 90.47,69.62 arc(90.46,69.45) 90.38,69.29 arc(90.27,69.15) 90.12,69.06 arc(90.06,69.03) 90.01,69.01 arc(89.98,68.99) 89.95,68.99 arc(89.95,68.99) 89.94,68.99 89.94,68.98 89.87,68.97 89.83,68.97 arc(89.82,68.97) 89.82,68.97 arc(89.81,68.97) 89.81,68.97 89.77,68.96 arc(89.75,68.96) 89.74,68.96 89.69,68.96 arc(89.57,68.98) 89.46,69.04 89.4,69.09 arc(89.34,69.15) 89.29,69.23 89.28,69.24 arc(89.22,69.29) 89.14,69.28 v2(88.9,69.14)
QSFPDD1_RX4_N: length 57.5
  L03_SIG1 w0.079: v2(52.03,49.65) 52.28,49.91 arc(52.32,49.93) 52.35,49.94 52.57,49.94 arc(52.68,49.89) 52.72,49.78 52.72,49.6 arc(52.82,49.1) 53.11,48.67 53.52,48.26 arc(54.41,47.67) 55.46,47.46 55.92,47.46 arc(58.81,48.03) 61.27,49.67 arc(62.52,51.55) 62.97,53.77 62.97,60.71 arc(63.08,61.27) 63.42,61.73 arc(63.48,61.79) 63.53,61.85 arc(64.03,62.22) 64.64,62.35 84.25,62.35 arc(84.34,62.36) 84.43,62.39 arc(84.67,62.55) 84.89,62.74 85.14,62.99 arc(85.32,63.11) 85.53,63.15 86.67,63.15 arc(86.92,63.2) 87.14,63.34 87.75,63.95 arc(87.82,64) 87.91,64.02 88.04,64.02 arc(88.35,64.09) 88.59,64.3 88.6,64.32 arc(88.72,64.43) 88.88,64.47 89.01,64.47 arc(89.07,64.46) 89.11,64.43 89.27,64.27 arc(89.48,64.13) 89.74,64.08 89.89,64.08 arc(90.08,64.12) 90.22,64.25 90.36,64.46 arc(90.41,64.51) 90.48,64.52 90.62,64.52 arc(90.88,64.59) 91.07,64.78 91.2,65.01 arc(91.22,65.08) 91.23,65.15 91.21,65.34 arc(91.19,65.43) 91.13,65.5 arc(91.09,65.59) 91.1,65.69 91.18,65.87 arc(91.19,65.91) 91.2,65.95 91.21,66.04 arc(91.21,66.24) 91.11,66.43 91.11,66.44 arc(91.08,66.47) 91.06,66.51 91.06,66.51 arc(91.04,66.62) 91.06,66.73 91.19,67.02 arc(91.22,67.2) 91.17,67.38 arc(91.13,67.69) 91.33,67.93 arc(91.38,67.95) 91.43,67.96 91.58,67.96 arc(91.67,67.97) 91.75,68 arc(91.86,68.07) 91.94,68.17 92.01,68.29 arc(92.05,68.3) 92.09,68.29 v2(92.36,68.14)
QSFPDD1_RX4_P: length 57.6
  L03_SIG1 w0.079: v2(52.03,50.45) 52.28,50.2 arc(52.32,50.17) 52.35,50.17 52.57,50.17 arc(52.84,50.05) 52.95,49.78 52.95,49.6 arc(53.03,49.18) 53.27,48.83 53.68,48.42 arc(54.5,47.88) 55.46,47.69 55.92,47.69 arc(58.73,48.24) 61.11,49.84 arc(62.31,51.64) 62.74,53.77 62.74,60.71 arc(62.88,61.36) 63.27,61.9 arc(63.32,61.95) 63.36,62 arc(63.94,62.42) 64.64,62.58 84.25,62.58 arc(84.28,62.58) 84.32,62.6 arc(84.54,62.73) 84.73,62.9 84.98,63.15 arc(85.23,63.32) 85.53,63.38 85.82,63.38 86,63.55 86.18,63.55 86.35,63.38 86.67,63.38 arc(86.84,63.41) 86.97,63.5 87.21,63.74 87.21,63.93 87.35,64.07 87.54,64.07 87.59,64.11 arc(87.73,64.21) 87.91,64.25 88.04,64.25 arc(88.24,64.3) 88.4,64.43 88.41,64.45 arc(88.61,64.63) 88.88,64.7 89.01,64.7 arc(89.15,64.67) 89.27,64.59 89.43,64.43 arc(89.57,64.34) 89.74,64.31 89.89,64.31 arc(89.97,64.32) 90.03,64.38 90.18,64.59 arc(90.31,64.71) 90.48,64.75 90.62,64.75 arc(90.76,64.79) 90.87,64.89 90.96,65.06 arc(90.99,65.13) 90.99,65.21 arc(90.97,65.31) 90.93,65.4 arc(90.86,65.58) 90.89,65.78 90.97,65.96 arc(90.97,65.98) 90.97,65.99 90.99,66.08 arc(90.99,66.19) 90.94,66.28 90.93,66.29 arc(90.89,66.35) 90.85,66.42 90.85,66.42 arc(90.81,66.62) 90.85,66.82 90.98,67.11 arc(90.99,67.19) 90.97,67.27 arc(90.91,67.75) 91.22,68.13 arc(91.32,68.17) 91.43,68.19 91.58,68.19 arc(91.62,68.19) 91.66,68.21 arc(91.7,68.24) 91.74,68.29 91.79,68.37 91.79,68.38 arc(91.8,68.44) 91.76,68.49 v2(91.49,68.64)
QSFPDD1_RX5_N: length 49.5
  L03_SIG1 w0.079: v2(54.96,50.05) 55.21,50.31 arc(55.25,50.33) 55.28,50.34 55.43,50.34 arc(55.62,50.26) 55.7,50.07 55.7,49.41 arc(55.96,48.79) 56.58,48.53 57.46,48.53 arc(58.83,48.8) 60,49.58 60.56,50.14 arc(61.73,51.9) 62.15,53.97 62.15,60.6 arc(62.33,61.55) 62.87,62.35 arc(63.5,62.81) 64.23,63.07 arc(64.27,63.07) 64.31,63.08 79.03,63.08 arc(80.44,63.36) 81.65,64.16 82.55,65.07 arc(82.8,65.23) 83.08,65.29 86.91,65.29 arc(87.21,65.36) 87.45,65.55 87.75,65.92 arc(87.8,65.97) 87.86,66 arc(87.92,66.02) 87.99,66.03 88.09,66.03 arc(88.3,66.08) 88.48,66.22 88.6,66.37 arc(88.69,66.44) 88.79,66.46 88.89,66.46 arc(88.96,66.47) 89.03,66.48 89.04,66.48 arc(89.24,66.57) 89.39,66.71 89.4,66.72 arc(89.44,66.77) 89.47,66.83 arc(89.53,67.08) 89.48,67.34 arc(89.47,67.36) 89.47,67.38 arc(89.47,67.38) 89.47,67.38 arc(89.46,67.44) 89.49,67.49 v2(89.76,67.64)
QSFPDD1_RX5_P: length 49.5
  L03_SIG1 w0.079: v2(88.89,67.14) 89.16,67.29 arc(89.22,67.3) 89.27,67.25 arc(89.3,67.09) 89.26,66.93 arc(89.24,66.89) 89.22,66.86 89.21,66.85 arc(89.11,66.76) 88.99,66.71 88.98,66.7 arc(88.94,66.7) 88.89,66.69 88.79,66.69 arc(88.74,66.69) 88.69,66.68 arc(88.55,66.62) 88.43,66.52 arc(88.42,66.51) 88.41,66.5 88.3,66.36 arc(88.2,66.29) 88.09,66.26 87.99,66.26 arc(87.88,66.25) 87.76,66.21 arc(87.66,66.15) 87.57,66.06 87.27,65.69 arc(87.11,65.56) 86.91,65.52 85.61,65.52 85.44,65.69 85.24,65.69 85.06,65.52 84.81,65.52 84.62,65.71 84.45,65.71 84.26,65.52 84.01,65.52 83.81,65.72 83.66,65.72 83.46,65.52 83.08,65.52 arc(82.71,65.44) 82.39,65.23 81.49,64.32 arc(80.36,63.57) 79.03,63.3 64.31,63.3 arc(64.25,63.3) 64.19,63.29 arc(63.39,63.01) 62.71,62.51 arc(62.12,61.64) 61.92,60.6 61.92,53.97 arc(61.52,51.99) 60.4,50.3 59.84,49.75 arc(58.75,49.01) 57.46,48.76 56.58,48.76 arc(56.12,48.95) 55.93,49.41 55.93,50.07 arc(55.79,50.42) 55.43,50.57 55.28,50.57 arc(55.25,50.57) 55.21,50.6 v2(54.96,50.85)
QSFPDD1_RX6_N: length 44.2
  L16_SIG6 w0.079: v1(52.03,52.05) 52.27,52.29 arc(52.32,52.33) 52.38,52.34 52.61,52.34 arc(52.97,52.49) 53.12,52.84 53.12,52.94 arc(53.57,54.04) 54.67,54.5 57.41,54.5 arc(58.76,54.76) 59.9,55.53 arc(60.19,55.72) 60.53,55.79 60.9,55.79 arc(61.44,55.9) 61.9,56.2 63.26,57.56 arc(63.61,58.09) 63.74,58.71 63.74,59.14 arc(64.01,59.8) 64.67,60.07 78.36,60.07 arc(80.1,60.41) 81.57,61.4 81.61,61.44 arc(82.61,62.1) 83.77,62.33 84.32,62.33 arc(84.51,62.37) 84.67,62.48 85.24,63.05 arc(85.36,63.13) 85.5,63.16 86.77,63.16 arc(86.93,63.19) 87.06,63.28 87.73,63.94 arc(87.77,63.97) 87.83,63.98 87.83,63.98 arc(88.2,64.06) 88.51,64.26 88.67,64.42 arc(88.72,64.46) 88.78,64.47 89.02,64.47 arc(89.25,64.53) 89.41,64.69 89.52,64.89 arc(89.57,65.09) 89.52,65.28 89.5,65.31 arc(89.49,65.43) 89.56,65.52 v1(89.76,65.64)
QSFPDD1_RX6_P: length 44.1
  L16_SIG6 w0.079: v1(52.03,52.85) 52.03,52.85 52.26,52.61 arc(52.32,52.58) 52.38,52.57 52.61,52.57 arc(52.81,52.65) 52.89,52.84 52.89,52.94 arc(53.41,54.2) 54.67,54.72 57.41,54.72 arc(58.67,54.97) 59.74,55.69 arc(60.11,55.93) 60.53,56.02 60.9,56.02 arc(61.35,56.11) 61.74,56.36 63.1,57.73 arc(63.4,58.18) 63.51,58.71 63.51,59.14 arc(63.85,59.96) 64.67,60.3 76.89,60.3 77.03,60.43 77.23,60.43 77.36,60.3 77.56,60.3 77.7,60.43 77.89,60.43 78.03,60.3 78.36,60.3 arc(80.01,60.63) 81.41,61.56 81.45,61.6 arc(82.52,62.31) 83.77,62.56 84.32,62.56 arc(84.42,62.58) 84.51,62.64 84.6,62.73 84.6,62.93 84.78,63.11 84.98,63.11 85.08,63.21 arc(85.27,63.34) 85.5,63.38 85.84,63.38 85.98,63.52 86.22,63.52 86.36,63.38 86.77,63.38 arc(86.84,63.4) 86.9,63.44 87.56,64.1 arc(87.69,64.18) 87.83,64.21 87.83,64.21 arc(88.11,64.27) 88.35,64.43 88.5,64.58 arc(88.63,64.67) 88.78,64.7 89.02,64.7 arc(89.13,64.73) 89.21,64.81 89.32,65 arc(89.35,65.09) 89.32,65.17 89.28,65.24 arc(89.22,65.29) 89.13,65.28 v1(88.89,65.14)
QSFPDD1_RX7_N: length 42.2
  L16_SIG6 w0.079: v1(89.76,63.64) 89.56,63.52 arc(89.49,63.43) 89.51,63.31 89.52,63.28 arc(89.57,63.1) 89.53,62.91 89.45,62.76 arc(89.24,62.55) 88.95,62.47 88.9,62.47 arc(88.73,62.44) 88.58,62.34 88.15,61.9 arc(87.84,61.7) 87.47,61.62 83.67,61.62 arc(83.42,61.52) 83.32,61.27 83.32,61.11 arc(83.18,60.77) 82.84,60.63 82.8,60.63 arc(82.69,60.61) 82.6,60.55 81.99,59.94 arc(81.83,59.83) 81.64,59.79 arc(81.62,59.79) 81.61,59.79 81.46,59.79 arc(80.3,59.56) 79.32,58.91 79.13,58.72 arc(78.84,58.29) 78.74,57.78 78.74,55.82 arc(78.58,55.01) 78.12,54.33 78.12,54.32 arc(77.51,53.89) 76.79,53.68 76.78,53.68 arc(76.73,53.67) 76.68,53.68 64.33,53.68 arc(64.31,53.67) 64.28,53.67 arc(63.95,53.52) 63.67,53.29 62.71,52.33 arc(61.89,51.78) 60.91,51.59 59.28,51.59 arc(58.58,51.73) 57.99,52.13 57.71,52.41 arc(57.34,52.65) 56.91,52.74 55.31,52.74 arc(55.25,52.73) 55.2,52.69 v1(54.96,52.45)
QSFPDD1_RX7_P: length 42.2
  L16_SIG6 w0.079: v1(54.96,53.25) 55.2,53.01 arc(55.25,52.98) 55.31,52.97 56.91,52.97 arc(57.43,52.86) 57.87,52.57 58.15,52.29 arc(58.67,51.94) 59.28,51.82 60.91,51.82 arc(61.8,51.99) 62.55,52.5 63.5,53.45 arc(63.83,53.71) 64.21,53.89 arc(64.27,53.9) 64.33,53.9 76.68,53.9 arc(76.72,53.91) 76.76,53.91 arc(77.41,54.09) 77.95,54.48 77.96,54.49 arc(78.37,55.1) 78.51,55.82 78.51,57.78 arc(78.63,58.37) 78.97,58.88 79.16,59.07 arc(80.22,59.77) 81.46,60.02 81.64,60.02 arc(81.74,60.04) 81.83,60.1 82.44,60.71 arc(82.61,60.82) 82.8,60.86 82.84,60.86 arc(83.02,60.93) 83.09,61.11 83.09,61.27 arc(83.26,61.68) 83.67,61.85 84.83,61.85 84.91,61.93 84.91,61.94 84.99,62.02 85.16,62.02 85.24,61.94 85.24,61.93 85.32,61.85 85.49,61.85 85.57,61.93 85.57,61.94 85.65,62.02 85.83,62.02 85.91,61.94 85.91,61.93 85.98,61.85 86.16,61.85 86.31,62 86.5,62 86.65,61.85 87.47,61.85 arc(87.75,61.91) 87.99,62.06 88.42,62.5 arc(88.64,62.65) 88.9,62.7 88.95,62.7 arc(89.12,62.75) 89.25,62.87 89.33,63.02 arc(89.35,63.09) 89.32,63.17 89.27,63.26 arc(89.22,63.3) 89.16,63.29 v1(88.89,63.14)
QSFPDD1_TX0_N: length 48.2
  L03_SIG1 w0.079: v2(57.89,62.85) 57.89,62.65 arc(57.92,62.58) 57.98,62.55 arc(58.3,62.69) 58.44,63 58.44,67.96 arc(59.22,70.15) 61.22,71.34 arc(61.29,71.36) 61.37,71.36 73.9,71.36 arc(74.28,71.52) 74.44,71.9 arc(74.64,72.37) 75.12,72.58 77.07,72.58 arc(77.33,72.52) 77.54,72.38 arc(77.72,72.26) 77.93,72.22 83.84,72.22 arc(84.14,72.28) 84.39,72.45 85.51,73.57 arc(85.64,73.66) 85.8,73.69 86.85,73.69 arc(86.95,73.7) 87.04,73.75 87.69,74.18 arc(87.8,74.23) 87.92,74.25 87.99,74.25 arc(88.19,74.29) 88.35,74.41 88.47,74.53 arc(88.66,74.67) 88.89,74.72 89.01,74.72 arc(89.23,74.66) 89.4,74.5 89.43,74.46 arc(89.54,74.35) 89.7,74.31 89.84,74.31 arc(90.09,74.24) 90.28,74.06 90.39,73.89 arc(90.5,73.78) 90.65,73.74 arc(90.93,73.67) 91.14,73.47 91.17,73.43 arc(91.27,73.34) 91.39,73.31 91.61,73.31 arc(91.72,73.33) 91.81,73.39 91.92,73.51 arc(92.12,73.65) 92.36,73.7 92.4,73.7 arc(92.61,73.66) 92.78,73.53 93.01,73.29 arc(93.05,73.26) 93.1,73.25 93.13,73.25 arc(93.68,72.97) 93.77,72.36 93.75,72.31 arc(93.81,71.97) 94.11,71.81 94.2,71.81 arc(94.32,71.79) 94.42,71.74 arc(94.48,71.68) 94.52,71.62 94.57,71.53 arc(94.63,71.49) 94.71,71.5 v2(94.96,71.64)
QSFPDD1_TX0_P: length 48.2
  L03_SIG1 w0.079: v2(94.09,71.14) 94.34,71.28 arc(94.38,71.34) 94.37,71.42 94.33,71.5 arc(94.3,71.53) 94.28,71.56 arc(94.24,71.58) 94.2,71.59 94.11,71.59 arc(93.62,71.84) 93.54,72.38 93.55,72.43 arc(93.49,72.84) 93.13,73.02 93.1,73.02 arc(92.96,73.05) 92.84,73.14 92.62,73.37 arc(92.52,73.45) 92.4,73.47 92.36,73.47 arc(92.21,73.44) 92.08,73.35 91.98,73.24 arc(91.81,73.12) 91.61,73.08 91.39,73.08 arc(91.16,73.14) 90.98,73.31 90.95,73.35 arc(90.82,73.47) 90.65,73.52 arc(90.39,73.58) 90.2,73.76 90.09,73.94 arc(89.98,74.04) 89.84,74.08 89.7,74.08 arc(89.43,74.15) 89.23,74.34 89.21,74.38 arc(89.12,74.46) 89.01,74.49 88.89,74.49 arc(88.75,74.46) 88.63,74.38 88.52,74.26 arc(88.28,74.08) 87.99,74.02 87.92,74.02 arc(87.86,74.01) 87.81,73.99 87.16,73.56 arc(87.01,73.48) 86.85,73.46 86.57,73.46 86.44,73.33 86.19,73.33 86.06,73.46 85.8,73.46 arc(85.73,73.45) 85.67,73.41 85.26,73 85.26,72.76 85.14,72.63 84.9,72.63 84.55,72.28 arc(84.22,72.07) 83.84,71.99 77.93,71.99 arc(77.64,72.05) 77.38,72.22 arc(77.24,72.31) 77.07,72.35 75.12,72.35 arc(74.81,72.21) 74.67,71.89 arc(74.44,71.35) 73.9,71.13 61.37,71.13 arc(61.31,71.13) 61.26,71.12 arc(59.4,70) 58.67,67.96 58.67,63 arc(58.46,62.53) 58,62.32 arc(57.99,62.32) 57.99,62.32 arc(57.92,62.29) 57.89,62.22 v2(57.89,62.05)
QSFPDD1_TX1_N: length 54.6
  L16_SIG6 w0.079: v1(49.1,62.45) 49.34,62.21 arc(49.39,62.18) 49.45,62.17 49.58,62.17 arc(49.76,62.24) 49.83,62.42 49.83,62.6 arc(50.05,63.71) 50.69,64.66 50.85,64.82 arc(56.67,68.71) 63.53,70.07 74.04,70.07 arc(74.59,69.96) 75.05,69.66 75.55,69.15 arc(75.59,69.12) 75.63,69.09 arc(77.34,68.6) 79.05,69.1 arc(80.15,69.59) 81.35,69.76 87.12,69.76 arc(87.25,69.79) 87.36,69.86 87.6,70.1 arc(87.78,70.22) 88,70.26 88.07,70.26 arc(88.21,70.3) 88.32,70.38 88.42,70.51 arc(88.54,70.63) 88.67,70.73 89.38,71.13 arc(89.84,71.22) 90.26,70.98 90.34,70.88 arc(90.47,70.79) 90.62,70.75 90.69,70.75 arc(90.78,70.77) 90.86,70.83 90.98,70.94 arc(91.17,71.07) 91.39,71.11 91.52,71.11 arc(91.81,71.05) 92.06,70.89 arc(92.2,70.8) 92.37,70.77 arc(92.53,70.8) 92.66,70.91 92.78,71.05 arc(92.97,71.2) 93.21,71.25 93.33,71.25 arc(93.55,71.3) 93.73,71.42 93.8,71.49 arc(94.08,71.67) 94.41,71.74 95.91,71.74 arc(96.1,71.7) 96.26,71.59 96.47,71.38 arc(96.55,71.33) 96.65,71.31 96.78,71.31 arc(97.04,71.24) 97.22,71.05 97.33,70.87 arc(97.38,70.69) 97.33,70.52 97.26,70.4 arc(97.25,70.34) 97.29,70.29 v1(97.56,70.14)
QSFPDD1_TX1_P: length 54.6
  L16_SIG6 w0.079: v1(96.69,70.64) 96.96,70.49 arc(97.02,70.48) 97.06,70.51 97.13,70.63 arc(97.15,70.69) 97.13,70.76 97.03,70.94 arc(96.92,71.04) 96.78,71.08 96.65,71.08 arc(96.47,71.12) 96.31,71.22 96.1,71.43 arc(96.01,71.49) 95.91,71.51 95.31,71.51 95.17,71.37 94.91,71.37 94.77,71.51 94.41,71.51 arc(94.17,71.46) 93.96,71.32 93.89,71.26 arc(93.64,71.08) 93.33,71.02 93.21,71.02 arc(93.07,70.99) 92.96,70.9 92.84,70.76 arc(92.63,70.6) 92.37,70.54 arc(92.12,70.58) 91.9,70.72 arc(91.72,70.84) 91.51,70.88 91.39,70.88 arc(91.26,70.86) 91.14,70.78 91.03,70.66 arc(90.87,70.56) 90.69,70.52 90.62,70.52 arc(90.37,70.58) 90.17,70.73 90.08,70.83 arc(89.81,70.99) 89.49,70.94 88.78,70.53 arc(88.69,70.46) 88.6,70.37 88.49,70.24 arc(88.31,70.09) 88.07,70.04 88,70.04 arc(87.87,70.01) 87.76,69.94 87.53,69.7 arc(87.34,69.58) 87.12,69.53 86.79,69.53 86.65,69.4 86.45,69.4 86.32,69.53 86.12,69.53 85.98,69.4 85.79,69.4 85.65,69.53 84.53,69.53 84.4,69.41 84.2,69.41 84.07,69.53 81.35,69.53 arc(80.22,69.37) 79.17,68.9 arc(77.34,68.37) 75.51,68.9 arc(75.45,68.94) 75.39,68.99 74.89,69.49 arc(74.5,69.75) 74.04,69.84 63.53,69.84 arc(56.75,68.49) 51.01,64.66 50.85,64.5 arc(50.27,63.63) 50.06,62.6 50.06,62.42 arc(49.92,62.08) 49.58,61.94 49.45,61.94 arc(49.39,61.93) 49.34,61.89 v1(49.1,61.65)
QSFPDD1_TX2_N: length 42.6
  L16_SIG6 w0.079: v1(94.96,69.64) 94.72,69.5 arc(94.64,69.49) 94.57,69.54 94.52,69.63 arc(94.39,69.76) 94.21,69.81 94.04,69.81 arc(93.85,69.77) 93.69,69.65 93.41,69.34 arc(93.31,69.28) 93.2,69.25 93.17,69.25 arc(92.97,69.21) 92.8,69.08 92.62,68.87 arc(92.51,68.78) 92.38,68.75 92.31,68.75 arc(92.18,68.78) 92.08,68.85 92,68.93 arc(91.8,69.06) 91.56,69.11 91.39,69.11 arc(91.17,69.07) 90.98,68.94 90.86,68.83 arc(90.78,68.77) 90.69,68.75 90.62,68.75 arc(90.47,68.79) 90.34,68.88 90.2,69.04 arc(89.85,69.25) 89.45,69.18 88.67,68.73 arc(88.54,68.63) 88.42,68.51 88.32,68.38 arc(88.21,68.3) 88.07,68.26 88.02,68.26 arc(87.82,68.23) 87.65,68.11 arc(87.41,67.95) 87.12,67.89 86.95,67.89 arc(86.67,67.84) 86.43,67.68 86.15,67.4 arc(85.91,67.24) 85.63,67.18 83.31,67.18 arc(82.5,67.02) 81.82,66.56 81.32,66.06 arc(80.96,65.82) 80.53,65.74 80.19,65.74 arc(79.83,65.66) 79.51,65.46 78.61,64.55 arc(78.09,64.21) 77.49,64.09 61.08,64.09 arc(59.5,63.43) 58.84,61.84 58.84,60.54 arc(58.73,60.28) 58.46,60.17 58.24,60.17 arc(58.18,60.18) 58.13,60.21 v1(57.89,60.45)
QSFPDD1_TX2_P: length 42.6
  L16_SIG6 w0.079: v1(57.89,59.65) 58.13,59.89 arc(58.18,59.93) 58.24,59.94 58.46,59.94 arc(58.89,60.11) 59.07,60.54 59.07,61.84 arc(59.66,63.27) 61.08,63.86 77.49,63.86 arc(78.18,64) 78.77,64.39 79.67,65.29 arc(79.91,65.45) 80.19,65.51 80.53,65.51 arc(81.05,65.61) 81.48,65.9 81.98,66.4 arc(82.59,66.81) 83.31,66.95 83.69,66.95 83.83,66.81 84.08,66.81 84.22,66.95 84.64,66.95 84.78,66.81 85.03,66.81 85.17,66.95 85.63,66.95 arc(86,67.03) 86.31,67.24 86.59,67.51 arc(86.76,67.63) 86.95,67.66 87.12,67.66 arc(87.49,67.74) 87.81,67.95 arc(87.91,68.01) 88.02,68.04 88.07,68.04 arc(88.31,68.09) 88.49,68.24 88.6,68.37 arc(88.69,68.46) 88.78,68.53 89.56,68.98 arc(89.81,69.02) 90.03,68.9 90.17,68.73 arc(90.37,68.58) 90.62,68.52 90.69,68.52 arc(90.87,68.56) 91.03,68.66 91.14,68.78 arc(91.26,68.86) 91.39,68.88 91.56,68.88 arc(91.71,68.85) 91.84,68.77 91.92,68.69 arc(92.1,68.57) 92.31,68.52 92.38,68.52 arc(92.61,68.58) 92.8,68.72 92.98,68.94 arc(93.06,69) 93.17,69.02 93.2,69.02 arc(93.41,69.07) 93.58,69.19 93.86,69.5 arc(93.94,69.56) 94.04,69.58 94.21,69.58 arc(94.27,69.56) 94.32,69.51 94.37,69.43 arc(94.38,69.34) 94.32,69.27 v1(94.09,69.14)
QSFPDD1_TX3_N: length 57.3
  L16_SIG6 w0.079: v1(94.96,67.64) 94.7,67.49 arc(94.63,67.48) 94.58,67.52 94.53,67.61 arc(94.5,67.71) 94.54,67.8 94.68,67.99 arc(94.75,68.06) 94.84,68.08 95.06,68.08 arc(95.25,68.12) 95.4,68.23 95.42,68.25 arc(95.55,68.5) 95.54,68.78 95.48,68.99 arc(95.47,69.13) 95.52,69.27 95.56,69.34 arc(95.64,69.64) 95.55,69.94 95.5,70.04 arc(95.29,70.23) 95.01,70.31 94.85,70.31 arc(94.73,70.34) 94.64,70.43 94.55,70.58 arc(94.4,70.74) 94.18,70.79 94.08,70.79 arc(93.86,70.74) 93.69,70.6 93.55,70.42 arc(93.4,70.3) 93.22,70.25 93.13,70.25 arc(92.96,70.22) 92.82,70.13 92.71,70.02 arc(92.59,69.94) 92.45,69.91 92.2,69.91 arc(92.08,69.93) 91.98,70 91.92,70.06 arc(91.72,70.2) 91.47,70.25 91.43,70.25 arc(91.2,70.19) 91.02,70.04 90.88,69.84 arc(90.8,69.78) 90.7,69.75 90.51,69.75 arc(90.45,69.76) 90.39,69.78 90.11,69.94 arc(89.74,70.03) 89.37,69.94 88.22,69.31 arc(88.13,69.28) 88.04,69.26 87.95,69.26 arc(87.76,69.23) 87.59,69.11 87.37,68.89 arc(86.92,68.59) 86.39,68.49 80.26,68.49 arc(80.15,68.48) 80.04,68.48 arc(80.03,68.47) 80.01,68.46 79.95,68.46 arc(79.31,68.2) 79.05,67.57 79.05,67.1 arc(78.88,66.23) 78.39,65.5 78.18,65.29 arc(77.72,64.98) 77.17,64.87 63.19,64.87 arc(62.78,64.93) 62.4,65.11 arc(62.03,65.28) 61.62,65.34 54.62,65.34 arc(53.05,65.03) 51.72,64.14 51.48,63.91 arc(51.1,63.33) 50.96,62.65 50.96,62.25 arc(50.96,62.19) 50.95,62.13 arc(50.83,61.84) 50.64,61.6 50.55,61.51 arc(50.12,60.87) 49.97,60.11 49.97,60.08 arc(49.88,59.86) 49.65,59.77 49.45,59.77 arc(49.39,59.78) 49.34,59.81 v1(49.1,60.05)
QSFPDD1_TX3_P: length 57.4
  L16_SIG6 w0.079: v1(49.1,59.25) 49.34,59.49 arc(49.39,59.53) 49.45,59.54 49.65,59.54 arc(50.04,59.7) 50.2,60.08 50.2,60.11 arc(50.33,60.78) 50.71,61.35 50.8,61.44 arc(51.03,61.73) 51.17,62.07 arc(51.18,62.16) 51.19,62.25 51.19,62.65 arc(51.31,63.24) 51.64,63.74 51.88,63.98 arc(53.14,64.82) 54.62,65.12 61.62,65.12 arc(61.96,65.07) 62.28,64.92 arc(62.71,64.71) 63.19,64.64 77.17,64.64 arc(77.8,64.77) 78.34,65.13 78.55,65.34 arc(79.09,66.15) 79.28,67.1 79.28,67.57 arc(79.48,68.04) 79.95,68.23 79.96,68.23 arc(80.01,68.24) 80.07,68.25 arc(80.16,68.26) 80.26,68.26 80.4,68.26 80.53,68.13 80.78,68.13 80.91,68.26 81.18,68.26 81.29,68.15 81.54,68.15 81.66,68.26 84.51,68.26 84.63,68.14 84.88,68.14 85,68.26 86.39,68.26 arc(87.01,68.38) 87.53,68.73 87.75,68.95 arc(87.85,69.01) 87.95,69.04 88.04,69.04 arc(88.19,69.06) 88.33,69.11 89.48,69.74 arc(89.74,69.8) 90,69.74 90.28,69.58 arc(90.39,69.54) 90.51,69.52 90.7,69.52 arc(90.91,69.57) 91.07,69.71 91.21,69.9 arc(91.31,69.99) 91.43,70.02 91.47,70.02 arc(91.63,69.99) 91.76,69.9 91.82,69.84 arc(92,69.72) 92.2,69.68 92.45,69.68 arc(92.68,69.73) 92.88,69.86 92.98,69.96 arc(93.05,70.01) 93.13,70.02 93.22,70.02 arc(93.51,70.09) 93.73,70.28 93.87,70.46 arc(93.96,70.54) 94.08,70.57 94.18,70.57 arc(94.28,70.54) 94.36,70.47 94.44,70.32 arc(94.61,70.14) 94.85,70.08 95.01,70.08 arc(95.18,70.04) 95.3,69.92 95.36,69.82 arc(95.41,69.64) 95.36,69.46 95.32,69.39 arc(95.24,69.16) 95.26,68.92 95.32,68.72 arc(95.33,68.55) 95.25,68.41 95.23,68.38 arc(95.15,68.33) 95.06,68.31 94.84,68.31 arc(94.65,68.26) 94.49,68.13 94.35,67.93 arc(94.28,67.72) 94.33,67.5 94.35,67.47 arc(94.36,67.35) 94.29,67.25 v1(94.09,67.14)
