# Allegro board FM85_AGILEX_PCIE_DK_CMC_ADI_REVC.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
VCCFUSEWR_SDM on L12_SIG4: 81.29,73.48 82.43,73.48 85.48,70.44 101.99,70.44 103.77,68.66 107.7,68.66 109.35,67.01 109.35,65.74 109.23,65.61 108.34,65.61 106.81,67.13 105.98,67.13 105.44,66.6 104.68,66.6 104.15,67.13 103.64,67.13 103,67.77 102.8,67.77 101.94,68.63 100.79,68.63 100.64,68.48 100.11,68.48 99.98,68.61 97.95,68.61 97.8,68.46 97.44,68.46 96.92,67.94 96.29,67.94 95.64,68.58 88.55,68.58 88.37,68.76 84.23,68.76 80.91,72.09 80.91,73.1
VCCFUSEWR_SDM on L14_SIG5: 81.9,74.7 81.87,74.73 81.87,77.32 76.31,82.88 76.31,84.41 75.01,85.7 72.57,85.7 71.66,84.79 71.66,83.87 73.18,82.35 73.64,82.35 74.48,81.51 74.48,79.91 75,79.39 77.41,79.39 77.91,78.89 77.91,77.63 77.45,77.17 59.95,77.17 58.05,75.26 39.5,75.26 38.87,74.63 38.87,73.48 40.27,72.09 59.65,72.09 62.36,74.81 78.14,74.81 79.36,73.59 79.36,72.9 80.04,72.21 81.57,72.21 81.9,72.55
VCCH_AGND on BOTTOM: 52.23,106.81 52.23,105.9 53.52,104.6 58.78,104.6 59.24,105.06 59.24,105.51 58.17,106.58 53.9,106.58 53.52,106.96 52.38,106.96
VCCH_FGT_GXF on BOTTOM: 85.12,56.31 87.05,56.31 87.31,56.58 87.31,60.91 86.24,60.91 85.73,60.4 84.97,60.4 84.72,60.15 84.72,56.72
VCCH_FGT_GXF on L07_SIG3: 85.35,55.83 85.35,64.98 85.61,65.23 101.51,65.23 102.22,64.52 102.22,58.73 101.82,58.33 98.05,58.33 95.3,55.58 85.61,55.58
VCCH_FGT_GXF on L12_SIG4: 87.64,56.47 85.73,56.47 84.46,57.74 84.46,61.04 85.1,61.67 86.75,61.67 87.38,62.31 87.38,63.32 87.76,63.71 97.42,63.71 98.18,64.47 101.35,64.47 101.61,64.72 102.24,64.72 102.5,64.47 102.5,61.93 98.18,57.61 98.18,55.58 97.67,55.07 89.03,55.07
VCCPLLDIG_HPS on BOTTOM: 149.03,47.41 149.11,47.49 150.47,47.49 150.5,47.45 150.5,45.96 150.39,45.84 148.45,45.84 148.43,45.86 148.43,47.37 148.46,47.41
VCCPLLDIG_HPS on L05_SIG2: 132.31,40.4 134.71,38 142.44,38 149.11,44.66 149.11,46.33 148.85,46.59 144.46,46.59 142.53,44.66 132.93,44.66 126.94,50.65 123.48,50.65 121.45,48.63 121.45,46.25 121.87,45.83 125.06,45.83 130.15,40.74 130.15,40.43 130.19,40.4
VCCPLLDIG_SDM on BOTTOM: 86.42,65.59 87.23,65.59 87.36,65.71 87.36,67.74 87.23,67.87 86.42,67.87 86.29,67.74 86.29,65.71
VCCPLLDIG_SDM on BOTTOM: 79.65,71.08 79.65,70.16 79.88,69.94 81.15,69.94 81.41,70.19 81.41,71.09 81.29,71.21 79.78,71.21
VCCPLLDIG_SDM on L07_SIG3: 102.75,68.66 103.89,67.52 107.58,67.52 107.83,67.77 107.83,69.04 108.08,69.29 109.48,69.29 109.74,69.04 109.74,66.5 107.45,64.21 103.77,64.21 102.37,65.61 81.01,65.61 79.43,67.19 79.43,70.77 79.74,71.07 81.87,71.07 84.28,68.66
VCCPLLDIG_SDM on L14_SIG5: 107.12,69.33 106.29,68.5 98.09,68.5 97.7,68.89 88.2,68.89 86.4,67.09 86.4,65.36 88.2,63.56 99.8,63.56 102.78,66.54 108.05,66.54 108.65,67.14 108.65,68.99 108.31,69.33
VCCR_CORE on TOP: 184.84,83.21 183.9,83.21 183.78,83.09 183.78,78.46 184.03,78.21 184.79,78.21 184.97,78.03 184.97,73.26 184.79,73.08 183.55,73.08 181.72,74.91 176.82,74.91 176.33,75.4 176.33,79.6 176.84,80.11 178.85,80.11 181.21,82.48 182.28,82.48 182.68,82.88 182.68,84.48 182.3,84.86 175.42,84.86 175.29,84.99 175.29,89 175.32,89.03 175.32,89.21 175.88,89.77 184.44,89.77 185,89.21 185,83.37
VCCR_CORE on TOP: 140.14,84.41 142.5,84.41 142.83,84.74 142.83,87.45 142.45,87.84 140.09,87.84 139.83,87.58 139.83,84.71
VCCR_CORE on BOTTOM: 184.97,88.27 184.97,83.21 184.72,82.96 184.13,82.96 183.93,82.76 183.93,78.72 184.26,78.39 185.02,78.39 185.2,78.21 185.2,73.66 184.51,72.98 183.52,72.98 183.24,73.26 183.24,73.38 181.72,74.91 176.21,74.91 176.03,75.09 176.03,80.06 176.08,80.11 178.85,80.11 179.31,80.57 179.31,81.77 179.56,82.02 181.52,82.02 182.3,82.81 182.3,84.71 182.15,84.86 175.17,84.86 174.81,85.22 174.81,88.7 176,89.89 184.31,89.89 185,89.21 185,88.29
VCCR_CORE on L05_SIG2: 192.2,88.3 192.9,87.6 192.9,73.81 192.38,73.28 173.03,73.28 154.19,54.43 126.66,54.43 126.31,54.08 126.31,51.25 125.94,50.88 123.4,50.88 121.88,49.35 119.9,49.35 119.77,49.48 119.77,51.26 119.13,51.89 113.04,51.89 112.15,51.01 112.15,49.62 111.94,49.41 111.08,49.41 110.34,50.16 108.51,50.16 108.03,50.63 108.03,65.67 108.16,65.8 109.41,65.8 109.83,66.23 109.83,68.62 110.51,69.29 113.21,69.29 113.34,69.17 113.34,67.21 113.55,67.01 119.64,67.01 120.53,67.9 120.53,69.57 120.91,69.95 122.13,69.95 122.64,70.46 124.16,70.46 125.2,69.42 129.62,69.42 132.85,72.65 132.85,78.18 133.1,78.44 136.79,78.44 138.82,80.47 138.82,87.3 139.35,87.84 148.6,87.84 149.06,88.3
VCCR_CORE on L14_SIG5: 121.17,49.51 111.06,49.51 110.52,50.04 110.52,51.18 112.28,52.94 120.78,52.94 121.32,52.4 121.32,49.66
VCCR_CORE_AGND on BOTTOM: 186.47,84.86 190.94,84.86 191.47,84.33 191.47,82.25 191.83,81.89 192.34,81.89 192.72,81.51 192.72,77.14 192.44,76.86 190.58,76.86 190.58,76.79 190.33,76.53 189.82,76.53 189.54,76.81 189.54,76.86 189.47,76.86 188.14,75.54 186.42,75.54 186.24,75.72 186.24,77.93 185.66,78.51 185.5,78.51 184.84,79.17 185.13,79.47 185.13,83.2 185.15,83.21 185.94,83.21 186.44,83.72 186.44,84.84 ; 1 cut-out
VCCR_CORE_AGND on L03_SIG1: 185.35,83.42 185.35,78.54 185.66,78.23 190.53,78.23 190.99,78.69 190.99,83.87 190.68,84.18 186.11,84.18
VDD33_OUT1 on BOTTOM: 229.39,43.26 229.39,41.81 229.47,41.73 231.22,41.73 231.83,41.13 231.83,38.31 232.37,37.77 236.25,37.77 236.92,38.44 236.92,40.62 236.26,41.28 232.98,41.28 232.29,41.96 232.29,43.11 231.99,43.41 229.55,43.41
(no net) on TOP: 54.35,5.8 53.98,6.17 53.98,8.46 54.24,8.71 54.87,8.71 55.13,8.46 55.13,5.92 54.95,5.75 54.95,2.6 54.35,2.6
(no net) on TOP: 51.19,99.01 51.19,98.63 51.06,98.5 50.38,98.5 49.84,97.97 49.84,96.27 50.27,95.84 54.86,95.84 55.03,96 55.03,98.25 54.26,99.01
(no net) on TOP: 206.48,44.53 207.91,43.11 207.91,41.35 207.02,40.46 201.78,40.46 199.14,43.11 199.14,43.77 198.89,44.02 196.86,44.02 196.73,44.15 196.73,45.54 199.68,45.54 199.98,45.24 200.59,45.24 200.74,45.39 200.74,45.98 200.82,46.05 201.81,46.05 201.94,45.93 201.94,44.61 201.81,44.48 201.81,42.95 203.77,42.95 203.87,43.06 203.87,43.64 204.2,43.97 205.06,43.97 205.16,44.07 205.16,44.4 205.29,44.53
(no net) on TOP: 51.72,102.95 54.39,102.95 54.39,100.84 54.92,100.84 55.33,100.43 55.33,100.21 56.01,99.52 59.19,99.52 59.19,94.95 45.98,94.95 45.98,99.52 49.49,99.52 50.63,100.66 51.72,100.66 ; 1 cut-out
(no net) on TOP: 51.47,100.92 50.43,100.92 49.54,100.03 45.83,100.03 45.83,102.59 46.18,102.95 48.6,102.95 48.74,102.81 48.74,102.2 49.26,101.68 51.47,101.68 ; 1 cut-out
(no net) on TOP: 206.2,48.85 196.98,48.85 196.73,48.59 196.73,46.43 197.24,45.93 199.68,45.93 199.75,46 199.75,46.46 199.68,46.54 198.99,46.54 198.76,46.76 198.76,47.68 199.37,48.29 201.81,48.29 202.11,47.98 202.11,44.45 202.06,44.4 202.06,43 203.46,43 203.72,43.26 203.72,43.87 203.61,43.97 203.61,45.32 203.97,45.67 205.82,45.67 206.76,46.61 206.76,48.29
(no net) on TOP: 40.8,100.87 41.56,100.87 42.45,99.98 45.63,99.98 45.68,100.03 45.68,101.96 42.15,101.96 41.82,101.63 40.8,101.63
(no net) on TOP: 32.42,94.52 32.42,92.48 32.67,92.23 45.12,92.23 45.63,92.74 45.63,94.52
(no net) on TOP: 203.97,44.02 204.99,44.02 205.11,44.15 205.11,44.53 205.37,44.78 206.69,44.78 208.41,43.06 208.41,42.75 208.67,42.5 210.57,42.5 210.83,42.75 210.83,44.15 210.57,44.4 210.07,44.4 209.15,45.32 208.64,45.32 208.59,45.27 207.96,45.27 207.8,45.42 204.2,45.42 203.84,45.06 203.84,44.15
(no net) on TOP: 37.62,98.96 37.62,98.58 37.5,98.45 36.81,98.45 36.28,97.92 36.28,96.22 36.71,95.79 41.49,95.79 41.79,96.09 41.79,97.87 41.33,98.33 40.55,98.33 40.42,98.45 40.42,98.96
(no net) on TOP: 46.46,94.57 46.46,91.48 46.84,91.1 58.97,91.1 59.66,91.79 59.66,94.57
(no net) on TOP: 54.36,100.92 55.13,100.92 56.01,100.03 59.24,100.03 59.47,100.26 59.47,101.78 59.24,102.01 55.71,102.01 55.38,101.68 54.36,101.68
(no net) on TOP: 37.88,102.9 40.16,102.9 40.16,100.61 41.31,100.61 42.45,99.47 45.63,99.47 45.63,94.9 32.42,94.9 32.42,99.47 35.59,99.47 36.74,100.61 37.88,100.61 ; 1 cut-out
(no net) on TOP: 45.65,6 45.65,8.89 46.08,9.32 48.65,9.32 48.93,9.05 48.93,6.96 48.7,6.73 48.52,6.73 48.22,6.43 48.22,5.92 47.95,5.66 47.95,2.6 45.45,2.6 45.45,5.79
(no net) on TOP: 52.35,2.6 52.35,5.77 52.08,6.05 52.08,8.59 52.2,8.71 53.22,8.71 53.35,8.59 53.35,6.17 52.95,5.78 52.95,2.6
(no net) on TOP: 37.24,100.87 36.48,100.87 35.59,99.98 32.42,99.98 32.42,102.39 32.67,102.64 34.58,102.64 34.58,102.14 34.7,102.01 35.97,102.01 36.35,101.63 37.24,101.63 ; 1 cut-out
(no net) on BOTTOM: 56.01,101.74 56.01,100.28 56.27,100.03 59.19,100.03 59.44,100.28 59.44,101.75 59.2,101.99 56.26,101.99
(no net) on BOTTOM: 54.24,7.19 54.87,7.19 55.13,7.44 55.13,9.22 54.87,9.48 54.87,10.87 54.49,10.87 54.49,9.6 53.98,9.1 53.98,7.44
(no net) on BOTTOM: 53.35,2.6 53.35,5.66 52.08,6.94 52.08,8.77 52.25,8.94 53.5,8.94 53.73,8.71 53.73,7.32 54.95,6.09 54.95,2.6
(no net) on BOTTOM: 45.98,94.47 45.98,92.53 46.24,92.28 58.23,92.28 58.59,92.64 58.59,94.3 58.41,94.47 55.97,94.47 55.97,94.47
(no net) on BOTTOM: outline of 115 points within 64.89,9.79 176.23,24.06 ; 6 cut-outs
(no net) on BOTTOM: 54.74,102.24 54.74,100.79 56.01,99.52 59.06,99.52 59.19,99.39 59.19,95.49 58.77,95.07 45.98,95.07 45.83,94.92 32.34,94.92 32.27,95 32.27,96.68 33.18,97.59 35.77,97.59 37.68,99.49 37.68,102.85 41.03,102.85 41.26,102.62 41.26,100.26 41.94,99.57 50.17,99.57 51.16,100.56 51.16,102.54 51.54,102.92 54.06,102.92
(no net) on BOTTOM: 46.35,2.6 46.35,5.8 46.11,6.05 46.11,8.82 46.34,9.05 48.7,9.05 48.93,8.82 48.93,6.96 48.7,6.73 48.52,6.73 48.22,6.43 48.22,5.92 47.95,5.66 47.95,2.6
(no net) on BOTTOM: 36.46,83.39 36.08,83.77 36.08,86.16 36,86.24 33.26,86.24 33.15,86.13 33.15,84.66 32.87,84.66 32.87,86.16 32.8,86.24 31.43,86.24 31.35,86.16 31.35,81.59 31.27,81.51 30.82,81.51 30.59,81.74 30.59,87.07 30.97,87.45 41.79,87.45 42.04,87.2 42.04,83.77 41.66,83.39
(no net) on L14_SIG5: 216.16,91.14 212.35,87.33 212.35,86.57 212.73,86.18 217.05,86.18 217.69,85.55 217.69,83.9 218.32,83.26 229.62,83.26 230,83.64 230,85.65 232.14,87.79 237.32,87.79 238.87,86.24 238.87,73.76 239.53,73.1 239.91,73.1 240.16,73.36 240.16,79.45 241.05,80.34 243.85,80.34 244.23,80.72 244.23,81.1 243.34,81.99 243.34,89.74 241.94,91.14 235.72,91.14 234.42,92.43 230.33,92.43 229.04,91.14
0P6V_VREF_DDR4_CH01 on BOTTOM: 119.6,26.77 119.6,20.18 119.99,19.78 123.12,19.78 123.2,19.86 123.2,20.35 123.14,20.4 121.92,20.4 121,21.33 121,27.18 119.43,28.74 119.06,28.74 118.68,28.36 118.68,27.68
0P6V_VREF_DDR4_CH01 on L05_SIG2: 46.44,26.27 44.99,26.27 44.53,25.81 44.53,19.18 46.36,17.35 56.27,17.35 58.55,15.06 68.61,15.06 68.76,15.22 68.76,16.28 68.54,16.51 65.18,16.51 61.9,19.79 48.95,19.79 46.97,21.77 46.97,25.73
0P6V_VREF_DDR4_CH01 on L10_PWR2: 120.31,30.38 118.6,28.67 118.6,27.79 118.95,27.44 119.59,27.44 122.32,30.17 122.32,47.29 121.98,47.63 121.79,47.63 121.35,47.19 120.68,47.19 120.31,46.81
0P6V_VREF_DDR4_CH01 on L16_SIG6: 110.13,47.45 110.13,46.31 110.39,46.05 117.81,46.05 118.52,46.76 118.88,46.76 119.34,46.31 121.29,46.31 121.85,46.87 122.03,46.87 122.26,47.09 122.26,47.45 122,47.7 110.39,47.7
0P6V_VREF_DDR4_CH2 on L10_PWR2: 122.79,69.7 123.18,70.1 123.18,78.5 128.19,83.52 188.93,83.52 196.48,91.07 196.48,99.81 195.33,100.96 190.04,100.96 186.98,97.9 114.69,97.9 110.73,93.95 89.56,93.95 88.85,93.23 88.85,80.66 89.56,79.94 105.32,79.94 106.29,78.97 106.29,74.69 111.28,69.7
0P6V_VREF_DDR4_CH2 on L12_SIG4: 28.54,108.31 54.14,108.31 54.97,107.49 95.87,107.49 99.57,103.79 99.57,92.94 96.93,90.3 88.53,90.3 88.33,90.5 88.33,92.61 88.65,92.93 92.31,92.93 93.82,94.44 93.82,103.75 91.95,105.62 89.56,105.62 88.37,104.42 29.2,104.42 28.19,105.44 28.19,107.97
0P6V_VREF_DDR4_CH3 on L10_PWR2: 112.21,71.12 114.57,71.12 116.75,73.31 116.75,86.82 119.3,89.37 179.91,89.37 181.22,88.06 186.7,88.06 187.05,88.41 187.05,92.65 186.67,93.03 113.95,93.03 109.51,88.59 109.51,73.82
0P6V_VTT_DDR4_CH01 on BOTTOM (solid shape): 77.79,23.94 77.79,22.19 78.29,21.69 78.29,20.52 78.23,20.45 78.21,20.36 78.21,19.74 78.17,19.67 78.09,19.66 78,19.69 77.91,19.7 77.86,19.7 77.83,19.78 77.87,19.84 77.88,19.92 77.88,20.42 77.82,20.57 77.68,20.63 77.17,20.63 77.07,20.62 77.07,20.75 77.25,20.75 77.25,21.26 77.07,21.26 77.07,21.39 76.99,21.47 76.99,21.65 77.02,21.65 77.02,22.16 76.99,22.16 76.99,22.54 77.02,22.54 77.02,23.04 76.99,23.04 76.99,23.41 77.02,23.41 77.02,23.93 77.15,24.06 77.68,24.06
0P6V_VTT_DDR4_CH01 on BOTTOM (solid shape): outline of 3101 points within 64.89,9.79 176.23,24.06
0P6V_VTT_DDR4_CH01 on TOP: 174.82,14.39 174.84,14.4 174.84,25.48 174.67,25.65 173.58,25.65 173.39,25.45 173.39,15.83 172.78,15.22 163.33,15.22 163.3,15.19 77.94,15.19 77.49,14.75 68.05,14.75 68.04,14.76 66.53,14.76 66.52,14.75 65.27,16 65.16,16 65.16,18.72 66.76,20.33 66.76,22.86 66.36,23.26 64.42,23.26 64.05,22.89 64.04,22.89 63.8,22.65 63.8,20.58 62.64,19.42 62.64,13.91 64,12.55 75.12,12.55 75.26,12.69 75.9,12.69 76.94,11.64 78.66,11.64 78.86,11.84 110.09,11.84 111.99,9.94 118.25,9.94 120.15,11.84 136.38,11.84 138.6,14.05 143.56,14.05 144.73,12.88 161.91,12.88 162.8,13.77 174.61,13.77 174.84,14 174.82,14.01
0P6V_VTT_DDR4_CH01 on BOTTOM: 41.23,25.4 41.94,26.11 41.94,26.95 41.87,27.03 41.1,27.03 41.05,27.08 41.05,27.56 41.03,27.59 39.91,27.59 39.89,27.56 39.89,22.61 39.96,22.53 41.1,22.53 41.23,22.66
0P6V_VTT_DDR4_CH01 on L12_SIG4: 50.4,28.31 66.57,28.32 67.24,27.65 67.24,21.62 66.56,20.93 65.01,20.93 63.94,22 60.85,22 59.5,23.35 59.5,23.37 49.99,23.37 48.94,22.31 46.81,22.31 45.43,23.7 39.76,23.7 38.69,24.77 38.68,24.77 37.82,25.63 37.82,27.67 38.47,28.31 39.24,28.31 40.66,29.73 44.3,29.73 46.74,27.29 48.84,27.29 49.86,28.31
0P6V_VTT_DDR4_CH2 on TOP: 28.38,104.35 28.38,103.36 28.61,103.14 33.1,103.14 34.13,104.17 34.13,104.39 34.12,104.39 34.12,105.07 36.04,106.99 53.39,106.99 53.89,107.5 53.89,109.49 53.63,109.75 32.41,109.75 31.5,108.84 31.5,104.92 30.92,104.35
0P6V_VTT_DDR4_CH2 on TOP: 26.56,104.53 26.61,104.58 27.27,104.58 27.6,104.25 31.05,104.25 31.05,103.28 30.96,103.19 29.59,103.19 29.51,103.11 29.51,101.97 29.43,101.89 27.22,101.89 27.15,101.97 27.15,103.04 26.99,103.19 25.85,103.19 25.62,103.42 25.62,104.48 25.85,104.48 25.85,103.64 25.93,103.57 26.54,103.57 26.56,103.59
0P6V_VTT_DDR4_CH2 on BOTTOM: 33.56,109.73 130.93,109.73 131.59,109.06 131.59,106.25 132.87,104.97 132.87,102.89 132.68,102.7 132.68,101.07 132.35,100.73 130.99,100.73 130.8,100.92 130.8,103.69 128.69,105.8 126.44,105.8 124.84,107.41 99.13,107.41 99.04,107.5 70.7,107.5 70.14,106.93 53.9,106.93 53.64,107.2 51.01,107.2 50.02,106.21 46.05,106.21 45.06,107.2 36.75,107.2 35.64,106.09 35.64,103.98 35.01,103.34 29.59,103.34 29.51,103.26 29.51,101.97 29.43,101.89 27.22,101.89 27.15,101.97 27.15,102.88 27.22,102.96 28.14,102.96 28.44,103.26 28.44,104.33 28.52,104.41 30.88,104.41 30.96,104.33 31.2,104.57 31.2,107.36
0P6V_VTT_DDR4_CH2 on L14_SIG5: 130.79,102.12 130.79,107.42 132.62,109.25 188.09,109.25 190,107.34 235.26,107.34 236.71,105.9 236.71,104.52 235.26,103.08 189.85,103.08 186.72,106.2 135.52,106.2 133.61,104.3 133.61,102.01 133.49,101.89 131.03,101.89
0P6V_VTT_DDR4_CH3 on TOP: 188.32,92.64 188.32,91.57 199.6,91.57 199.6,92.64
0P6V_VTT_DDR4_CH3 on BOTTOM: 189.39,91.95 192.44,91.95 192.82,92.33 197.62,92.33 197.77,92.18 197.77,90.58 197.7,90.5 189.39,90.5 189.31,90.58 189.31,90.88 189.39,90.96 190.3,90.96 190.38,91.04 190.38,91.49 190.3,91.57 190.08,91.57 189.92,91.72 189.39,91.72 189.31,91.8 189.31,91.87
0P6V_VTT_DDR4_CH3 on BOTTOM: 130.79,94.46 130.79,95.68 130.26,96.22 128.58,96.22 128.43,96.37 128.43,99.68 128.42,99.69 128.61,99.88 131.33,99.88 131.5,99.7 131.5,96.81 131.63,96.68 131.63,95.85 131.45,95.67 131.45,94.4 131.4,94.35 130.91,94.35
0P6V_VTT_DDR4_CH3 on L14_SIG5: 199.3,91.26 189.31,91.26 188.65,91.93 182.88,91.93 179.14,95.67 179.14,96.8 173.68,102.26 168.35,102.26 166.57,100.49 140.92,100.49 139.44,99 139.44,92.06 139.04,91.67 135.77,91.67 135.38,92.05 135.38,103.95 136.8,105.36 183.98,105.36 191.37,97.97 191.37,95.99 192.97,94.39 199.52,94.39 200.21,93.7 200.21,92.18
0P6V_VTT_DDR4_CH3 on L16_SIG6: 133.31,91.04 130.64,93.7 130.64,94.06 129.19,95.51 129.19,102.51 130.68,104.01 143.62,104.01 144.65,102.98 144.65,92.83 142.86,91.04
0P8V_VCC_HSSI_GXF on TOP: 78.47,65.69 78.47,64.39 77.88,63.81 63.2,63.81 62.97,64.04 62.97,65.76 63.05,65.84 67.95,65.84 68,65.79 68,65.03 68.33,64.7 72.91,64.7 73.39,65.18 73.39,65.81 73.49,65.92 78.24,65.92
0P8V_VCC_HSSI_GXF on BOTTOM: 60.23,71.71 60.23,63.53 60.94,62.82 63.43,62.82 64.27,63.66 81.49,63.66 81.62,63.78 81.62,65.46 84.59,65.46 85.2,66.07 85.2,69.14 84.87,69.47 81.39,69.47 81.36,69.5 79.59,69.5 79.36,69.27 79.36,66.58 79.18,66.4 69.73,66.4 69.6,66.27 63.41,66.27 63.13,66.55 63.13,71.71 63.05,71.78 60.31,71.78
0P8V_VCC_HSSI_GXF on L10_PWR2: 111.13,69.29 105.8,74.63 105.8,78.56 105.16,79.2 86.52,79.2 84.81,77.49 81.37,77.49 77.96,74.08 74.4,74.08 74.25,73.93 74.25,73.43 74.56,73.13 74.56,67.87 72.8,66.12 63.05,66.12 62.59,65.66 62.59,62.77 63.05,62.31 76.61,62.31 78.21,60.71 78.21,51.34 75.9,49.02 75.9,33.18 77.32,31.76 88.66,31.76 93.77,36.87 100.69,36.87 101.7,37.88 101.7,55.22 103.71,57.23 106.56,57.23 108.08,58.75 108.08,62.56 112.15,66.63 112.15,68.91 111.77,69.29
0P8V_VCCH on TOP (solid shape): 54.85,94.57 59.66,94.57 59.66,91.79 58.97,91.1 46.84,91.1 46.46,91.48 46.46,94.57 51.33,94.57
0P8V_VCCH on BOTTOM (solid shape): 53.85,94.44 54.87,94.44 54.87,94.47 55.97,94.47 55.97,94.47 56.73,94.47 56.73,94.41 58.35,94.41 58.35,94.47 58.41,94.47 58.59,94.3 58.59,92.64 58.23,92.28 46.24,92.28 45.98,92.53 45.98,94.47 53.85,94.47
0P8V_VCCH on L03_SIG1: 125.28,58.17 125.28,52.83 125.1,52.66 122.05,52.66 120.91,51.51 107.7,51.51 107.35,51.87 107.35,56.16 105.52,57.98 105.52,63.91 107.38,65.77 107.81,65.77 108.99,66.95 109.44,66.95 110.28,67.79 111.92,67.79 113.85,65.86 124.72,65.86 124.98,66.12 125.48,66.12 127.26,64.34 127.26,60.15
0P8V_VCCH on L09_PWR1: 107.83,59.13 107.83,39.19 110.12,36.91 110.12,36.34 109.88,36.1 82.92,36.1 78.33,40.69 55.12,40.69 53.4,42.41 53.41,42.41 44.03,51.79 44.03,91.29 47.31,94.58 57.53,94.58 57.73,94.38 59.04,94.38 60.34,93.08 60.34,70.11 62.14,68.31 80.75,68.31 84.21,64.85 84.21,62.05 86.11,60.15 103.89,60.15 105.29,61.55 105.29,65.61 105.67,65.99 108.19,65.99 108.57,65.61 108.57,59.87
0P8V_VCCH on L14_SIG5: 46.9,94.44 46.9,92.29 47.27,91.92 58.08,91.92 58.47,92.3 58.47,94.42 58.12,94.78 47.23,94.78
0P9V_VCC_HSSI_GXR on TOP: 185.43,51.36 185.43,48.9 185.73,48.59 185.73,44.25 185.43,43.94 184.16,43.94 183.24,43.03 183.24,40.72 183.78,40.19 184.21,40.19 184.39,40.01 184.39,39.25 184.61,39.02 185.33,39.02 185.76,38.59 185.76,37.9 185.78,37.87 185.78,33.02 186.06,32.74 188.48,32.74 188.63,32.59 188.63,27.69 188.25,27.31 179.69,27.31 179.25,27.74 179.25,30.76 177.93,32.08 177.93,34.52 177.91,34.55 177.91,44.53 177.07,45.37 177.07,46.03 175.7,47.39 175.39,47.39 174.88,47.9 174.88,50.95 175.27,51.34 177.63,51.34 177.91,51.62 185.17,51.62
0P9V_VCC_HSSI_GXR on BOTTOM: 176.87,51.95 185.33,51.95 185.53,51.74 185.53,49.2 185.91,48.82 185.91,44.17 185.78,44.05 179.64,44.05 179.31,44.38 179.31,45.11 179.05,45.37 178.26,45.37 176.64,46.99 176.64,51.72
0P9V_VCC_HSSI_GXR on BOTTOM: 185.86,37.09 185.86,33.15 186.09,32.92 188.3,32.92 188.63,32.59 188.63,30.33 178.52,30.33 178.29,30.56 178.29,33.71 178.24,33.76 178.24,34.47 178.65,34.88 181.62,34.88 182.33,35.59 182.33,36.1 182.48,36.25 184.36,36.25 184.82,36.71 184.82,37.32 184.97,37.47 185.48,37.47
0P9V_VCC_HSSI_GXR on L03_SIG1: 106.97,55.81 106.97,51.72 107.55,51.13 121.04,51.13 122.18,52.28 125.36,52.28 125.66,52.58 125.66,58.04 128.15,60.53 132.98,60.53 133.74,59.77 133.74,48.19 128.84,45.36 118.36,45.36 115.19,42.19 109.48,42.19 103,48.67 103,55.32 104.27,56.59 106.18,56.59
0P9V_VCC_HSSI_GXR on L10_PWR2: 122.94,69.29 123.71,70.06 123.71,77.68 129.17,83.14 182,83.14 182.61,82.53 182.61,57.66 185.58,54.69 185.58,44.83 185.56,44.84 185.56,43.88 185.45,43.77 133.26,43.77 127.55,49.48 109.61,49.48 107.58,47.45 104.78,47.45 104.53,47.7 104.53,54.92 105.34,55.73 105.34,56.64 105.54,56.85 106.43,56.85 108.47,58.88 108.47,62.44 112.53,66.5 112.53,68.91 112.91,69.29
0P9V_VCCED_GXR on TOP: 203.59,52.78 203.72,52.91 204.73,52.91 205.75,51.89 205.75,49.48 205.37,49.1 195.51,49.1 195.26,49.35 195.26,52.78 194.77,53.27 193.56,53.27 193.35,53.47 193.35,56.06 193.43,56.14 195.71,56.14 195.87,55.98 195.87,54.16 196.1,53.93 196.6,53.93 197.04,53.49 199.19,53.49 199.27,53.57 199.27,53.58 199.27,54.4 199.3,54.43 199.91,54.43 200.03,54.31 200.03,50.9 200.29,50.65 204.4,50.65 204.4,52.12 204.25,52.28 203.72,52.28 203.59,52.4
0P9V_VCCED_GXR on BOTTOM: 196.7,49.13 200.21,49.13 200.44,49.35 200.44,49.58 200.74,49.89 200.74,50.35 200.46,50.35 200.11,50.7 200.11,53.52 199.47,54.16 196.76,54.16 195.59,55.32 195.59,55.78 195.18,56.19 193.76,56.19 193.38,55.81 193.38,52.68 193.89,52.17 194.98,52.17 195.79,51.36 195.79,50.04
0P9V_VCCED_GXR on L14_SIG5: 196.27,49.1 195.84,48.67 192.49,48.67 192.06,48.24 178.64,48.24 177.74,47.34 177.74,41.88 174.59,38.73 160.9,38.73 154.78,44.84 154.78,46.11 154.08,46.81 136.81,46.81 134.77,48.86 125.95,48.86 121.79,53.01 111.69,53.01 110.41,51.72 104.14,51.72 103.98,51.88 103.98,53.57 104.41,54 105.8,54 106.81,55.02 106.81,61.19 107.47,61.85 191.45,61.85 198.43,54.87 198.43,53.04 199.12,52.35 199.12,49.41 198.81,49.1
0P9V_VCCL_HPS on TOP (solid shape): outline of 470 points within 196.73,40.46 207.91,46.05
0P9V_VCCL_HPS on BOTTOM: 197.11,41.35 199.11,41.35 199.26,41.5 199.26,42.89 199.49,43.12 201.21,43.12 201.37,42.96 201.37,42.41 201.49,42.3 201.94,42.3 201.98,42.34 201.98,44.32 201.64,44.66 200.92,44.66 200.29,45.29 197.11,45.29 196.86,45.04 196.86,41.61
0P9V_VCCL_HPS on L07_SIG3: 122.18,51.64 122.18,49.48 122.44,49.23 123.07,49.23 123.32,49.48 123.32,50.12 123.58,50.37 124.59,50.37 126.12,48.85 126.12,46.26 126.63,45.75 127.18,45.75 128.18,46.74 128.53,46.74 128.91,46.36 130.79,46.36 131.33,46.89 132.32,46.89 132.54,47.12 134.02,47.12 134.83,46.31 135.24,46.31 135.8,45.75 135.97,45.75 136.47,45.25 136.61,45.18 136.96,45.11 137.27,44.83 139.34,43.74 140.92,45.32 153.96,45.32 170.76,28.51 200.38,28.51 200.69,28.83 200.69,39.32 202.42,41.05 206.15,41.05 206.99,41.89 206.99,47.45 206.61,47.83 198.3,47.83 196.35,45.88 196.35,44.78 192.54,40.97 183.4,40.97 182.28,39.86 173.9,39.86 173.11,40.64 173.11,42.88 166.05,49.94 166.01,49.94 158.48,57.47 158.48,65.1 155.29,68.28 149.23,68.28 148.98,68.02 148.98,53.67 148.34,53.04 123.58,53.04
1P0V_VCCCLK_GXR on TOP: 178.49,69.24 179.18,69.24 179.41,69.47 179.41,70.16 179.48,70.23 180.02,70.23 180.09,70.31 180.09,72.45 180.16,72.51 181.36,72.51 182.72,71.15 183.37,71.15 183.52,71 183.52,69.32 183.37,69.17 182.07,69.17 181.62,68.71 178.49,68.71
1P0V_VCCCLK_GXR on L05_SIG2: 178.65,68.48 179.84,67.28 179.84,66.32 177.72,64.2 177.72,62.59 174.28,59.15 172.36,59.15 172.25,59.26 171.15,59.26 170.37,58.48 170.37,45.06 167.1,41.79 150.34,41.79 143.45,34.9 139.33,34.9 138.82,35.41 138.82,36.03 139.17,36.38 141.57,36.38 149.67,44.48 149.67,46.52 149.14,47.05 144.28,47.05 142.34,45.11 133.07,45.11 126.5,51.68 126.5,53.97 126.63,54.1 128.57,54.1 128.68,53.99 128.68,52.65 130.88,50.45 159.11,50.45 176.18,67.53 176.18,68.01 176.66,68.48
1P0V_VCCCLK_GXR on L07_SIG3: 98.36,57.94 103.21,57.94 103.42,57.72 103.91,57.72 104.66,56.97 104.66,55.4 104.09,54.84 104.09,54.09 103.29,53.29 101.04,53.29 97.72,56.61 97.72,57.3
1P0V_VCCCLK_GXR on L10_PWR2: 56.82,13.46 58.19,13.46 61.97,17.24 61.97,29.04 62.67,29.73 92.71,29.73 94.7,31.72 94.7,31.97 97.25,34.52 102.91,34.52 104.36,35.98 104.36,55.34 104.61,55.59 104.61,55.93 104.44,56.1 103.05,56.1 102.27,55.32 102.27,37.86 100.85,36.43 94.84,36.43 89.55,31.14 60.03,31.14 59.13,30.24 59.13,17.87 56.5,15.25 56.5,13.77
1P0V_VCCCLK_GXR on L16_SIG6: 147.08,79.98 170.07,79.98 175.84,74.21 181.45,74.21 185.5,70.17 185.5,67.11 185.08,66.7 180.78,66.7 180.32,66.25 147.3,66.25 143.29,62.23 135.44,62.23 133.74,60.53 128.4,60.53 128.02,60.15 128.02,55.83 128.79,55.07 128.79,53.75 128.53,53.5 128.53,52.89 128.35,52.71 127.85,52.71 127.39,53.16 127.39,54.31 124.34,57.36 106.43,57.36 104.53,55.45 104.02,55.45 103,56.47 103,60.12 116.89,68.12 135.22,68.12 ; 3 cut-outs
1P0V_VCCERT_FGT_GXF on TOP (solid shape): 45.63,92.74 45.12,92.23 32.67,92.23 32.42,92.48 32.42,94.52 45.63,94.52
1P0V_VCCERT_FGT_GXF on BOTTOM: 32.42,94.39 32.42,92.33 32.8,91.95 44.23,91.95 44.76,92.48 44.76,94.01 44.3,94.47 32.49,94.47
1P0V_VCCERT_FGT_GXF on L09_PWR1: 104.91,61.67 104.91,74.63 96.13,83.41 96.13,87.3 91.33,92.1 90.57,92.1 89.47,93.2 89.47,93.35 89.46,93.35 89.46,97.54 87.99,99.01 80.65,99.01 80.18,99.48 79.63,99.48 79.63,99.48 55.62,99.48 36.38,99.04 34.4,97.06 34.4,89.21 35.63,87.98 42.79,87.98 43.61,88.8 43.61,91.18 47.28,94.85 59.12,94.85 60.7,93.27 60.7,70.47 62.26,68.91 80.78,68.91 84.59,65.1 84.59,62.31 86.37,60.53 103.77,60.53
1P0V_VCCERT_FGT_GXF on L14_SIG5: 34.7,94.29 34.7,92.19 34.91,91.97 44.37,91.97 44.58,92.19 44.58,94.21 44.29,94.5 34.91,94.5
1P0V_VCCFUSE_GXR on TOP: 195.84,69.29 195.94,69.4 198.18,69.4 198.36,69.57 198.36,70.61 198.25,70.72 194.98,70.72 194.8,70.54 194.8,69.9 194.65,69.75 193.48,69.75 193.45,69.73 193.45,68.13 193.53,68.05 194.37,68.05 194.44,68.13 195.82,68.13 195.84,68.15
1P0V_VCCFUSE_GXR on L05_SIG2: 154.31,54.05 129.17,54.05 128.83,53.72 128.83,52.89 130.7,51.03 158.97,51.03 175.78,67.83 175.78,68.12 176.57,68.91 178.64,68.91 181.89,65.66 193.51,65.66 196.04,68.19 196.04,72.19 195.45,72.78 173.03,72.78
1P0V_VCCFUSE_GXR on L16_SIG6: 128.53,52.4 127.64,52.4 127.13,52.91 125.48,52.91 123.83,54.56 105.93,54.56 105.42,55.07 103.89,55.07 103,55.96 102.12,55.96 101.86,55.7 101.86,53.67 102.37,53.16 104.02,53.16 104.78,52.4 123.71,52.4 125.48,50.62 129.44,50.62 130.44,51.63 130.44,53.04 129.98,53.5 129.47,53.5 129.42,53.55 128.91,53.55 128.79,53.42 128.79,52.66
1P0V_VCCRT_GXR on TOP: 198.25,29.47 198.25,37.54 198.08,37.72 198.08,40.29 197.77,40.59 196.17,40.59 195.97,40.39 195.97,36.38 195.41,35.82 195.41,28.48 195.56,28.32 196.02,28.32 196.25,28.55 196.25,29.19 196.4,29.34 198.13,29.34
1P0V_VCCRT_GXR on BOTTOM: 102.27,53.06 102.27,52.33 102.12,52.17 101.89,52.17 101.68,52.38 101.02,52.38 100.79,52.15 99.7,52.15 99.7,53.16 100.16,53.62 101.43,53.62 101.68,53.88 101.68,55.02 102.04,55.37 102.55,55.37 102.98,54.94 102.98,53.77
1P0V_VCCRT_GXR on BOTTOM: 197.37,37.92 196.17,37.92 195.08,36.83 195.08,29.57 195.41,29.24 197.09,29.24 197.37,29.52
1P0V_VCCRT_GXR on L12_SIG4: 133.53,73.41 173.82,73.41 176.41,70.82 191.04,70.82 191.51,70.35 191.51,67.04 192.81,65.74 196.8,65.74 198.28,64.26 198.28,57.18 196.88,55.78 195.19,55.78 192.82,53.4 192.82,50.7 194.27,49.24 194.27,36.99 198.28,32.98 198.28,29.95 197.92,29.59 193.07,29.59 191.75,28.27 174.27,28.27 173.31,29.23 146.48,29.23 135.39,40.32 135.39,46.44 133.18,48.65 130.64,48.65 130.56,48.72 120.91,48.72 118.63,51.01 110.45,51.01 109.96,51.49 106.15,51.49 105.34,52.3 99.02,52.3 98.56,52.76 98.56,57.48 102.88,61.8 102.88,64.47 103.13,64.72 104.66,64.72 105.04,65.1 109.35,65.1 109.86,65.61 109.86,68.53 111.39,70.06 127.87,70.06 132.77,72.77 133.13,73.1 ; 10 cut-outs
1P2V_DDR4_CH01 on TOP: 192.95,16.08 193.2,16.33 193.2,19 193.02,19.18 192.21,19.18 192.01,18.98 192.01,18.16 191.98,18.14 189.36,18.14 189.26,18.24 189.26,18.9 189.16,19 188.53,19 188.4,18.87 188.4,18.16 188.34,18.1 188.23,18.1 188.22,18.09 185.68,18.09 185.48,18.29 185.48,18.85 185.17,19.15 184.59,19.15 184.46,19.03 184.46,18.09 184.39,18.01 182.43,18.01 182.3,18.14 181.57,18.14 181.46,18.24 181.46,20.17 181.16,20.48 177.88,20.48 177.65,20.25 177.65,15.4 177.83,15.22 190.96,15.22 191.12,15.06 191.12,14.1 191.47,13.74 192.89,13.74 192.95,13.79
1P2V_DDR4_CH01 on TOP: 41.41,32.36 41.41,29.26 40.62,28.48 40.42,28.48 40.34,28.4 40.34,27.87 40.42,27.79 41.03,27.79 41.1,27.71 41.1,27.28 41.18,27.21 41.59,27.21 41.84,27.46 42.7,27.46 42.76,27.51 42.76,27.74 42.7,27.79 41.87,27.79 41.76,27.89 41.76,28.53 42.53,29.29 42.53,32.41 42.43,32.51 41.56,32.51
1P2V_DDR4_CH01 on BOTTOM: 179.71,20.14 179.71,16.94 179.59,16.82 178.87,16.82 178.73,16.67 178.73,15.9 178.8,15.83 179.48,15.83 179.74,16.08 180.93,16.08 181.32,16.47 181.32,18.13 181.44,18.24 183.37,18.24 183.37,18.21 183.5,18.21 183.5,17.19 183.57,17.11 184.04,17.11 184.28,16.87 185.3,16.87 185.5,16.67 185.5,14.53 185.58,14.46 190.53,14.46 190.76,14.68 190.76,16.36 191.29,16.89 191.88,16.89 192.01,17.02 192.01,18.34 192.08,18.42 193.02,18.42 193.12,18.52 193.12,18.9 192.98,19.04 188.59,19.04 187.92,18.37 185.76,18.37 184.67,19.46 181.46,19.46 181.29,19.63 181.29,20.24 181.22,20.31 179.88,20.31
1P2V_DDR4_CH01 on L03_SIG1: 197.85,87.99 200.29,87.99 201.82,89.52 210.64,89.52 210.73,89.44 218.57,89.44 228.18,79.83 243.34,79.83 244.1,79.07 244.1,63.09 243.01,62 243.01,56.01 244.1,54.92 244.1,52.56 244.56,52.1 245.52,52.1 245.69,52.26 245.69,55.48 244.57,56.6 244.57,58.43 244.89,58.75 246.43,58.75 248.2,56.98 250.06,56.98 250.33,57.25 250.33,81.95 249.56,82.73 232.82,82.73 223.75,91.81 208.24,91.81 205.84,94.21 202.16,94.21 197.54,89.59 197.54,88.29
1P2V_DDR4_CH01 on L05_SIG2: 107.88,50 110.16,50 110.41,49.74 110.41,48.12 109.91,47.62 106.13,47.62 104.67,49.09 104.67,67.4 106.54,69.27 109.33,69.27 109.53,69.07 109.53,66.73 108.93,66.13 107.79,66.13 107.44,65.77 107.44,50.44
1P2V_DDR4_CH01 on L10_PWR2: 180.81,17.24 180.37,17.67 173.44,17.67 172.33,16.56 132.51,16.56 131.98,16.03 63.18,16.03 62.41,16.79 62.41,29.01 62.64,29.24 105.7,29.24 110.35,33.88 110.35,35.82 109.55,36.61 105.61,36.61 104.5,37.72 104.5,46.76 104.96,47.22 107.09,47.22 107.17,47.15 107.55,47.15 109.84,49.43 121.11,49.43 121.18,49.36 122.42,49.36 132.94,38.84 135.15,38.84 138.17,35.81 138.17,33.46 138.79,32.84 140.82,32.84 142.44,34.46 142.44,41.6 143.88,43.04 185.37,43.04 186.12,43.78 186.12,55.33 183.41,58.04 183.41,81.9 184.69,83.18 189.77,83.18 196.03,89.45 198.66,89.45 199.08,89.03 199.08,88.42 191.6,80.93 191.6,66.65 203.91,54.34 203.91,27.88 197.69,21.67 197.69,17.79 197.14,17.24
1P2V_DDR4_CH01 on L14_SIG5: 76.97,106.38 78.75,104.6 78.75,102.57 77.59,101.41 33.14,101.41 24.14,92.41 13.09,92.41 12.45,93.04 12.45,95.71 17.15,100.41 17.15,104.22 20.84,107.9 72.65,107.9 74.18,106.38 ; 1 cut-out
1P2V_DDR4_CH01 on L16_SIG6: 18.68,99.14 20.96,99.14 21.09,99.01 21.09,93.8 21.09,93.8 21.09,79.43 23.07,77.46 27.48,77.46 43.16,61.78 43.16,52.31 49.81,45.66 49.81,38.39 45.82,34.4 45.82,25 46.41,24.42 54.82,24.42 57.28,21.95 63.61,21.95 67.02,25.36 69.75,25.36 70.16,24.95 70.16,18.47 67.9,16.21 60.98,16.21 60.37,16.82 60.37,19.59 60.24,19.71 58.26,19.71 56.3,17.75 49.72,17.75 47.72,15.75 47.72,14.15 46.63,13.06 45.73,13.06 40.29,18.5 40.29,37.79 42.68,40.18 42.68,43.66 38.25,48.09 38.25,50.81 30.23,58.83 30.23,58.95 26.15,63.04 26.15,66.81 25.03,67.93 18.3,67.93 16.64,66.28 16.64,62.31 15.76,61.42 14.23,61.42 13.47,62.18 13.47,70.31 11.82,71.96 11.82,92.28 ; 1 cut-out
1P2V_DDR4_CH01_AGND on BOTTOM: 182.68,26.19 182.68,24.97 182.76,24.89 183.83,24.89 183.98,24.74 189.24,24.74 189.54,25.05 189.54,26.19 189.77,26.42 190.38,26.42 190.46,26.49 190.46,27.03 190.38,27.1 189.31,27.1 188.32,26.11 184.67,26.11 184.36,26.42 182.91,26.42
1P2V_DDR4_CH2 on TOP: 20.9,104.94 20.97,105.02 23.11,105.02 23.26,104.86 23.26,104.03 23.79,103.49 25.01,103.49 25.09,103.57 25.09,104.18 25.17,104.25 25.24,104.25 25.32,104.18 25.32,102.44 24.86,101.98 21.44,101.98 20.9,102.51
1P2V_DDR4_CH2 on TOP: 205.18,102.02 205.59,101.6 206.61,101.6 206.88,101.88 206.88,102.86 207.44,103.41 209.61,103.41 210.09,102.93 210.8,102.93 211.36,103.49 213.11,103.49 213.83,102.77 214.56,102.77 215.3,103.51 216.22,103.51 216.91,102.81 218.23,102.81 218.36,102.95 218.36,104.7 218.01,105.06 204.93,105.06 204.93,105.06 204.17,105.06 203.53,104.42 203.53,102.85 202.76,102.08 202.76,98.04 203.53,97.26 203.53,94.3 203.83,94 206.66,94 206.87,94.22 206.87,95.12 206.82,95.17 204.8,95.17 204.16,95.8 204.16,98.09 203.83,98.42 203.83,101.56 204.29,102.02
1P2V_DDR4_CH2 on BOTTOM: 20.24,108.74 20.24,108.46 20.02,108.24 20.02,105.21 21.27,103.96 22.86,103.96 22.99,104.09 22.99,104.95 22.87,105.07 21.49,105.07 20.45,106.12 20.45,107.59 20.76,107.9 21.08,107.9 21.2,108.02 21.2,108.67 21.03,108.85 20.35,108.85
1P2V_DDR4_CH2 on BOTTOM: 97.57,32.03 97.57,33.73 97.34,33.96 96.04,33.96 95.74,33.66 95.74,32.33 96.48,31.59 97.14,31.59 97.87,30.87 97.87,30.3 97.99,30.18 100.36,30.18 100.54,30.36 100.54,30.69 100.39,30.84 98.76,30.84
1P2V_DDR4_CH2 on BOTTOM: 205.29,106.92 205.29,105.38 203.82,103.91 203.82,103.08 202.82,102.08 202.82,98.34 203.54,97.62 203.54,94.32 203.7,94.16 206.68,94.16 206.96,94.44 206.96,95.04 206.8,95.2 204.36,95.2 204.11,95.45 204.11,98.05 203.69,98.47 203.69,101.12 204.27,101.69 205.62,101.69 205.86,101.45 206.71,101.45 206.71,101.45 206.86,101.45 207.06,101.66 207.06,104.89 207.22,105.05 208.46,105.05 208.67,104.84 208.67,103.51 208.79,103.39 209.68,103.39 209.95,103.11 209.95,102.88 210.08,102.75 210.64,102.75 210.75,102.87 210.75,104.91 210.99,105.15 212.26,105.15 212.51,104.9 212.51,103.48 212.63,103.36 213.56,103.36 213.78,103.14 213.78,102.83 213.89,102.72 214.4,102.72 214.55,102.87 214.55,104.88 214.78,105.11 216.11,105.11 216.3,104.92 216.3,103.4 216.36,103.35 217.37,103.35 217.57,103.15 217.57,102.9 217.74,102.73 218.28,102.73 218.42,102.87 218.42,106.75 217.93,107.24 205.6,107.24
1P2V_DDR4_CH2 on BOTTOM: 189.47,92.48 190.23,92.48 190.38,92.64 190.38,93.32 190.08,93.63 190.08,96.75 189.85,96.98 189.24,96.98 189.08,97.13 189.08,97.59 189.31,97.82 190.53,97.82 190.68,97.67 190.68,94.54 190.76,94.47 193.35,94.47 193.5,94.31 193.5,92.79 193.35,92.64 192.67,92.64 192.21,92.18 190.38,92.18 190.3,92.1 189.54,92.1 189.39,92.26 189.39,92.41
1P2V_DDR4_CH2 on L03_SIG1: 109.56,67.64 112.17,70.24 112.17,70.33 111.37,71.12 106.89,71.12 105.41,69.64 102.44,69.64 100.54,67.74 100.54,44.76 108.85,36.45 108.85,35.54 109.28,35.11 113.16,35.11 113.98,35.92 113.98,40.92 113.01,41.89 109.18,41.89 102.62,48.44 102.62,55.93 104.08,57.39 104.08,63.39 108.34,67.64
1P2V_DDR4_CH2 on L07_SIG3: 72.63,102.56 86.26,102.56 92.37,96.45 96.63,96.45 96.88,96.19 96.88,90.45 96.63,90.2 61.22,90.2 55.59,95.83 55.59,99.74 58.28,102.43 72.5,102.43 ; 2 cut-outs
1P2V_DDR4_CH2 on L09_PWR1: 107.77,86.84 107.77,80.15 110.67,77.24 110.67,70.23 111.21,69.7 123.1,69.7 123.32,69.93 123.32,89.2 126.46,92.34 183.66,92.34 184.82,93.5 188.2,93.5 194.87,100.17 194.87,100.17 195.22,100.52 203.11,100.52 204,101.41 206.52,101.41 206.77,101.66 206.77,102.68 206.94,102.86 217.98,102.86 218.12,103 218.12,105.57 217.66,106.02 204.53,106.02 204.48,105.98 204.27,106.2 204.27,106.2 203.04,107.42 198.94,107.42 197.95,106.43 90.11,106.43 89.97,106.29 89.97,106.12 89.98,106.11 89.98,94.12 96.06,88.04 106.57,88.04
1P2V_DDR4_CH2 on L10_PWR2: 95.14,31.85 97.5,34.2 103.08,34.2 105.13,36.25 109.52,36.25 109.99,35.78 109.99,34.03 105.58,29.62 95.71,29.62 95.14,30.19
1P2V_DDR4_CH2 on L12_SIG4: 21.13,105.14 21.13,103.81 22.96,101.98 23.04,101.98 27.31,97.71 59.39,97.71 61.17,99.48 70.3,99.48 71.35,100.53 73.13,100.53 75.26,98.39 89.82,98.39 90.87,99.45 90.87,104.94 90.59,105.21 89.8,105.21 88.57,103.98 27.14,103.98 25.74,105.38 21.37,105.38
1P2V_DDR4_CH2 on L16_SIG6: 93.17,92.31 94.7,92.31 107.3,79.7 116.39,79.7 116.77,79.32 116.77,72.72 113.66,69.62 110.12,69.62 109.86,69.36 109.86,69.35 108.21,67.71 102.57,67.71 101.55,68.73 101.55,70.66 100.48,71.73 100.48,80.54 92.03,88.99 92.03,91.17
1P2V_PRE on BOTTOM: 21.83,61.93 22.21,61.55 22.61,61.55 22.94,61.22 22.94,60.68 23.07,60.56 25.82,60.56 26.18,60.2 26.18,59.13 26.43,58.87 27.9,58.87 27.91,58.86 28.36,58.86 29.03,59.53 29.03,61.04 29.97,61.99 29.97,62.64 29.57,63.04 28.91,63.04 27.95,62.08 26.61,62.08 26.19,62.49 26.19,65.56 26.38,65.75 25.99,66.14 21.95,66.14 21.83,66.02
1P2V_PRE on BOTTOM: 20.73,32.36 21.6,32.36 21.75,32.21 21.75,31.52 21.83,31.45 23.04,31.45 23.12,31.52 23.12,32.82 22.89,33.05 21.7,33.05 21.27,33.48 20.78,33.48 20.6,33.3 20.6,32.5
1P2V_PRE on L12_SIG4: 25.79,38.92 25.79,61.47 24.8,62.46 19.01,62.46 18.02,61.47 18.02,48.69 14.42,45.1 14.42,38.39 20.61,32.21 21.29,32.21 21.52,32.44 21.52,33.73 20.07,35.18 20.07,36.1 20.99,37.01 23.88,37.01
1P2V_PRE on L16_SIG6: 23.27,22.68 32.49,22.68 32.8,22.99 32.8,29.92 32.33,30.39 29.9,30.39 28.88,31.41 28.88,34.77 28.32,35.33 20.3,35.33 19.84,35.79 19.01,35.79 18.78,35.56 18.78,33.89 22.21,30.46 22.21,23.75
1P8V on TOP: 64.6,56.09 64.73,55.96 64.73,52.76 64.88,52.61 66.48,52.61 66.5,52.63 66.5,55.88 66.68,56.06 67.09,56.06 67.32,55.83 67.32,54.97 67.49,54.79 68.51,54.79 68.61,54.69 68.61,52.86 68.76,52.71 70.31,52.71 70.39,52.78 70.39,53.55 70.44,53.6 71.13,53.6 71.41,53.88 71.41,54.77 71.48,54.84 72.22,54.84 72.42,54.64 72.42,52.83 72.55,52.71 74.05,52.71 74.2,52.86 74.2,53.55 74.3,53.65 74.99,53.65 75.27,53.93 75.27,54.87 75.95,54.87 76.26,54.56 76.26,52.58 77.08,51.76 77.08,49.68 77.67,49.09 79.36,49.09 79.68,49.41 79.68,52.3 79.42,52.57 79.42,59.44 81.82,61.85 84.02,61.85 84.87,61 84.87,58.16 84.16,57.46 82.27,57.46 81.75,56.94 81.75,54.11 81.89,53.97 83.99,53.97 84.41,53.56 84.41,51.78 84.29,51.67 82.1,51.67 81.79,51.35 81.79,49.03 81.81,49.05 81.81,44.91 80.91,44.01 80.91,44.07 80.3,43.46 66.57,43.46 62.85,47.18 62.85,55.51 63.43,56.09
1P8V on BOTTOM: 84.62,69.64 85.82,69.64 85.99,69.8 85.99,70.56 85.86,70.69 84.59,70.69 84.46,70.56 84.46,69.8
1P8V on BOTTOM: 84.21,61.8 84.21,56.72 84.59,56.34 84.59,54.31 84.72,54.18 84.72,44.15 84.28,43.71 77.52,43.71 76.36,44.87 76.36,48.42 80.1,52.16 80.08,52.16 80.4,52.48 80.4,59.13 81.87,60.61 81.87,61.34 81.9,61.37 81.9,62.23 82,62.33 83.67,62.33
1P8V on L05_SIG2: 88.02,38.56 97.12,38.56 102.54,43.98 103.43,43.98 104.62,42.79 108.95,42.79 111.54,45.38 118.83,45.38 119.39,45.94 119.39,51.01 118.88,51.51 113.16,51.51 112.63,50.98 112.63,49.77 111.98,49.12 111.31,49.12 110.93,48.74 110.93,48.04 110.28,47.4 106.04,47.4 104.28,49.16 104.28,67.65 106.2,69.57 113.27,69.57 113.72,69.12 113.72,67.54 113.88,67.39 119.51,67.39 120.15,68.02 120.15,70.87 119.62,71.4 119.39,71.4 118.83,71.96 118.52,71.96 118.14,72.34 117.56,72.34 117,72.9 116.29,72.9 115.16,74.03 115.16,75.17 111.89,78.44 88.78,78.44 88.27,77.93 88.27,71.61 87.36,70.69 82.81,70.69 81.92,69.8 81.92,64.72 76.59,59.39 76.59,44.78 79.51,41.86 84.72,41.86
1P8V on L07_SIG3: 63.6,56.25 63.6,52.36 64.27,51.69 76.63,51.69 82.08,57.14 84.4,57.14 84.94,57.69 84.94,61.04 84.28,61.7 81.65,61.7 76.14,56.19 63.66,56.19
1P8V on L14_SIG5: 80.59,62.98 82.68,62.98 84.29,61.36 84.29,60.92 83.8,60.43 83.48,60.43 74.9,51.85 64.21,51.85 63.69,52.37 63.69,56.89 65.17,58.37 65.91,58.37 65.91,57.14 67.21,57.14 67.21,58.37 75.98,58.37
1P8V_AGND on TOP: 65.18,59.79 65.33,59.94 66.02,59.94 66.4,60.32 66.4,60.71 67.01,61.32 69.6,61.32 70.59,60.33 71.13,60.33 71.36,60.56 71.36,62.16 71.13,62.39 64.42,62.39 63.58,61.55 63.58,59.87 63.66,59.79
1P8V_AGND on L07_SIG3: 65.18,59.79 65.34,59.95 65.34,60.03 66.45,60.03 67.41,60.99 69.93,60.99 70.59,60.33 71.13,60.33 71.72,60.92 71.72,62.24 71.58,62.39 64.42,62.39 63.58,61.55 63.58,59.87 63.66,59.79
1P8V_FLTR on BOTTOM: 84.76,72.34 86.37,72.34 86.65,72.62 86.65,73.66 87.66,73.66 87.67,73.64 87.67,72.5 87.26,72.09 87.26,69.29 86.37,69.29 86.24,69.42 86.24,70.82 85.87,71.19 84.65,71.19 84.65,72.23
1P8V_FLTR on L05_SIG2: 85.35,40.46 84.46,41.35 79.38,41.35 76.08,44.66 76.08,59.39 81.29,64.59 81.29,70.06 82.43,71.2 87.05,71.2 87.38,71.53 87.38,73.23 87.13,73.48 79.48,73.48 79.05,73.05 79.05,65.66 75.19,61.8 75.19,61.78 73.72,60.3 73.72,42.19 76.16,39.75 78.67,39.75 78.75,39.83 84.08,39.83 84.34,39.58 84.84,39.58 85.35,40.08
1P8V_FLTR on L07_SIG3: 107.32,71.22 107.32,68.28 106.81,67.77 104.15,67.77 102.88,69.04 86.11,69.04 85.86,69.29 85.86,72.44 86.14,72.44 86.82,73.13 94.29,73.13 95.89,71.53 107.02,71.53
1P8V_FLTR on L12_SIG4: 123.32,48.34 120.68,48.34 118.37,50.65 110.83,50.65 110.16,49.99 109.07,49.99 108.25,50.8 100.27,50.8 99.46,50 99.46,49.79 99.21,49.53 95.94,49.53 94.33,47.92 90.44,47.92 87.08,44.55 87.08,43.34 84.44,40.69 84.44,40.01 84.61,39.83 92.16,39.83 99.63,47.3 112.76,47.3 113.34,47.88 114.21,47.88 115.7,46.38 121.62,46.38 122.18,46.94 123.45,46.94 123.83,47.32 123.83,47.83
1P8V_PRE on TOP: 9.45,40.93 9.56,40.82 10.24,40.82 10.55,40.52 10.55,39.91 10.72,39.73 11.89,39.73 12.16,40.01 12.16,40.29 12.34,40.48 13.62,40.48 13.94,40.79 13.94,43.14 13.72,43.36 9.58,43.36 9.45,43.23
1P8V_PRE on BOTTOM: 11.59,39.02 12.07,39.02 12.07,39.65 12.48,40.06 12.48,40.08 13.27,40.08 14.18,41 14.18,42.01 12,44.2 10.34,44.2 9.35,43.21 9.35,41.25
1P8V_PRE on L03_SIG1: 35.01,28.1 35.01,22.84 35.24,22.61 35.92,22.61 36,22.68 36,28.02 35.77,28.25 35.16,28.25
1P8V_PRE on L16_SIG6: 15.5,41.99 14,43.49 9.48,43.49 9.25,43.26 9.25,40.13 10.04,39.35 10.04,36.53 8.14,34.62 8.14,28.86 4.33,25.05 3,25.05 1.25,23.29 1.25,16.74 3.82,14.18 36.25,14.18 36.28,14.15 37.75,14.15 39.28,15.67 39.28,29.77 38.67,30.38 33.33,30.38 33.07,30.11 33.07,22.27 32.09,21.29 28.07,21.29 27.44,20.65 19.95,20.65 18.68,21.92 18.68,33.99 18.71,34.03 15.5,37.24
1P8V_SI52204 on BOTTOM (solid shape): 44.08,43.26 44.08,41.73 43.95,41.61 42.55,41.61 42.43,41.73 42.43,43.39 43.95,43.39
1P8V_SI52204 on L12_SIG4: 42.3,34.75 52.46,34.75 52.71,35 52.71,42.75 52.46,43 42.3,43 42.04,42.75 42.04,35
1P8V_VCCCLK_GXF on BOTTOM: 84.72,60.78 85.73,60.78 86.24,61.29 87.13,61.29 87.31,61.47 87.31,64.65 86.29,64.65 86.15,64.51 86.15,63.62 85.92,63.39 84.72,63.39
1P8V_VCCCLK_GXF on L12_SIG4: 85.48,62.05 86.62,62.05 87,62.44 87,63.45 87.64,64.09 97.29,64.09 98.05,64.85 101.1,64.85 101.35,65.1 102.5,65.1 103,65.61 103,65.99 102.62,66.37 85.35,66.37 84.84,65.86 84.84,62.69
1P8V_VCCH_GXR on BOTTOM: 87.21,51.1 87.05,51.26 85.68,51.26 85.22,50.8 85.22,44.78 85.61,44.4 87,44.4 87.21,44.61
1P8V_VCCH_GXR on L07_SIG3: 103.89,52.91 100.33,52.91 98.9,54.35 83.14,54.35 82.53,53.74 82.53,52.8 82.5,52.8 82.5,47.42 82.51,47.4 82.51,47.11 83.19,46.43 86.37,46.43 87.89,44.91 88.27,44.91 89.03,44.15 97.67,44.15 102.24,48.72 103.26,48.72 104.27,49.74 104.27,52.53
1P8V_VCCH_GXR on L16_SIG6: 101.73,52.28 103.69,52.28 103.94,52.02 123.58,52.02 125.36,50.24 129.29,50.24 130.82,51.77 130.82,53.16 129.34,54.65 129.34,55.03 128.4,55.96 128.4,59.77 128.79,60.15 131.2,60.15 131.58,59.77 131.58,56.34 134.5,53.42 134.5,49.1 131.96,46.56 123.58,46.56 121.93,48.21 102.24,48.21 101.48,48.97 101.48,52.02
2P5V on TOP: 207.64,14.34 208.78,14.34 209.1,14.66 209.1,18.44 208.97,18.57 206.99,18.57 205.59,17.17 205.59,16.72 207.36,14.95 207.36,14.62
2P5V on BOTTOM: 214.26,67.64 214.26,68.4 214.13,68.53 213.11,68.53 212.99,68.4 212.99,67.64 213.11,67.52 214.13,67.52
2P5V on BOTTOM: 77.3,24.87 79.02,24.87 80.25,23.64 80.25,16.4 81.75,14.9 134.15,14.9 135.38,16.13 159.54,16.13 160.08,16.66 160.08,22.73 161.15,23.8 165.15,23.8 165.5,24.15 165.5,29.37 165.21,29.66 158.27,29.66 157.57,28.96 155.63,28.96 154.63,29.96 134.65,29.96 134.21,29.52 121.95,29.52 121.01,30.46 111.03,30.46 110.09,29.52 94.4,29.52 93.8,30.12 77.33,30.12 76.74,29.53 76.74,25.43 ; 2 cut-outs
2P5V on BOTTOM: 205.2,16.62 205.2,15.84 207.25,13.79 209.33,13.79 209.46,13.92 209.46,18.18 209.15,18.5 207.08,18.5 205.2,16.62
2P5V on L03_SIG1: 169.67,17.18 169.67,22.23 171.35,23.91 194.33,23.91 195.22,23.02 195.22,22.98 196.69,21.51 205.37,21.51 205.41,21.47 207.11,21.47 207.72,20.86 207.72,17.73 206.69,16.7 204.85,16.7 201.93,19.61 201.41,19.61 199.58,17.79 173.26,17.79 172.36,16.89 169.95,16.89
2P5V on L05_SIG2: 56.9,40.21 57.06,40.37 57.06,46.91 60.93,50.78 60.93,66.08 61.45,66.6 61.45,69.78 64.57,72.9 73.11,72.9 73.49,73.28 73.49,77.63 71.53,79.59 67.35,79.59 66.17,80.76 66.17,106.25 66.49,106.57 72,106.57 72.95,105.62 72.95,102.11 72.58,101.75 71.36,101.75 71.12,101.51 71.12,100.04 71.51,99.65 76.97,99.65 78.05,98.57 78.05,95.95 78.62,95.38 78.62,88.75 78.48,88.61 78.48,66.77 72.65,60.94 72.65,47.68 64.87,39.89 64.87,36.21 67.09,33.98 67.09,33.45 70.19,30.36 78.37,30.36 79.51,29.22 79.51,27.97 79.32,27.78 68.72,27.78 67.97,27.04 67.97,26.25 67.42,25.7 61.4,25.7 60.51,24.8 60.51,22.73 60.26,22.48 58.89,22.48 56.9,24.47
2P5V on L07_SIG3: 218.83,61.55 218.19,60.91 217.22,60.91 216.66,61.47 216.66,62.95 216.63,62.98 216.63,64.21 212.86,67.98 212.86,68.24 212.41,68.69 209.18,68.69 206.54,66.05 204.67,66.05 204.57,66.15 204.57,67.52 204.82,67.77 206.29,67.77 208.32,69.8 216.02,69.8 218.83,67
2P5V on L09_PWR1: 74.82,18.3 74.82,17.42 74.97,17.28 85.6,17.28 85.92,17.6 85.92,18.15 85.63,18.45 74.96,18.45
2P5V on L09_PWR1: 169.55,17.35 169.55,18.2 169.98,18.63 206.01,18.63 206.68,17.96 206.68,16.9 206.35,16.57 169.98,16.57 169.51,17.04 169.51,17.31
2P5V on L10_PWR2: 202.88,65.56 204.33,67 205.28,67 210.51,61.77 210.51,19.04 208.07,16.59 199.57,16.59 198.27,17.89 198.27,21.21 204.42,27.36 204.42,55.1 196.29,63.24 196.29,64.09 196.76,64.56 201.95,64.56 202.88,65.49
2P5V on L10_PWR2: 74.85,106.6 74.78,106.66 66.78,106.66 66.71,106.58 66.71,101.17 67.39,100.49 67.39,98.12 69.6,95.91 69.6,93.35 70.67,92.28 72.8,92.28 74.25,93.73 74.25,97.51 77.53,100.79 105.11,100.79 105.49,101.17 105.49,105.95 104.84,106.6
2P5V on L14_SIG5: 160.61,18.3 166.11,18.3 165.95,18.15 170.17,18.15 170.64,17.69 170.64,16.62 170.52,16.51 168.68,16.51 168.4,16.22 163.72,16.22 163.7,16.24 138.22,16.24 138.02,16.45 138.02,17.82 138.18,17.98 139.89,17.98 140.24,18.33 148.99,18.33 149.35,17.97 149.48,17.97 149.49,17.99 150.09,17.99 150.36,18.26 160.61,18.26
2P5V_AGND on BOTTOM: 201.58,14.23 202.04,13.77 205.77,13.77 205.92,13.92 205.92,14.23 205.7,14.46 203.46,14.46 203.14,14.78 203.14,15.56 202.98,15.72 201.67,15.72 201.58,15.63
2P5V_PRE on TOP: 32.57,43.49 32.57,41.43 32.87,41.13 33.33,41.13 33.56,40.9 33.56,40.44 33.89,40.11 34.91,40.11 35.31,40.52 35.31,43.26 34.93,43.64 32.72,43.64
2P5V_PRE on BOTTOM: 34.55,39.45 35.31,39.45 35.31,43.41 35.62,43.72 36.84,43.72 36.89,43.77 36.89,45.52 36.74,45.67 34.78,45.67 32.57,43.46 32.57,41.43
2P5V_PRE on L12_SIG4: 20.61,36.17 20.61,35.05 21.2,34.46 24.91,34.46 25.79,35.33 27.39,35.33 33.33,41.28 33.33,42.27 33.1,42.5 31.58,42.5 25.79,36.71 21.14,36.71
2P5V_SI53254_2 on BOTTOM: 212.48,67.64 212.48,68.4 212.38,68.51 210.57,68.51 210.5,68.43 210.5,67.34 210.19,67.03 210.19,66.04 210.27,65.97 210.42,65.97 210.5,66.04 210.5,66.88 210.8,67.19 210.95,67.19 211.18,67.41 212.25,67.41
2P5V_SI53254_2 on L07_SIG3: 213.52,58.37 207.61,58.37 205.04,60.95 205.04,65.13 205.69,65.78 208.76,65.78 211.25,68.28 212.22,68.28 212.48,68.02 212.48,64.59 214.64,62.44 214.64,59.49
3P3V on BOTTOM (solid shape): 39.43,83.37 36.03,83.37 36.03,85.47 39.43,85.47
3P3V on BOTTOM (solid shape): 42.04,87.2 42.04,83.77 41.66,83.39 36.46,83.39 36.08,83.77 36.08,86.16 36,86.24 35.02,86.24 34.35,86.63 33.68,86.24 33.26,86.24 33.15,86.13 33.15,84.66 32.92,84.66 32.92,85.41 32.91,85.45 32.9,85.55 32.9,85.62 32.87,85.69 32.87,86.16 32.8,86.24 31.43,86.24 31.35,86.16 31.35,82.12 31.31,82.12 31.31,81.74 31.28,81.67 31.21,81.65 31.13,81.66 31.06,81.66 30.91,81.65 30.76,81.6 30.74,81.59 30.59,81.74 30.59,82.97 30.68,83.07 30.71,83.19 30.71,83.7 30.68,83.82 30.59,83.92 30.59,84.01 30.68,84.1 30.71,84.22 30.71,84.73 30.68,84.86 30.59,84.95 30.59,87.07 30.97,87.45 41.79,87.45
3P3V on TOP: 24.61,106.79 24.78,106.79 24.84,106.85 24.84,107.76 23.57,109.03 23.57,109.66 23.51,109.72 23.16,109.72 23.11,109.66 23.11,108.14 23.18,108.06 23.74,108.06 23.78,108.03 23.78,107.98 24.56,107.2 24.56,106.85
3P3V on TOP: 203.08,110.06 55.38,110.06 55,109.68 55,107.65 55.38,107.27 60.21,107.27 61.35,106.12 65.28,106.12 65.67,106.5 129.12,106.5 130.79,108.18 196.87,108.18 198.18,106.87 198.18,99.32 199.04,98.46 202.05,98.46 202.43,98.83 202.43,102.26 203.19,103.02 203.19,106.33 203.33,106.47 203.33,109.81
3P3V on TOP: 195.84,67.8 195.84,66.75 195.99,66.6 197.8,66.6 197.82,66.58 197.82,65.61 197.8,65.59 194.62,65.59 194.6,65.61 193.79,65.61 193.62,65.78 193.62,66.9 193.7,66.97 194.19,66.97 194.6,67.39 194.6,67.86 194.6,67.87 195.76,67.87
3P3V on TOP: 188.04,68 189.03,68 189.08,67.95 189.08,66.78 189.21,66.65 190.91,66.65 190.99,66.58 190.99,65.66 190.94,65.61 188.45,65.61 187.56,66.5 186.82,66.5 186.77,66.55 186.77,67.08 186.87,67.19 187.81,67.19 187.9,67.27 187.9,67.86
3P3V on TOP: 236.6,49.62 235.8,50.42 230.99,50.42 230,49.43 230,48.97 229.93,48.9 228.86,48.9 228.71,49.05 228.71,50.42 228.56,50.57 228.56,56.37 228.68,56.49 237.95,56.49 238.16,56.29 238.16,50.73 237.93,50.5 237.93,49.2 237.85,49.13 236.71,49.13 236.6,49.24
3P3V on BOTTOM: 237.52,49.51 229.29,49.51 228.89,49.91 228.89,56.26 229.12,56.49 237.57,56.49 237.85,56.21 237.85,49.84
3P3V on BOTTOM: 184.28,92.79 185.5,92.79 185.96,93.25 185.96,94.08 186.04,94.16 186.72,94.16 186.8,94.08 186.8,93.17 186.95,93.02 187.03,93.02 187.1,92.94 187.1,92.71 187.03,92.64 186.11,92.64 185.81,92.33 184.28,92.33 184.21,92.41 184.21,92.71
3P3V on BOTTOM: 55.38,108.03 58.81,108.03 59.06,108.28 59.06,109.3 58.81,109.55 55.38,109.55 55,109.17 55,108.41
3P3V on BOTTOM: 176.65,42.11 176.83,41.94 177.35,41.94 177.43,42.01 177.43,43.36 178.97,43.36 179.21,43.6 179.21,44.27 177.14,46.34 176.79,46.34 176.65,46.21
3P3V on L05_SIG2: 202.5,20.13 202.5,20.72 200.85,22.38 193.91,22.38 190.03,18.5 184.97,18.5 182.96,20.51 182.96,22.15 183.23,22.42 183.23,26.5 176.61,26.5 176.28,26.83 176.28,37.47 177.12,38.31 188.25,38.31 189.6,36.96 189.6,34.71 193.17,31.14 197.89,31.14 202.77,26.26 206.14,26.26 207.48,27.61 212.66,27.61 213.57,26.7 213.57,20.55 213.09,20.07 202.57,20.07
3P3V on L09_PWR1: 202.26,99.51 204.1,97.67 204.1,69.55 204.48,69.17 226.58,69.17 227.72,68.02 227.72,58.37 229.29,56.8 236.25,56.8 237.6,55.45 237.6,50.7 233.42,46.52 233.42,40.38 233.43,40.36 233.43,36.1 229.55,32.21 215.3,32.21 214.08,30.99 214.08,24.09 208.73,18.75 47.31,18.75 45.84,17.28 45.83,17.3 45.83,17.27 43.01,14.46 21.26,14.46 20.87,14.84 20.87,17.23 21.17,17.52 38.15,17.52 40.34,19.71 40.34,35.57 39.45,36.46 30.2,36.46 29.69,36.97 29.69,44.35 25.38,48.66 25.38,61.2 21.73,64.84 21.73,78.11 27.14,83.51 35.62,83.51 36.15,84.04 36.15,86.97 36.47,87.3 41.99,87.3 42.03,87.26 42.92,87.26 43.34,86.84 43.34,51.45 54.34,40.45 77.89,40.45 82.73,35.61 108.84,35.61 109.79,34.66 109.79,31.89 110.32,31.35 158.58,31.35 171.18,43.94 171.18,53.4 171.75,53.98 176.08,53.98 176.4,54.3 176.4,56.22 175.76,56.86 175.76,57.68 176.1,58.01 177.89,58.01 178.86,58.99 178.86,70.38 177.03,72.22 171.58,72.22 171.05,72.75 171.05,91.37 171.56,91.87 183.9,91.87 185.04,93.02 188.44,93.02 194.94,99.51
