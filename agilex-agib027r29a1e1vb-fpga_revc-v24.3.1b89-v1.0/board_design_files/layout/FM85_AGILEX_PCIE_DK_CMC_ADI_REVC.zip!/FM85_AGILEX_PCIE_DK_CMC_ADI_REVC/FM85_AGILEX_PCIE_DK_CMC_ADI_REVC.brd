# Allegro board FM85_AGILEX_PCIE_DK_CMC_ADI_REVC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_DIMM2_SA0: length 1.6
  TOP w0.149: J1.139 v1(73.39,98.26)
  BOTTOM w0.149: R1068.1 73.48,98.18 v1(73.39,98.26) 73.35,98.31 R84.2
DDR4_DIMM2_SA1: length 2.1
  TOP w0.149: J1.140 v1(72.54,99.34)
  BOTTOM w0.149: R1069.1 72.56,99.32 v1(72.54,99.34) 72.59,99.39 R85.2
DDR4_DIMM2_SA2:
  vias: v1(111.64,93.34)
DDR4_DIMM2_SAVE_N: length 38.9
  L03_SIG1 w0.081: v1(118.44,93.34) 118.44,94.98 117.16,96.26 117.16,102.9 117.19,102.92 117.19,103.67 115.68,105.18 114.47,105.18 114.17,105.49 114.17,105.48 113.18,105.48 112.96,105.7 111.78,105.7 111.22,105.14 102.58,105.14 101.95,104.51 101.24,104.51 100.69,103.95 93.54,103.95 v1(92.67,104.83)
  BOTTOM w0.149: v1(92.67,104.83) 92.96,104.53 U12.12
DDR4_DIMM_SCL: length 121.3
  L05_SIG2 w0.081: v1(71.69,99.34) 72.89,100.54 78.17,100.54 78.89,99.82 78.89,85.77 77.78,84.66 77.78,79.77 78.75,78.81 78.75,66.86 77.81,65.92 77.5,65.92 72.58,61 72.58,43.56 72.28,43.25 72.28,41.42 74,39.7 74,32.57 73.65,32.22 67.38,32.22 v1(65.6,33.99)
  L12_SIG4 w0.089: v1(91.85,104.9) 91.3,105.46 89.92,105.46 88.91,104.46 75.83,104.46 75.65,104.27 73.43,104.27 72.06,105.65 71.9,105.65 v1(71.69,105.86)
  L16_SIG6 w0.081: v1(71.69,99.34) 71.3,99.74 71.3,105.57 71.38,105.65 71.47,105.65 v1(71.69,105.86)
  BOTTOM w0.149: U29.2 64.8,34.09 64.9,33.99 v1(65.6,33.99) ; v1(91.85,104.9) 92.31,104.45 U12.11
DDR4_DIMM_SDA: length 131.3
  L05_SIG2 w0.081: v1(65.6,32.97) 66.7,31.87 73.82,31.87 74.32,32.38 74.32,39.83 73.18,40.97 73.18,43.24 72.91,43.51 72.91,52.67 72.88,52.7 72.88,60.11 73.17,60.4 73.43,60.4 73.64,60.62 73.64,60.87 79.08,66.31 79.08,78.94 78.11,79.91 78.11,84.53 79.74,86.16 79.74,99.64 77.9,101.47 72.2,101.47 v1(71.69,100.96)
  L12_SIG4 w0.089: v1(91.17,104.9) 91.66,104.41 91.66,98.89 90.58,97.81 74.38,97.81 73.4,98.79 73.4,99.58 72.01,100.96 v1(71.69,100.96) 71.69,99.87 72.07,99.5 72.07,99.02 73.07,98.02 73.07,95.83 71.69,94.45 v1(71.69,93.34)
  BOTTOM w0.149: U12.10 91.66,104.41 v1(91.17,104.9) ; U29.3 64.62,33.44 65.08,32.97 v1(65.6,32.97)
DFX_1_TOG: length 92.2
  L07_SIG3 w0.089: v1(85.87,74.27) 85.73,74.27 84.29,72.83 84.29,72.65 84.03,72.39 79.67,72.39 78.65,71.37 78.65,70.05 79.05,69.64 79.05,64.23 77.57,62.75 63.86,62.75 62.56,61.46 62.56,52.37 57.57,47.37 57.57,46.87 56.98,46.28 55.35,46.28 54.56,47.07 47.59,47.07 46.89,47.76 43.79,47.76 43.02,46.99 40.66,46.99 38.93,45.26 38.93,44.13 38.27,43.47 38.27,39.76 39.15,38.89 39.15,38.2 39.88,37.47 39.88,37.15 39.54,36.81 39.54,35.57 39.8,35.31 39.8,34.34 40.11,34.02 40.11,33.1 39.8,32.79 39.8,31.64 38.69,30.53 38.24,30.53 37.87,30.16 37.87,28.75 37.65,28.53 37.42,28.53 37.16,28.27 37.16,28.02 36.49,27.36 v1(36.49,26.9)
ED_PMBUS_ALERTN: length 277.9
  L07_SIG3 w0.089: v1(197.69,21.32) 198.09,20.93 198.81,20.93 199.55,20.19 199.55,18.86 200.44,17.98 201.99,17.98 202.56,17.41 202.89,17.41 203.29,17.82 203.71,17.82 203.94,18.05 204.3,18.05 204.68,17.68 209.02,17.68 214.23,22.89 219.19,22.89 219.41,22.66 225.72,22.66 226.03,22.98 226.03,22.98 v1(226.48,23.43) ; v1(175.12,55.84) 175.12,55.84 175.12,55.54 174.93,55.35 174.93,55.25 174.65,54.97 173.98,54.97 172.23,53.23 169.1,53.23 162.2,60.13 162.2,83.15 v1(167.07,88.02) ; v1(226.02,38.01) 224.68,39.36 224.68,45.02 226.45,46.8 240.1,46.8 240.45,46.44 241.92,46.44 243.06,47.58 243.06,47.98 244.55,49.47 245.41,49.47 248.14,52.2 248.14,66.4 250.3,68.55 250.3,98.42 242.85,105.87 236.08,105.87 233.9,108.05 197.22,108.05 194.41,105.24 194.41,104.75 193.95,104.29 v1(193.28,104.29)
  L16_SIG6 w0.081: v1(193.28,104.29) 192.94,103.95 184.88,103.95 183.44,102.51 183.44,99.51 183.44,99.51 183.44,98.13 175.99,90.68 175.46,90.68 175.28,90.5 173.48,90.5 171,88.02 v1(167.07,88.02)
  BOTTOM w0.149: R926.1 175.12,54.22 175.12,55.84 v1(175.12,55.84) ; v1(226.48,23.43) 226.63,23.58 226.63,35.77 225.84,36.56 225.84,37.83 v1(226.02,38.01)
EXT_JTAG_TCK: length 331.8
  TOP w0.149: v2(22.27,20.01) 22.85,20.01 23,19.86 23,18.95 22.85,18.8 22.12,18.8 19.85,16.53 19.55,16.53 19.11,16.97 U38.1
  L03_SIG1 w0.081: v1(226.11,106.42) 224.96,107.58 223.67,107.58 222.58,106.49 219.02,106.49 217.19,108.31 195.08,108.31 194.24,109.15 184.45,109.15 181.98,106.69 180.64,106.69 180.01,106.06 180.01,104.35 179.49,103.83 172.98,103.83 172.46,104.35 172.46,108.01 171.74,108.72 71.79,108.72 59.79,96.72 59.79,95.91 59.71,95.83 59.16,95.83 59.08,95.75 59.08,95.57 59.16,95.49 59.71,95.49 59.79,95.41 59.79,95.24 59.71,95.16 59.16,95.16 59.08,95.08 59.08,94.9 59.16,94.82 59.71,94.82 59.79,94.74 59.79,94.57 59.71,94.49 59.16,94.49 59.08,94.41 59.08,94.23 59.16,94.15 59.71,94.15 59.79,94.07 59.79,93.9 59.71,93.82 59.16,93.82 59.08,93.74 59.08,93.56 59.16,93.48 59.71,93.48 59.79,93.4 59.79,93.23 59.71,93.15 59.16,93.15 59.08,93.06 59.08,92.89 59.16,92.81 59.71,92.81 59.79,92.73 59.79,92.56 59.71,92.48 59.16,92.48 59.08,92.39 59.08,92.22 59.16,92.14 59.71,92.14 59.79,92.06 59.79,91.89 59.71,91.8 59.16,91.8 59.08,91.72 59.08,91.55 59.16,91.47 59.71,91.47 59.79,91.39 59.79,91 59.24,90.44 46.38,90.44 46.3,90.36 46.3,89.72 46.21,89.64 46.04,89.64 45.96,89.72 45.96,90.36 45.88,90.44 45.71,90.44 45.63,90.36 45.63,89.72 45.54,89.64 45.37,89.64 45.29,89.72 45.29,90.36 45.21,90.44 45.03,90.44 44.55,89.96 44.55,83.85 42.3,81.6 42.3,62.53 42.98,61.85 42.98,52.98 42.56,52.56 42.56,51.68 42.79,51.45 42.79,45.76 44.41,44.14 44.41,43.1 44.73,42.78 44.73,40.76 43.65,39.69 43.65,36.12 44.74,35.03 44.74,32.97 44.37,32.59 44.37,30.33 46.85,27.85 46.85,23.8 47.42,23.23 47.42,20.76 47.6,20.59 47.6,20.17 47.25,19.83 47.25,18.71 44.91,16.37 44.4,16.37 43.65,15.62 40.87,15.62 40.63,15.39 39.76,15.39 39.45,15.09 33.98,15.09 32.39,16.68 29.19,16.68 27.87,18.01 27.87,18.28 27.76,18.38 27.76,18.64 v1(27.5,18.9) 27.12,18.9 26.67,19.35 26.27,19.35 26.04,19.57 25.36,19.57 24.65,20.27 23.34,20.27 22.67,19.6 20.38,19.6 20.17,19.81 20.17,20.21 20.39,20.42 21.86,20.42 v2(22.27,20.01)
  BOTTOM w0.149: R434.1 226.1,106.42 v1(226.11,106.42)
EXT_JTAG_TDI: length 335.6
  TOP w0.149: v2(16.99,19.54) 17.33,19.2 U38.8
  L03_SIG1 w0.081: v1(233.05,105.56) 232.59,105.11 226.43,105.11 224.67,106.87 223.91,106.87 222.85,105.82 218.74,105.82 216.91,107.64 194.81,107.64 193.97,108.48 184.73,108.48 182.18,105.94 181.95,105.94 181.74,105.73 181.74,103.79 181.03,103.08 170.99,103.08 169.03,105.04 169.03,107.42 168.4,108.05 74.94,108.05 68.99,102.1 66.12,102.1 60.7,96.68 60.7,94.38 60.78,94.3 61.56,94.3 61.64,94.22 61.64,94.05 61.56,93.97 60.78,93.97 60.7,93.88 60.7,93.71 60.78,93.63 61.56,93.63 61.64,93.55 61.64,93.38 61.56,93.3 60.78,93.3 60.7,93.21 60.7,93.04 60.78,92.96 61.56,92.96 61.64,92.88 61.64,92.71 61.56,92.62 60.78,92.62 60.7,92.54 60.7,90.62 59.62,89.54 47.62,89.54 46.61,88.53 46.61,83.73 45.9,83.03 45.52,83.03 43,80.5 43,62.78 43.65,62.12 43.65,52.71 43.24,52.29 43.24,51.96 43.47,51.73 43.82,51.73 44.03,51.52 44.03,49.28 46.25,47.06 46.25,43.33 45.41,42.49 45.41,41.62 45.59,41.44 45.59,35.52 46.28,34.84 46.28,32.21 46.74,31.75 46.74,31.15 48.09,29.79 48.09,21.07 48.48,20.69 48.48,20.29 48.72,20.06 48.72,19.62 48.5,19.4 48.19,19.4 47.92,19.13 47.92,17.61 45.46,15.15 44.16,15.15 43.96,14.94 41.14,14.94 40.95,14.75 40.94,14.75 40.73,14.53 29.86,14.53 v1(26.5,17.9) 26.13,17.9 25.5,18.53 25.34,18.53 25.12,18.75 25.12,19.1 24.95,19.27 23.34,19.27 23.12,19.06 23.12,18.85 23.04,18.77 22.42,18.77 22.34,18.69 22.34,17.73 22.25,17.65 22.08,17.65 22,17.73 22,18.39 21.92,18.47 21.75,18.47 21.67,18.39 21.67,17.73 21.58,17.65 21.41,17.65 21.33,17.73 21.33,18.39 21.25,18.47 17.07,18.47 16.99,18.56 v2(16.99,19.54)
  BOTTOM w0.149: v1(233.05,105.56) 233.05,101.1 234.32,99.83 J10.9
EXT_JTAG_TDO: length 334.9
  TOP w0.149: U38.11 v2(17.76,17.37) ; v2(23.42,17.25) 24.64,17.25 25.01,17.62 25.01,18.12 25.29,18.41 25.8,18.41 26.02,18.63 26.02,19.1 26.3,19.38 26.72,19.38 26.98,19.64 26.98,20.23 27.17,20.42 27.71,20.42 27.98,20.69 27.98,21.23 28.16,21.4 28.99,21.4 v1(29.5,21.9)
  L03_SIG1 w0.081: v1(219.88,106.96) 219.88,107.01 218.19,108.7 195.23,108.7 194.4,109.53 184.35,109.53 181.94,107.13 179.78,107.13 179.27,106.62 179.27,105.41 179.48,105.21 179.48,104.54 179.2,104.26 174.5,104.26 174.11,104.66 174.11,108.33 173.38,109.06 71.65,109.06 58.74,96.14 58.74,91.66 58.05,90.98 45.04,90.98 44.16,90.09 44.16,83.95 41.22,81.01 41.22,73.3 41.87,72.64 41.87,62.48 42.57,61.79 42.57,53.04 42.23,52.7 42.23,51.54 42.44,51.33 42.44,45.55 44.07,43.91 44.07,42.96 44.39,42.64 44.39,41.82 43.32,40.75 43.32,35.88 44.41,34.8 44.41,33.26 44.14,33 43.54,33 43.4,33.14 43.07,33.14 42.82,32.89 42.82,31.25 46.24,27.83 46.24,26.18 45.84,25.78 45.84,24.74 45.71,24.62 45.71,23.9 46.61,22.99 46.61,22.67 47.05,22.24 47.05,21.66 46.8,21.42 46.8,18.74 45.69,17.62 45.31,17.62 45.09,17.84 45.09,18.04 44.71,18.43 44.21,18.43 43.27,17.49 42.7,17.49 42.2,16.99 41.74,16.99 41.52,17.21 39.68,17.21 39.08,16.61 36.65,16.61 35.73,17.53 35.34,17.53 35,17.87 35,18.92 34.65,19.27 34.16,19.27 33.12,20.31 33.12,21.38 31.87,22.64 31.87,23.06 31.05,23.87 31.05,23.87 30.65,24.27 30.34,24.27 29.69,23.62 29.69,23.29 29.87,23.11 29.87,22.27 v1(29.5,21.9) ; v2(17.76,17.37) 18.52,18.14 19.76,18.14 20.64,17.25 v2(23.42,17.25)
  BOTTOM w0.149: v1(219.88,106.96) 220.65,107.72 228.55,107.72 228.88,107.4 228.88,105.92 229.08,105.71 229.19,105.71 R430.2 229.37,104.78 228,103.41 228,100.7 J10.3
EXT_JTAG_TMS: length 337.5
  TOP w0.149: U38.4 19.18,18.17 19.47,18.46 v2(19.47,18.99)
  L03_SIG1 w0.081: v1(230.51,105.56) 230.08,105.99 226.02,105.99 224.77,107.24 223.81,107.24 222.71,106.15 218.88,106.15 217.05,107.98 194.94,107.98 194.1,108.82 184.59,108.82 182.49,106.72 182.48,106.72 182.06,106.3 181.07,106.3 180.91,106.14 180.91,104.09 180.28,103.46 171.7,103.46 170.71,104.45 170.71,107.81 170.14,108.38 71.93,108.38 71.47,107.92 71.47,107.81 72.09,107.18 72.09,107.07 71.97,106.95 71.85,106.95 71.23,107.57 71.12,107.57 70.99,107.45 70.99,107.33 71.62,106.71 71.62,106.59 71.5,106.47 71.38,106.47 70.76,107.1 70.64,107.1 68.83,105.29 68.83,105.17 70.05,103.96 70.05,103.85 69.92,103.73 69.81,103.73 68.6,104.94 68.48,104.94 68.36,104.81 68.36,104.7 69.57,103.49 69.57,103.37 69.45,103.25 69.33,103.25 68.72,103.87 68.61,103.87 68.31,103.57 68.19,103.57 68.07,103.69 68.07,103.81 68.37,104.1 68.37,104.22 68.12,104.46 68.01,104.46 60.3,96.75 60.3,90.87 59.3,89.88 47.47,89.88 45.63,88.03 45.63,83.61 42.66,80.65 42.66,62.64 43.32,61.98 43.32,52.84 42.9,52.43 42.9,51.82 43.13,51.59 43.13,45.97 45.23,43.87 45.23,43 45.08,42.84 45.08,41.48 45.26,41.3 45.26,35.39 45.95,34.7 45.95,31.4 47.76,29.59 47.76,20.9 47.93,20.73 47.93,20.03 47.59,19.69 47.59,18.57 46.79,17.77 46.79,17.05 45.26,15.53 44.07,15.53 43.83,15.29 41.01,15.29 40.59,14.87 33.94,14.87 32.31,16.5 29.09,16.5 27.94,17.64 27.76,17.64 v1(27.5,17.9) 27.5,18.18 27.21,18.47 26.19,18.47 26.05,18.61 26.05,19.27 25.93,19.39 25.28,19.39 25.19,19.47 23.08,19.47 22.84,19.23 22.04,19.23 21.63,18.81 20.41,18.81 19.53,19.69 19.09,19.69 18.78,19.38 17.53,19.38 17.42,19.27 17.42,19.1 17.53,18.99 v2(19.47,18.99)
  BOTTOM w0.149: J10.5 230.51,100.67 v1(230.51,105.56)
FAN_CTRL: length 62.5
  L07_SIG3 w0.089: v1(198.69,17.52) 198.69,16.72 199.76,15.65 210.04,15.65 212.21,17.81 212.68,17.81 214.75,19.88 214.75,20.35 214.98,20.58 215.47,20.58 216.68,21.78 216.68,22.15 216.91,22.38 218.11,22.38 218.97,21.53 227.19,21.53 227.58,21.92 229.37,21.92 229.64,21.64 236.43,21.64 237.41,22.62 237.75,22.62 244.4,29.26 244.4,29.73 245.47,30.8 246.88,30.8 J9.4
  BOTTOM w0.203: J9.4 244.88,32.08 R415.1
FAN_TACH: length 66.1
  L14_SIG5 w0.081: v1(244.04,31.07) 243.44,30.47 243.44,16.32 241.88,14.76 225.05,14.76 223.34,16.47 222.85,16.47 222.34,15.96 221.82,15.96 221.58,16.19 219.58,16.19 219.47,16.3 217.35,16.3 217.24,16.19 216.24,16.19 216,15.96 215.14,15.96 212.84,13.66 208.93,13.66 207.16,15.43 199.6,15.43 v1(198.19,16.84)
  BOTTOM w0.149: U107.3 v1(198.19,16.84)
  BOTTOM w0.203: v1(244.04,31.07) 244.02,31.08 R416.1
FAULT: length 5.8
  TOP w0.149: R6256.1 R6257.1 176.31,55.41 v1(176.92,55.41) ; U119.18 v1(178.78,56.62)
  BOTTOM w0.149: R6025.1 176.97,55.46 v1(176.92,55.41) ; v1(176.92,55.41) 177.76,55.41 R6065.1 177.81,55.54 178.4,56.14 178.65,56.14 178.78,56.28 v1(178.78,56.62) ; v1(176.92,55.41) 176.9,55.44 R6258.1
FGT_AGND: length 3.1
  TOP w0.381: C806.2 v3(45.12,104.3) ; v3(40.67,105.95) 40.35,106.26 C804.2 v1(38.39,106.26)
  BOTTOM w0.203: ST9.2 v3(45.12,104.3)
FM41_14C_PCIE_PERSTN: length 73.7
  L14_SIG5 w0.081: v1(65.75,28.89) 67.44,30.58 71.35,30.58 74.38,33.62 74.38,39.65 74.98,40.25 74.98,40.36 80.46,45.84 80.92,45.84 83.83,48.75 84.06,48.75 86.31,50.99 86.31,51.35 86.58,51.62 87.06,51.62 87.29,51.85 87.29,53.32 88.44,54.47 89.03,54.47 89.24,54.27 89.91,54.27 90.12,54.47 90.76,54.47 90.93,54.3 91.63,54.3 91.8,54.47 92.5,54.47 92.66,54.3 93.36,54.3 93.53,54.47 94.23,54.47 94.39,54.3 95.1,54.3 95.26,54.47 95.96,54.47 96.13,54.3 96.83,54.3 96.99,54.47 97.5,54.47 98.05,55.02 98.05,56.54 98.8,57.29 99.33,57.29 v1(99.59,57.55)
  BOTTOM w0.149: R6324.2 55.58,14.33 55.84,14.6 R6297.1 55.84,15.02 55.99,15.17 58.89,15.17 59.13,15.41 60.51,15.41 61.36,16.25 61.36,20.65 64.54,23.83 64.54,27.68 v1(65.75,28.89)
FM41_15C_CXL_PERSTN: length 188.8
  L05_SIG2 w0.081: v1(174.72,28.35) 174.35,28.35 171.72,30.98 162.59,30.98 162.58,30.98 162.25,30.98 162.25,30.98 141.9,30.98 141.73,30.82 v1(141.73,30.21)
  L12_SIG4 w0.089: v1(126.68,67.67) 127.74,67.67 128.12,68.04 128.43,68.04 128.8,67.67 129.39,67.67 129.73,68.01 130.01,68.01 130.34,67.67 130.99,67.67 131.32,68.01 131.6,68.01 131.94,67.67 132.58,67.67 132.92,67.33 133.19,67.33 133.67,67.8 133.67,68.24 134.36,68.93 134.36,69.64 134.83,70.11 135.1,70.11 135.75,70.76 135.87,70.76 136.14,71.03 137.01,71.03 137.31,70.72 137.62,70.72 137.93,71.03 138.27,71.03 138.9,71.65 139.29,71.65 139.61,71.98 140.21,71.98 140.47,71.72 141.09,71.72 141.33,71.96 142.05,71.96 142.52,72.44 142.95,72.44 143.16,72.22 143.68,72.22 143.78,72.32 147.64,72.32 148.74,71.22 148.74,71.16 156.13,71.16 158.12,73.16 175.09,73.16 177,71.25 186.34,71.25 186.99,70.6 190.49,70.6 191.67,69.42 191.67,66.86 191.47,66.66 191.47,66.01 192.02,65.46 197.89,65.46 198.42,64.92 198.42,56.76 197.3,55.63 195.31,55.63 193.03,53.36 193.03,50.89 194.81,49.12 194.81,41.45 193.46,40.11 193.46,38.35 194.53,37.28 194.53,36.95 198.3,33.18 198.3,29.77 197.78,29.26 193.14,29.26 191.92,28.03 184.63,28.03 184.31,28.35 v1(174.72,28.35)
  BOTTOM w0.149: v1(141.73,30.21) 141.73,29.78 141.4,29.45 139.38,29.45 139.17,29.66 R6325.1 139.14,30.15 R6299.1
FPGA_3V3_LED0: length 11.6
  L03_SIG1 w0.081: v1(246,48.34) 245.86,48.19 245.86,44.51 246.61,43.77 246.61,41.52 246.6,41.51 246.6,39.88 v1(246.86,39.61)
  BOTTOM w0.149: Q7.1 246.56,39.77 246.71,39.61 v1(246.86,39.61) ; v1(246,48.34) U42.20
FPGA_3V3_LED1: length 9.6
  TOP w0.149: Q9.1 v1(246.23,41.67)
  L03_SIG1 w0.081: v1(247.3,49.61) 246.75,49.61 245.63,48.48 245.63,44.33 246.23,43.72 v1(246.23,41.67)
FPGA_3V3_LED2: length 15.1
  L03_SIG1 w0.081: v1(247.95,48.34) 247.05,47.43 247.05,47.02 247.2,46.87 247.2,40.13 247.47,39.86 247.47,36.31 v1(246.86,35.7)
  BOTTOM w0.149: v1(246.86,35.7) Q10.1
FPGA_3V3_LED3: length 14.7
  TOP w0.149: v1(246.31,37.62) 246.3,37.61 Q11.1
  L03_SIG1 w0.081: v1(246.31,37.62) 247.23,38.54 247.23,39.77 246.97,40.03 246.97,46.15 246.09,47.02 246.09,47.59 248.12,49.61 v1(248.6,49.61)
FPGA_BYPASSN: length 36.5
  L12_SIG4 w0.089: v1(34.5,30.9) 34.1,30.51 33.33,30.51 33.07,30.76 33.07,31.41 32.98,31.51 32.33,31.51 32.01,31.83 32.01,32.16 31.66,32.51 31.33,32.51 31.09,32.75 31.09,33.06 31.55,33.52 32.21,33.52 33.5,34.81 36.04,34.81 36.14,34.71 36.47,34.71 37.8,36.04 37.8,37.7 37.16,38.34 37.16,39.35 32.25,44.26 31.38,44.26 27.09,48.55 26.65,48.55 26.42,48.78 26.42,49.22 v1(25.9,49.74)
  L16_SIG6 w0.081: v1(23.7,52.5) 23.7,51.94 v1(25.9,49.74)
FPGA_CONF_DONE: length 378.5
  L07_SIG3 w0.089: v1(34.5,25.9) 34.5,25.37 33.62,24.5 32.43,24.5 31.87,25.05 31.87,26.06 31.65,26.28 31.37,26.28 30.83,26.82 30.83,27.04 30.63,27.24 30.41,27.24 29.02,28.63 29.02,31.96 28.64,32.34 28.64,33.14 29.16,33.65 29.16,34.59 29.08,34.67 28.6,34.67 28.36,34.9 28.36,35.5 28.69,35.83 28.69,38.08 28.91,38.3 29.34,38.3 29.94,38.9 29.94,39.36 30.17,39.59 31.32,39.59 32.11,40.39 32.11,43.52 31.86,43.76 31.86,51.14 32.06,51.34 32.06,52.51 39.63,60.08 39.63,62.48 45.13,67.97 51.26,67.97 64.7,81.42 66.04,81.42 68.36,83.74 73.52,83.74 78.44,88.66 88.69,88.66 89.44,87.91 98.04,87.91 104.82,81.13 104.82,79.32 105.17,78.97 v1(105.17,78.25) ; v1(246.39,45.8) 245.85,46.34 245.85,47.47 247.96,49.58 247.96,49.87 249.83,51.74 249.83,54.29 249.43,54.69 249.43,66.32 251.26,68.15 251.26,98.85 242.38,107.74 235.6,107.74 234.33,109.02 196.82,109.02 195.96,108.16 189.52,108.16 187.8,106.43 185.23,106.43 184.91,106.75 176.87,106.75 176.59,106.47 175.79,106.47 173.73,108.53 149.96,108.53 149.94,108.55 128.87,108.55 124.71,104.38 115.47,104.38 114.46,105.39 99.97,105.39 99.28,104.7 99.28,93.79 99.93,93.14 99.93,89.11 v1(106.85,82.2)
  BOTTOM w0.149: v1(105.17,78.25) 105.46,78.54 105.46,79.36 106.85,80.75 v1(106.85,82.2)
FPGA_CXL_PERSTN: length 24.9
  BOTTOM w0.149: R195.1 R196.2 137.17,35.07 137.17,35.5 137.91,36.24 137.91,37.45 137.33,38.03 137.33,38.41 137.49,38.57 137.49,38.9 137.18,39.21 136.88,39.21 136.65,39.44 136.65,40.23 136.41,40.47 136.07,40.47 135.2,41.34 134.9,41.34 133.51,42.73 133.51,43 133.17,43.34 132.89,43.34 132.65,43.58 132.65,46.79 132.66,46.8 132.66,47.13 132.5,47.3 132.5,47.56 132.66,47.72 132.66,48.05 132.49,48.22 132.49,48.47 132.66,48.64 132.66,48.97 132.31,49.32 132.09,49.32 131.85,49.56 131.85,49.89 131.87,49.91 131.87,50.35 131.63,50.59 131.3,50.59 130.73,51.16 130.5,51.16 129.87,51.79 v1(129.87,52.03)
FPGA_CXL_PRSNTX1_N:
  vias: v1(199.7,89.51)
FPGA_CXL_PRSNTX4_N:
  vias: v1(199.96,90.16)
FPGA_CXL_PRSNTX8_N: length 86.6
  L12_SIG4 w0.089: v1(166.49,73.75) 158.18,73.75 155.93,71.5 149.03,71.5 147.28,73.26 143.35,73.26 142.82,72.72 142.42,72.72 141.96,72.26 141.66,72.26 141.45,72.47 140.55,72.47 140.3,72.22 139.83,72.22 139.46,72.59 139.03,72.59 138.43,72 137.84,72 137.61,71.76 137.33,71.76 137.09,72 136.31,72 136.04,71.72 135.56,71.72 135.16,72.13 134.64,72.13 134.13,71.62 133.83,71.62 133.56,71.35 v1(133.05,71.35)
  L14_SIG5 w0.081: v1(200.26,90.81) 200.59,91.14 200.59,91.86 200.28,92.16 198.49,92.16 197.52,91.2 188.28,91.2 187.95,90.87 185.06,90.87 184.65,91.28 176.07,91.28 176.07,91.27 176.04,91.27 175.76,91 175.34,91 172.64,88.29 170.36,88.29 167.6,85.53 167.6,84.95 167.72,84.83 167.72,74.98 v1(166.49,73.75)
FPGA_CXL_PRSNTX16_N: length 92.8
  L03_SIG1 w0.081: v1(132.26,71.81) 132.26,71.8 132.64,71.42 132.64,70.34 arc(132.67,70.21) 132.74,70.1 arc(132.88,70) 133.05,69.97 134.22,69.97 arc(134.43,69.96) 134.64,69.94 arc(134.71,69.94) 134.78,69.95 arc(134.95,69.95) 135.1,69.88 arc(135.16,69.84) 135.22,69.81 arc(135.94,69.49) 136.55,69 136.56,69 arc(136.62,68.95) 136.7,68.92 arc(136.78,68.88) 136.85,68.82 136.85,68.82 arc(137.15,68.62) 137.49,68.55 arc(137.92,68.39) 138.28,68.12 138.5,67.9 138.82,67.9 138.95,67.77 139.37,67.77 139.91,67.23 140.59,67.23 140.79,67.43 141.07,67.43 141.27,67.23 142.27,67.23 142.51,67.47 143.19,67.47 143.45,67.21 145.39,67.21 145.66,67.47 146.35,67.47 146.74,67.08 149.95,67.08 150.64,67.77 150.64,69.14 151.09,69.58 155.3,69.58 156.75,68.13 166.21,68.13 arc(166.3,68.15) 166.37,68.2 arc(166.48,68.4) 166.52,68.63 166.52,72.11 166.21,72.42 v1(166.05,72.42)
  L14_SIG5 w0.081: v1(199.9,91.49) 198.53,91.49 197.91,90.87 197.91,90.27 197.38,89.74 195.65,89.74 194.95,89.05 174.06,89.05 172.73,87.72 170.45,87.72 168.07,85.34 168.07,85.14 168.2,85.01 168.2,74.39 167.36,73.54 167.17,73.54 v1(166.05,72.42)
FPGA_CXL_RSTN: length 209.2
  L03_SIG1 w0.081: v1(117.12,41.91) 118.19,41.91 118.56,42.28 118.82,42.28 119.5,42.95 119.65,42.95 119.84,43.15 119.84,43.47 120.95,44.58 121.46,44.58 121.75,44.3 122.26,44.3 122.54,44.58 123.06,44.58 123.34,44.3 123.85,44.3 124.14,44.58 124.65,44.58 124.93,44.3 125.45,44.3 125.73,44.58 126.24,44.58 126.53,44.3 127.04,44.3 127.32,44.58 127.84,44.58 128.12,44.3 128.64,44.3 128.92,44.58 129.43,44.58 129.71,44.3 130.23,44.3 130.51,44.58 131.03,44.58 131.31,44.3 131.61,44.3 131.9,44.58 132.41,44.58 132.91,44.08 133.49,44.08 134.64,42.93 135.07,42.93 135.82,42.18 135.82,36.53 138.73,33.62 138.98,33.62 141.51,31.09 141.76,31.09 v1(142.37,30.48)
  L05_SIG2 w0.081: v1(251.84,53.33) 252.25,52.92 252.25,24.33 243.75,15.83 234.59,15.83 232.72,13.96 215.99,13.96 214.26,15.68 206.31,15.68 204.91,14.29 202,14.29 201.31,14.99 196.19,14.99 195.76,15.41 195.76,16.79 197.12,18.14 197.21,18.14 197.44,18.37 197.44,19.49 198.66,20.71 198.85,20.71 199.08,20.94 199.08,21.49 198.37,22.2 195.42,22.2 194.49,21.27 194.49,18.67 192.29,16.46 182.73,16.46 179.43,19.76 176.04,19.76 171.43,24.37 171.43,28.91 169.86,30.48 v1(142.37,30.48)
  BOTTOM w0.149: U42.7 249.9,53.75 250.33,53.33 v1(251.84,53.33)
FPGA_DDIMM_EVENT_N: length 77.6
  TOP w0.149: v1(101.74,97.33) 102.54,96.53 105.52,96.53 106.45,97.47 110.31,97.47 111.15,96.63 124.87,96.63 126.4,98.16 127.39,98.16 128.08,97.46 128.08,93.35 129.58,91.85 141.32,91.85 141.81,91.36 141.81,88.4 v1(142.14,88.07)
  L07_SIG3 w0.089: v1(130.66,73.65) 131.09,74.07 131.09,74.26 131.09,76.1 131.09,80.18 129.78,81.49 129.78,84.88 130.61,85.72 130.83,85.72 134.5,89.38 141.55,89.38 141.87,89.25 142.14,88.98 v1(142.14,88.07)
FPGA_DDIMM_SAVE_N: length 45.8
  L07_SIG3 w0.089: v1(129.87,72.27) 129.47,72.67 129.47,80.43 129.08,80.82 v1(129.08,81.94)
  L16_SIG6 w0.081: v1(101.07,96.83) 103.01,96.83 106.17,93.66 106.17,93.19 106.39,92.97 107.21,92.97 108.34,91.85 114.58,91.85 115.2,91.23 119.26,91.23 119.84,90.65 121.48,90.65 123.98,88.15 125.19,88.15 128.71,84.62 128.71,84.19 128.7,84.18 128.7,82.31 v1(129.08,81.94)
FPGA_DIMM2_EVENT_N: length 33.3
  L07_SIG3 w0.089: v1(106.76,72.73) 106.77,72.73 107.22,73.18 107.22,73.33 107.42,73.53 107.57,73.53 107.93,73.89 107.93,80.23 98.44,89.72 98.44,96.14 97.38,97.2 93.87,97.2 v1(93.62,96.95)
FPGA_DIMM2_SAVE_N: length 32.4
  L07_SIG3 w0.089: v1(106.76,73.65) 106.76,73.65 107.17,74.06 107.17,80.37 97.69,89.84 97.69,96.25 97.03,96.91 94.15,96.91 93.77,96.53 93.3,96.53 93.15,96.68 93.15,96.89 92.95,97.09 v1(92.95,97.29)
FPGA_DIMM_SCL: length 62.8
  L07_SIG3 w0.089: v1(130.66,71.81) 130.66,72.2 130.29,72.57 130.29,80.31 129.49,81.1 129.49,82.26 129.14,82.62 129.14,83.14 129.34,83.35 129.34,83.38 v1(129.37,83.38)
  L16_SIG6 w0.081: v1(129.37,83.38) 129.34,83.38 129.34,83.51 129.07,83.78 129.07,85.23 128.58,85.73 125.84,88.46 124.02,88.46 121.59,90.88 119.94,90.88 119.36,91.47 115.3,91.47 114.66,92.1 108.54,92.1 104.85,95.79 v1(104.85,97.14)
  BOTTOM w0.149: v1(104.85,97.14) 104.85,95.32 104.18,94.65 99.61,94.65 97.62,96.63 96.5,96.63 95.99,96.12 95.99,95.6 95.54,95.15 92.62,95.15 92.37,95.39 R80.1 92.31,95.85 U12.4
FPGA_DIMM_SDA: length 84
  TOP w0.149: v1(141.48,88.09) 141.48,91.03 141.01,91.5 129.41,91.5 125.17,95.75 116.71,95.75 116.15,95.19 113.15,95.19 113.11,95.23 92.12,95.23 v1(91.59,95.76)
  L07_SIG3 w0.089: v1(141.48,88.09) 141.48,88.89 141.25,89.12 134.58,89.12 131.1,85.65 131.1,84.94 130.02,83.86 130.02,81.65 131.84,79.83 131.84,73.15 v1(132.26,72.73)
  BOTTOM w0.149: U12.5 v1(91.66,96.95) 91.66,95.83 v1(91.59,95.76)
FPGA_FABRIC_RESET_N: length 88.4
  L14_SIG5 w0.081: v1(251.2,47.57) 251.33,47.44 251.33,46.28 250.22,45.18 250.22,45.08 249.4,44.25 249.3,44.25 249.26,44.22 248.26,44.22 248.18,44.14 248.18,38.63 243.17,33.61 243.17,16.38 241.81,15.02 225.12,15.02 223.44,16.71 222.75,16.71 222.24,16.19 221.91,16.19 221.61,16.5 220.39,16.5 219.91,16.98 216.69,16.98 215.91,16.19 215.04,16.19 212.74,13.89 209.03,13.89 207.25,15.66 201.01,15.66 201.01,15.66 200.68,15.66 199.67,16.67 199.67,16.91 199.35,17.23 198.95,17.23 198.85,17.13 198.53,17.13 198.45,17.21 197.73,17.21 v1(197.19,16.67)
  BOTTOM w0.149: U42.12 v1(251.2,47.57) ; U107.5 v1(197.19,16.67)
FPGA_I2C1_SCL: length 96.5
  TOP w0.149: v1(29.85,101.17) 29.88,101.14 U28.2
  L05_SIG2 w0.081: v1(31.53,95.32) 30.21,96.64 30.21,100.82 v1(29.85,101.17)
  L07_SIG3 w0.089: v1(105.17,72.73) 105.17,72.96 105.56,73.35 105.56,80.89 96.96,89.49 76.93,89.49 76.7,89.71 38.9,89.71 37.92,90.69 35.39,90.69 31.53,94.55 v1(31.53,95.32)
FPGA_I2C1_SDA: length 99
  TOP w0.149: U28.3 29.23,100.9 v1(28.96,101.17)
  L05_SIG2 w0.081: v1(31.87,95.98) 30.47,97.37 30.47,101.22 30.15,101.54 29.33,101.54 v1(28.96,101.17)
  L07_SIG3 w0.089: v1(105.96,72.27) 106.34,72.65 106.34,80.65 97.25,89.74 77.28,89.74 76.83,90.19 44.3,90.19 42.83,91.66 34.94,91.66 31.87,94.73 31.87,95.13 31.9,95.16 31.9,95.47 31.87,95.51 v1(31.87,95.98)
FPGA_I2C2_EN: length 201.4
  L07_SIG3 w0.089: v1(123.47,38.23) 123.49,38.21 123.49,37.22 121.86,35.59 121.86,35.24 122.7,34.4 122.7,32.18 121.53,31 121.53,30.11 120.68,29.26 120.68,21.54 120.19,21.05 120.19,20.74 120.68,20.25 120.68,18 121.29,17.39 121.29,15.72 124.05,12.97 125.51,12.97 125.8,13.26 128.08,13.26 128.45,13.63 v1(128.92,13.63)
  L16_SIG6 w0.081: v1(15.06,59.64) 16.8,61.39 16.8,63.21 18.03,64.44 23.67,64.44 30.32,57.79 30.32,57.26 35.48,52.11 35.48,50.24 36.8,48.92 37.44,48.92 42.15,44.21 42.15,41.5 42.5,41.14 42.5,39.08 40.05,36.62 40.05,36.27 40.15,36.17 40.15,22.55 40.61,22.09 40.61,20.95 40.06,20.41 40.06,17.76 42.37,15.45 42.74,15.45 45.4,12.79 47.55,12.79 47.72,12.97 48.62,12.97 48.94,13.29 48.94,13.76 48.91,13.79 48.91,14.29 49.27,14.64 49.94,14.64 50.8,13.79 51.71,13.79 52.21,13.29 52.21,12.47 54.51,10.16 56.13,10.16 56.31,10.35 58.85,10.35 60.22,8.98 77.99,8.98 78.22,8.74 127.12,8.74 129.01,10.64 129.01,13.54 v1(128.92,13.63)
FPGA_I2C2_EN_R: length 73.8
  L12_SIG4 w0.089: v1(43.24,32.74) 41.06,32.74 40.04,31.73 40.04,31.54 38.94,30.43 36.41,30.43 36.09,30.75 36.09,30.87 35.66,31.3 33.54,31.3 33.1,31.74 33.1,31.98 32.58,32.51 32.33,32.51 32.1,32.74 32.1,33.07 33.6,34.57 35.94,34.57 36.04,34.47 36.57,34.47 38.15,36.05 38.15,38.87 34.54,42.48 34.54,43.17 33.21,44.5 32.14,44.5 29.25,47.39 29.25,51.14 28.74,51.65 28.74,53.48 30.12,54.86 30.12,56.98 29.98,57.12 29.98,57.37 28,59.35 27.64,59.35 26.27,60.72 26.27,62.16 25.56,62.87 17.4,62.87 v1(14.17,59.64)
  BOTTOM w0.149: v1(14.17,59.64) R337.2 14.04,60.53 SW4.2 ; U30.8 42.25,31.31 43.24,32.29 v1(43.24,32.74)
FPGA_I2C2_SCL: length 120.1
  L07_SIG3 w0.089: v1(121.25,12.25) 121.25,12.43 119.71,13.97 v1(119.71,16.48)
  L14_SIG5 w0.081: v1(119.71,16.48) 120.91,16.48 121.47,17.05 121.47,27.42 122.35,28.31 122.35,28.37 122.44,28.45 122.98,28.45 123.24,28.71 123.24,28.96 123.51,29.23 123.62,29.23 123.97,29.59 123.97,31.76 124.47,32.26 124.47,32.61 124.22,32.85 124.22,33.22 124.47,33.46 124.47,33.81 123.97,34.31 123.97,36.39 124.66,37.08 124.66,37.89 124.44,38.11 124.44,38.37 124.62,38.55 124.62,38.68 v1(125.09,39.15) ; v1(121.25,12.25) 120.6,11.61 120.6,10.89 118.32,8.61 68.26,8.61 63.34,13.52 63.34,14.13 59.51,17.97 58.61,17.97 57.83,18.74 57.83,18.97 57.58,19.22 57.24,19.22 57.21,19.19 55.36,19.19 52.98,21.57 52.98,22.34 52.75,22.57 52.24,22.57 51.35,23.46 51.35,24.01 51.11,24.25 50.76,24.25 50.03,23.52 48.69,23.52 48.28,23.11 47.84,23.11 47.17,22.44 45.95,22.44 45.69,22.7 45.69,23.03 45.6,23.11 45.45,23.11 v1(45.2,22.86)
  BOTTOM w0.149: U30.2 45.5,23.17 v1(45.2,22.86)
FPGA_I2C2_SDA: length 122.1
  L07_SIG3 w0.089: v1(121.9,39.15) 121.52,38.77 121.52,38.07 121.69,37.9 121.69,37.44 120.71,36.46 120.71,34.3 120.9,34.12 120.9,33.12 120.9,33.09 120.9,31.96 120.56,31.63 120.56,31.09 120.56,30.38 119.84,29.65 119.84,21.92 119.17,21.25 119.17,17 119.3,16.86 119.3,16.38 119.17,16.24 119.17,13.8 121.15,11.82 121.41,11.82 121.92,12.33 v1(122.39,12.33)
  L14_SIG5 w0.081: v1(122.39,12.33) 122.34,12.33 121.94,12.74 121.71,12.74 121.6,12.63 120.94,12.63 120,11.68 118.19,11.68 115.35,8.84 68.36,8.84 63.58,13.62 63.58,14.23 59.01,18.8 59.01,18.91 58.78,19.14 58.71,19.14 58.69,19.15 58.07,19.15 57.77,19.45 55.42,19.45 53.21,21.67 53.21,22.44 52.84,22.8 52.34,22.8 51.59,23.55 51.59,24.1 51.33,24.36 51.33,25.01 51.1,25.24 50.77,25.24 49.78,24.25 49.77,24.25 49.54,24.02 48.14,24.02 47.47,23.35 44.8,23.35 v1(44.29,22.84)
  BOTTOM w0.149: U30.3 44.85,23.19 44.5,22.84 v1(44.29,22.84)
FPGA_I2C_EN: length 164
  L14_SIG5 w0.127: v1(120.3,39.15) 120.7,38.75 120.7,22.27 120.96,22.01 120.96,19.5 120.71,19.25 120.71,18.28 arc(120.7,18.22) 120.67,18.16 120.24,17.74 arc(120.2,17.69) 120.19,17.62 v1(120.19,17.45) 120.13,17.45 arc(120.07,17.44) 120.01,17.4 119.38,16.77 arc(119.35,16.71) 119.33,16.64 119.33,16.33 119.27,16.26 arc(119.23,16.24) 119.18,16.23 117.02,16.23 116.66,15.86 74.27,15.86 72.54,17.59 72.54,25.95 71.55,26.94 66.46,26.94 64.28,29.12 64.28,35.11 66.47,37.31 66.47,39.25 arc(66.46,39.31) 66.43,39.36 65.27,40.52 arc(65.21,40.56) 65.15,40.57 64.24,40.57 62.16,42.65 62.16,43.58 61.74,44 61.12,44 arc(61.05,44.01) 61,44.04 57.58,47.47 arc(57.19,47.73) 56.74,47.82 47.86,47.82 45.28,50.4 43.33,50.4 43.21,50.52 43.21,52.3 43.22,52.3 43.22,52.94 42.46,53.69 42.46,53.69 38.72,57.44 v1(35.21,57.44) ; v1(15.06,62.69) 15.56,63.2 24.94,63.2 v1(30.72,57.42)
  BOTTOM w0.127: v1(30.72,57.42) 35.19,57.42 v1(35.21,57.44)
FPGA_I2C_EN_R: length 42.7
  TOP w0.149: U28.8 v1(26.63,93.04)
  L03_SIG1 w0.081: v1(26.63,93.04) 25.29,91.7 25.29,85.33 25.29,85.33 25.29,85.01 25.29,85 25.29,84.32 25.29,84.32 25.29,83.99 25.29,83.99 25.29,83.3 25.29,83.3 25.29,82.97 25.29,82.97 25.29,78.19 23.46,76.36 23.46,76.34 22.13,75.01 22.13,65.2 20.07,63.14 14.62,63.14 v1(14.17,62.69)
  BOTTOM w0.149: v1(14.17,62.69) R321.2 12.45,61.67 SW4.1
FPGA_JTAG_TCK: length 124.8
  L03_SIG1 w0.081: v1(36.49,20.9) 37.7,20.9 38.25,21.45 38.56,21.45 38.9,21.79 38.9,24.09 39.58,24.77 39.58,30.6 38.49,31.69 38.49,34.19 39.08,34.78 39.08,41.8 39.87,42.59 39.87,45.75 40.88,46.75 v1(40.88,49.28)
  L07_SIG3 w0.089: v1(102.78,75.03) 102.51,75.29 102.51,75.56 102.25,75.83 101.79,75.83 101.31,76.3 100.01,76.3 99.55,76.76 98.77,76.76 98.56,76.98 97.87,76.98 97.7,76.8 96.7,76.8 96.03,77.48 95.68,77.48 95.4,77.19 93,77.19 92.61,76.8 91.44,76.8 90.77,77.48 88.39,77.48 88.18,77.26 87.54,77.26 86.36,76.09 84.2,76.09 83.82,75.71 83.71,75.64 79.91,75.64 77.84,73.57 77.49,73.57 77.25,73.33 77.25,72.71 76.39,71.85 76.39,69.93 75.98,69.52 75.98,69.19 76.84,68.33 76.84,65.36 75.91,64.43 61.65,64.43 61.58,64.36 61.57,64.36 59.21,62 59.21,56 58.26,55.05 51.08,55.05 48.67,52.64 43.52,52.64 43.18,52.3 43.18,51.21 41.25,49.28 v1(40.88,49.28)
  BOTTOM w0.149: R216.2 101.04,81.84 101.51,81.38 101.51,76.27 101.85,75.93 102.13,75.93 102.5,75.57 102.5,75.31 v1(102.78,75.03)
FPGA_JTAG_TDI: length 123.8
  L03_SIG1 w0.081: v1(38.98,49.43) 38.65,49.1 38.65,46.86 36.94,45.15 36.94,36.69 35.67,35.41 35.67,33.42 35.88,33.21 35.88,30.57 35.8,30.49 34.53,30.49 34.09,30.05 34.09,24.98 33.5,24.38 v1(33.5,23.9)
  L07_SIG3 w0.089: v1(38.98,49.43) 40.5,49.43 40.5,49.43 40.72,49.65 41.05,49.65 42.83,51.44 42.83,52.46 43.98,53.61 47.87,53.61 49.75,55.49 55.52,55.49 55.6,55.58 55.6,56.3 55.69,56.39 55.87,56.39 55.96,56.3 55.96,55.61 56.08,55.49 56.23,55.49 56.32,55.58 56.32,56.3 56.4,56.39 56.58,56.39 56.67,56.3 56.67,55.61 56.79,55.49 57.92,55.49 58.87,56.44 58.87,62.14 61.43,64.7 61.44,64.7 61.51,64.78 75.04,64.78 75.86,65.59 75.86,68.83 75.32,69.37 75.32,70.17 76.04,70.89 76.04,72.25 76.78,73 76.78,73.53 77.29,74.04 77.82,74.04 79.81,76.02 83.6,76.02 84,76.43 84.01,76.43 86,76.43 87.59,78.01 88.18,78.01 88.5,77.7 91.08,77.7 91.35,77.98 91.63,77.98 91.91,77.7 92.46,77.7 92.74,77.98 93.36,77.98 93.65,77.69 96.12,77.69 96.63,77.17 97.11,77.17 97.42,77.48 97.7,77.48 97.98,77.19 98.81,77.19 99.13,77.51 99.76,77.51 100.47,76.8 102.71,76.8 v1(102.78,76.87)
  BOTTOM w0.149: v1(102.78,76.87) 102.78,77.18 103.24,77.64 103.24,77.98 103.09,78.13 103.09,78.39 104.02,79.32 104.02,80.19 104.86,81.03 R215.2
FPGA_JTAG_TDO: length 111.9
  L03_SIG1 w0.081: v1(36.49,21.9) 36.87,21.53 37.65,21.53 37.87,21.75 37.87,23.75 39.37,25.25 39.37,30.55 38.87,31.05 38.87,31.06 38.65,31.27 38.64,31.27 38.16,31.76 38.16,34.32 38.74,34.91 38.74,43.35 39.23,43.84 39.23,45.66 40.42,46.85 v1(40.42,48.75)
  L07_SIG3 w0.089: v1(101.18,75.03) 101.18,75.17 100.53,75.83 100.25,75.83 100.1,75.68 98.98,75.68 98.64,76.02 97.18,76.02 96.51,76.69 95.38,76.69 95.1,76.98 93.09,76.98 92.5,76.39 90.85,76.39 90.23,77.01 87.78,77.01 86.51,75.74 85.18,75.74 83.78,74.34 80.35,74.34 80.29,74.28 79.69,74.28 79.65,74.24 79.63,74.24 77.24,71.86 77.24,70 76.91,69.66 76.91,69.05 77.22,68.74 77.22,64.81 76.51,64.09 63.23,64.09 61.22,62.08 61.22,57.16 58.67,54.61 51.53,54.61 48.57,51.65 45.17,51.65 42.27,48.75 v1(40.42,48.75)
FPGA_JTAG_TMS: length 123.7
  L03_SIG1 w0.081: v1(39.87,49.93) 39.87,49.71 38.99,48.82 38.99,46.72 37.36,45.09 37.36,35.88 36.7,35.22 36.7,33.66 36.07,33.02 36.07,30.5 35.88,30.31 35.06,30.31 34.9,30.14 34.9,24.78 34.5,24.38 v1(34.5,23.9)
  L07_SIG3 w0.089: v1(39.87,49.93) 40.51,49.93 40.68,50.1 41.01,50.1 42.48,51.56 42.48,54.22 42.56,54.3 43.15,54.3 43.24,54.39 43.24,54.57 43.15,54.66 42.57,54.66 42.48,54.76 42.48,54.93 42.56,55.02 43.15,55.02 43.24,55.1 43.24,55.28 43.15,55.37 42.57,55.37 42.48,55.47 42.48,55.64 42.56,55.73 43.15,55.73 43.24,55.82 43.24,55.99 43.15,56.08 42.57,56.08 42.48,56.18 42.48,56.61 42.68,56.82 53.06,56.82 54.35,58.11 57.97,58.11 58.42,58.56 58.42,62.18 61.29,65.04 61.29,65.04 61.37,65.12 74.01,65.12 75.51,66.62 75.51,68.69 74.71,69.49 74.71,72.1 79.02,76.41 83.5,76.41 83.86,76.77 85.86,76.77 87.89,78.8 89.03,78.8 89.32,79.09 90.2,79.09 90.49,78.8 90.77,78.8 91.06,79.09 91.93,79.09 92.22,78.8 92.5,78.8 92.67,78.98 93.73,78.98 94.4,78.3 95.1,78.3 95.27,78.48 96.11,78.48 96.58,78.01 98.53,78.01 98.76,77.78 99.82,77.78 100.01,77.98 100.29,77.98 100.79,77.48 101.16,77.48 101.31,77.33 v1(101.98,77.33)
  BOTTOM w0.149: v1(101.98,77.33) 101.98,77.64 102.44,78.1 102.44,78.44 102.3,78.59 102.3,78.85 102.6,79.15 102.87,79.15 103.18,79.46 103.18,79.8 103.05,79.92 103.05,80.22 103.86,81.02 R214.2
FPGA_LED0: length 187.8
  L03_SIG1 w0.081: v1(117.12,39.15) 117.54,38.72 117.54,35.95 118.83,34.66 118.83,32.25 119.44,31.65 119.44,30.36 119.76,30.04 119.76,26.35 119.54,26.13 119.54,20.34 121.67,18.21 121.67,15.68 122.3,15.04 135.6,15.04 136.09,15.54 175.85,15.54 176.81,16.5 180.72,16.5 181.74,15.48 185.33,15.48 185.65,15.8 192.83,15.8 193.17,15.45 194.73,15.45 194.98,15.7 196.66,15.7 197.17,15.18 201.37,15.18 202.26,14.29 204.61,14.29 205.05,14.73 214.98,14.73 215.94,13.78 230.37,13.78 235.59,18.99 238.98,18.99 239.95,19.96 239.98,20.17 239.98,23.38 243.03,26.44 243.03,33.44 244.46,34.87 244.46,43.06 244.82,43.41 244.82,44.46 244.51,44.77 244.51,47.71 244.96,48.17 244.96,49.03 245.92,49.99 v1(245.92,54.16)
  BOTTOM w0.149: v1(245.92,54.16) 245.67,53.91 245.05,53.91 244.55,54.41 R452.2
FPGA_LED1: length 184.1
  L03_SIG1 w0.081: v1(117.91,39.61) 118.29,39.24 118.29,36.82 119.82,35.28 119.82,33.82 119.95,33.69 119.95,30.43 120.13,30.25 120.13,26.12 119.91,25.89 119.91,20.83 121.05,19.69 123.76,19.69 124.05,19.41 124.05,16.12 124.18,15.98 172.52,15.98 173.61,17.08 194.14,17.08 194.27,17.21 197.2,17.21 198.02,16.39 199.95,16.39 200.68,15.66 209.45,15.66 209.91,15.2 212.17,15.2 212.88,15.92 215.26,15.92 215.49,16.16 218.81,16.16 218.89,16.24 219.54,16.24 219.64,16.15 232.04,16.15 236.78,20.88 236.78,21.3 237.61,22.13 237.95,22.13 242.57,26.74 242.57,33.7 243.94,35.07 243.94,43.44 243.71,43.67 243.71,43.7 243.7,43.7 243.7,50.19 244.55,51.04 v1(244.55,52.4)
  BOTTOM w0.149: U42.3 247.3,53.39 246.32,52.4 v1(244.55,52.4)
FPGA_LED2: length 190.6
  L03_SIG1 w0.081: v1(117.12,38.23) 117.12,36.02 118.59,34.54 118.59,32.17 119.13,31.62 119.21,31.55 119.21,30.34 119.58,29.96 119.58,26.54 119.36,26.31 119.36,19.39 120.18,18.57 120.63,18.57 121.42,17.78 121.42,15.53 122.08,14.86 135.8,14.86 136.25,15.31 176.01,15.31 176.97,16.27 180.55,16.27 182.2,14.62 184.95,14.62 185.9,15.57 192.41,15.57 193.09,14.88 196.7,14.88 196.77,14.94 201.28,14.94 202.16,14.06 204.71,14.06 205.15,14.49 214.89,14.49 215.84,13.54 230.47,13.54 235.68,18.76 239.08,18.76 240.21,19.89 240.21,23.28 243.27,26.34 243.27,33.26 244.73,34.72 244.73,42.99 245.05,43.32 245.05,44.63 244.74,44.94 244.74,47.48 245.2,47.94 245.2,48.7 246.66,50.16 v1(246.66,51.65)
  BOTTOM w0.149: R449.2 245.05,51.89 246.42,51.89 v1(246.66,51.65) 247.03,51.65 247.95,52.57 U42.4
FPGA_LED3: length 188.6
  L03_SIG1 w0.081: v1(117.91,37.77) 117.91,36.78 119.08,35.61 119.08,32.33 119.72,31.7 119.72,30.36 119.95,30.13 119.95,26.19 119.72,25.97 119.72,20.67 122.44,17.95 122.44,15.53 122.75,15.23 135.36,15.23 135.91,15.78 174.4,15.78 175.39,16.77 192.19,16.77 193.27,15.69 194.64,15.69 195.11,16.16 199.81,16.16 200.53,15.43 209.29,15.43 209.75,14.97 212.26,14.97 212.98,15.68 214.42,15.68 216.1,14.01 230.28,14.01 235.49,19.22 238.88,19.22 239.73,20.07 239.74,20.19 239.74,23.48 242.8,26.53 242.8,33.6 244.23,35.02 244.23,43.17 244.49,43.43 244.49,44.2 244.13,44.56 244.13,49.95 v1(245.53,51.36)
  BOTTOM w0.149: U42.5 248.6,52.33 247.28,51.01 245.88,51.01 v1(245.53,51.36) R448.2
FPGA_M10_FABRIC_RESET_N: length 177.4
  TOP w0.149: U6.D36 126.05,38.23 126.5,38.68 126.85,38.68 127.31,38.23 127.65,38.23 128.1,38.68 128.45,38.68 128.9,38.23 129.23,38.23 129.7,38.7 130.03,38.7 130.51,38.23 130.84,38.23 131.28,38.67 131.67,38.67 132.11,38.23 132.44,38.23 132.89,38.68 133.24,38.68 133.7,38.22 134.03,38.22 134.49,38.67 134.81,38.67 135.26,38.22 135.61,38.22 136.06,38.67 136.41,38.67 136.83,38.24 137.23,38.24 137.65,38.67 137.99,38.67 138.45,38.21 138.8,38.21 140.4,36.61 144.17,36.61 148.86,31.93 152.63,31.93 v1(153.65,32.95)
  L03_SIG1 w0.081: v1(153.65,32.95) 153.86,32.75 158.3,32.75 163.41,27.63 170.15,27.63 171.37,26.41 v1(175.26,26.41)
  L07_SIG3 w0.089: v1(251.2,54.84) 251.2,52.02 249.07,49.89 249.07,49.51 248.35,48.78 248.35,48.14 247.83,47.62 247.29,47.62 247.04,47.37 247.04,41.86 244.51,39.33 244.51,35.39 242.81,33.69 242.81,30.1 v1(241.19,28.48)
  L12_SIG4 w0.089: v1(175.26,26.41) 175.26,22.87 176.44,21.69 176.44,20.71 179.3,17.85 183.83,17.85 184.31,17.38 184.31,17.29 184.7,16.89 186.4,16.89 186.85,17.34 186.85,17.38 187.33,17.85 187.85,17.85 188.6,17.1 190.13,17.1 190.42,17.4 190.42,17.43 191.05,18.06 192,18.06 192.93,17.14 194.06,17.14 194.16,17.25 195.22,17.25 195.4,17.43 197.32,17.43 197.52,17.24 198.41,17.24 198.52,17.13 198.85,17.13 198.94,17.21 199.34,17.21 200,16.56 201.88,16.56 202.46,15.98 206.72,15.98 207.04,15.66 211.5,15.66 213.82,17.99 218.56,17.99 221.42,20.84 233.63,20.84 235.86,18.61 240.72,18.61 241.19,19.09 v1(241.19,28.48)
FPGA_M10_HB: length 120.5
  TOP w0.149: v1(124.52,36.21) 103.12,36.21 102.64,36.69 98.5,36.69 95.37,33.57 84.87,33.57 83.84,32.54 77.36,32.54 v1(76.34,31.51) ; TP950.1 39.89,18.59 39.89,19.88 39.35,20.42 38.25,20.42 38.01,20.67 38.01,23.1 37.71,23.4 33.99,23.4 v1(33.5,22.9)
  L12_SIG4 w0.089: v1(33.5,22.9) 33.12,23.28 32.54,23.28 31.96,23.86 31.96,28.34 32.24,28.63 33.24,28.63 33.34,28.53 36.65,28.53 36.87,28.75 36.87,28.87 37.28,29.28 37.65,29.28 37.87,29.06 37.87,29 38.34,28.53 38.74,28.53 40.54,30.32 40.54,30.59 40.76,30.81 43.83,30.81 46.99,27.65 48.46,27.65 48.9,28.08 56.24,28.08 57.31,29.15 60.15,29.15 60.87,28.43 61.93,28.43 62.15,28.21 62.48,28.21 62.5,28.22 62.51,28.22 64.63,30.34 64.63,30.7 67.76,33.83 69.41,33.83 70.32,32.92 74.88,32.92 76.28,31.51 v1(76.34,31.51)
FPGA_M10_IBUS_CLK0: length 59
  L07_SIG3 w0.089: v1(25.5,20.9) 25.02,20.9 24.57,21.36 23.51,21.36 23.12,21.75 23.12,21.97 21.32,23.77 20.83,23.77 20.6,24 18.38,24 16.99,22.6 11.8,22.6 9.04,19.84 9.04,15.43 10.69,13.78 36.05,13.78 38.5,16.23 38.5,16.67 38.5,17.42 38.74,17.66 39.07,17.66 39.2,17.53 v1(39.23,17.53)
  BOTTOM w0.149: v1(39.23,17.53) 39.22,17.53 39.22,17.51 39.43,17.72 U106.15
FPGA_M10_IBUS_CLK1: length 151.9
  L07_SIG3 w0.089: v1(127.81,13.71) 126.47,13.71 124.04,16.14 124.04,16.71 124.04,16.71 124.04,17.02 124.04,17.02 124.04,17.05 123.81,17.29 123.46,17.29 123.24,17.51 123.24,17.82 123.02,18.04 122.48,18.04 122.4,18.13 122.4,24.12 122.37,24.15 122.37,25.69 122.71,26.04 122.97,26.04 123.24,26.31 123.24,26.57 123.51,26.84 123.77,26.84 124.04,27.11 124.04,27.37 124.31,27.64 124.57,27.64 124.97,28.04 124.97,28.48 129.3,32.8 129.3,33.13 129.64,33.47 130.6,33.47 130.92,33.15 v1(131.01,33.15)
  L12_SIG4 w0.089: v1(127.81,13.71) 125.9,11.8 75.77,11.8 75.49,12.08 66.79,12.08 64.77,14.1 64.77,16.96 63.6,18.13 61.86,18.13 60.01,16.29 52,16.29 51.31,15.6 47.6,15.6 46.62,16.58 44.3,16.58 43.35,17.53 41.13,17.53 40.09,16.49 35.7,16.49 35.19,17 31.23,17 30.91,16.68 25.86,16.68 24.99,17.56 24.99,18.96 24.67,19.28 24.43,19.28 23.91,19.79 23.91,21.85 24.4,22.33 24.93,22.33 v1(25.5,22.9)
  BOTTOM w0.149: U105.20 131.37,36.87 131.73,36.51 131.73,33.87 v1(131.01,33.15)
FPGA_M10_IBUS_CS0_N: length 23.6
  L03_SIG1 w0.081: v1(28.5,24.9) 28.12,24.53 28.12,22.59 28.44,22.27 28.65,22.27 28.87,22.06 28.87,21.72 29.31,21.28 31.59,21.28 31.83,21.04 31.83,20.78 32.23,20.37 32.23,20.06 34.05,18.24 34.05,16.04 34.59,15.5 38.37,15.5 38.77,15.9 39.86,15.9 40.21,16.25 41.16,16.25 41.41,15.99 v1(42.42,15.99)
  BOTTOM w0.149: v1(42.42,15.99) 42.41,15.99 42.39,15.97 42.39,15.92 42.24,15.77 U106.12
FPGA_M10_IBUS_CS1_N: length 147.6
  TOP w0.149: R6209.1 22.02,24.21 v1(22.36,24.21)
  L03_SIG1 w0.081: v1(22.36,24.21) 22.42,24.27 27.12,24.27 v1(27.5,23.9)
  L07_SIG3 w0.089: v1(123.88,13.71) 123.88,13.76 123.97,13.86 123.97,15.21 123.48,15.71 121.85,15.71 121.5,16.06 121.5,17.68 121.14,18.05 121.14,28.67 122.01,29.54 122.01,29.85 122.23,30.07 122.54,30.07 122.71,30.24 122.94,30.24 123.18,30.47 123.18,30.71 125.89,33.42 v1(128.41,33.42)
  L12_SIG4 w0.089: v1(27.5,23.9) 26.87,23.28 26.87,22.75 26.65,22.53 26.64,22.53 26.16,22.04 26.16,22.04 25.4,21.28 25.34,21.28 25.12,21.06 25.12,20.75 25.63,20.24 25.63,20.24 25.83,20.04 25.83,20.04 26.37,19.5 27.43,19.5 27.87,19.06 27.87,19 28.34,18.53 29.4,18.53 29.87,18.06 29.87,18 30.34,17.53 30.65,17.53 31.4,18.28 38.76,18.28 39.19,18.71 40.04,18.71 40.74,18.01 42.36,18.01 42.59,18.25 42.59,18.37 42.81,18.59 43.12,18.59 43.95,17.76 43.95,17.55 44.68,16.82 45.21,16.82 45.84,17.46 46.52,17.46 46.96,17.01 48.02,17.01 48.45,16.58 49.04,16.58 49.27,16.81 51.53,16.81 51.6,16.74 60.12,16.74 61.76,18.37 63.7,18.37 65.01,17.06 65.01,14.2 66.89,12.33 75.59,12.33 75.84,12.08 120.51,12.08 121.17,12.73 122.9,12.73 v1(123.88,13.71)
  BOTTOM w0.149: v1(128.41,33.42) 128.41,34.12 128.56,34.27 U105.16
FPGA_M10_MISO_0: length 57.1
  L07_SIG3 w0.089: v1(23.49,21.9) 23.49,21.93 21.42,24.01 20.93,24.01 20.69,24.25 18.2,24.25 16.8,22.84 11.7,22.84 8.8,19.94 8.8,15.29 10.55,13.54 36.15,13.54 38.88,16.26 v1(38.88,17.03)
  BOTTOM w0.149: v1(38.88,17.03) 39.49,16.42 U106.13
FPGA_M10_MISO_1: length 148.6
  L05_SIG2 w0.081: v1(125.83,13.67) 125.34,13.18 125.34,10.38 123.66,8.7 59.52,8.7 58.06,10.16 55.13,10.16 53.55,11.74 53.02,11.74 52.74,12.02 48.22,12.02 48.1,11.9 47.36,11.9 46.32,12.94 45.48,12.94 44.57,13.84 27.09,13.84 22.94,17.99 22.94,22.87 23.97,23.9 v1(24.49,23.9)
  L07_SIG3 w0.089: v1(131.08,33.93) 129.75,33.93 129.06,33.23 129.06,33 128.78,32.72 127.02,32.72 125.16,30.86 125.04,30.86 124.95,30.77 124.95,30.55 124.04,29.63 124.04,28.71 123.77,28.44 122.71,28.44 122.47,28.19 122.47,27.11 121.65,26.29 121.65,23.81 121.89,23.57 121.89,22.85 121.62,22.59 121.62,22.02 122.18,21.46 122.18,17.52 122.43,17.27 122.99,17.27 123.24,17.02 123.24,17.01 123.29,16.96 123.29,16.59 124.84,15.04 124.84,14.66 v1(125.83,13.67)
  BOTTOM w0.149: v1(131.08,33.93) 131.1,33.95 131.1,34.71 130.89,34.92 U105.17
FPGA_M10_MOSI_0: length 25.2
  L12_SIG4 w0.089: v1(42.96,18.22) 42.52,17.77 40.34,17.77 40.21,17.9 39.08,17.9 38.7,17.53 30.95,17.53 30.74,17.32 29.79,17.32 29.68,17.43 29.43,17.43 29.12,17.75 29.12,17.81 28.65,18.28 27.59,18.28 26.87,19 26.87,19.06 26.65,19.28 25.95,19.28 25.74,19.49 25.43,19.49 25.16,19.76 25.16,19.77 24.4,20.53 24.34,20.53 24.12,20.75 24.12,21.53 v1(24.49,21.9)
  BOTTOM w0.149: U106.14 42.55,17.07 42.95,17.46 42.95,18.18 42.92,18.22 v1(42.96,18.22)
FPGA_M10_MOSI_1: length 142.8
  L05_SIG2 w0.081: v1(23.49,22.9) 23.12,22.53 23.12,18.75 27.13,14.75 41.8,14.75 42.4,14.14 44.44,14.14 44.76,14.47 45.23,14.47 47.57,12.13 48,12.13 48.15,12.28 52.19,12.28 52.7,12.79 53.95,12.79 54.18,12.56 54.18,12.34 55.51,11.01 57.54,11.01 59.62,8.93 122.16,8.93 123.56,10.33 123.56,12.41 v1(124.52,13.36)
  L07_SIG3 w0.089: v1(124.52,13.36) 124.52,15.04 123.64,15.92 123.19,15.92 122.44,16.66 122.44,16.84 121.94,17.34 121.94,17.61 121.35,18.2 121.35,27.88 122.71,29.24 122.76,29.24 122.8,29.28 123.53,29.28 123.67,29.41 123.67,30.29 126.35,32.98 v1(126.75,32.98)
  BOTTOM w0.149: U105.18 128.63,35.57 127.87,34.81 127.87,33.28 127.56,32.98 v1(126.75,32.98)
FPGA_M10_VID_ALERTN: length 121.3
  L07_SIG3 w0.089: v1(124.84,10.97) 124.84,11.47 120.66,15.65 120.66,16.37 119.65,17.38 119.65,21.11 120.26,21.72 120.26,29.44 121.04,30.23 121.04,31.43 121.38,31.76 121.38,32.16 121.38,33.47 121.38,33.49 121.38,34.32 121.23,34.47 121.23,35.82 122.7,37.28 v1(122.7,37.77)
  L14_SIG5 w0.081: v1(46.32,19.02) 46.78,19.48 46.78,20.5 48.08,21.8 50.01,21.8 52.02,19.79 52.98,19.79 55.78,16.98 59.11,16.98 61.5,14.59 61.5,12.8 61.76,12.54 61.76,11.75 61.6,11.59 61.6,10.93 61.87,10.66 61.87,9.97 64.89,6.95 121.28,6.95 124.84,10.51 v1(124.84,10.97)
FPGA_MSEL0: length 93.5
  L03_SIG1 w0.081: v1(30.43,78.57) 32.91,78.57 39.28,72.2 39.28,62.75 38.68,62.15 38.68,52.94 40.18,51.45 40.18,51.14 40.43,50.89 40.94,50.89 41.17,50.66 41.17,50.16 41.17,50.16 39.55,48.55 39.55,46.47 38.82,45.74 38.82,44.05 38.41,43.63 38.41,35.05 37.73,34.37 37.73,33.19 37.87,33.06 37.87,33.05 37.88,33.04 37.88,29 38.6,28.27 38.95,28.27 39.03,28.19 39.03,27.44 v2(38.5,26.9)
  L12_SIG4 w0.089: v1(2.36,80.34) 3.3,81.29 8.49,81.29 10.96,83.76 25.91,83.76 27.44,82.23 28.63,82.23 28.83,82.02 28.83,80.17 v1(30.43,78.57)
FPGA_MSEL1: length 90.9
  L05_SIG2 w0.081: v1(2.36,82.5) 4.27,80.58 4.27,73.52 3,72.25 3,67.01 3.74,66.27 3.74,64.49 3.5,64.25 3.5,38.8 7.45,34.85 7.45,27.99 9.47,25.97 16.37,25.97 17.25,25.1 19.84,25.1 20.25,25.51 27.7,25.51 28.56,26.37 31.56,26.37 32.12,25.81 32.12,25.7 32.31,25.51 36.57,25.51 36.83,25.76 36.83,26.24 v1(37.5,26.9)
FPGA_NCONFIG: length 134.8
  L07_SIG3 w0.089: v1(33.5,24.9) 32.87,25.53 32.87,26.2 32.51,26.57 32.36,26.57 32.16,26.76 32.16,26.91 30.1,28.97 30.1,30.74 30.1,31.99 29.56,32.53 29.34,32.53 29.12,32.75 29.12,33.28 29.62,33.78 29.76,33.78 30,34.01 30,34.42 29.76,34.66 29.43,34.66 29.2,34.89 29.2,35.22 29.43,35.45 29.45,35.45 30,36 29.49,36.51 29.49,37.74 30.31,38.55 31.93,38.55 32.48,39.1 32.48,43.17 32.75,43.44 32.75,45.96 32.95,46.16 32.95,52.81 40.65,60.51 40.65,63.15 45.02,67.52 52.05,67.52 65.71,81.18 66.23,81.18 67.52,82.47 73.77,82.47 79.6,88.3 88.18,88.3 88.97,87.51 97.93,87.51 104.58,80.85 104.58,79.06 104.74,78.89 104.74,78.55 104.73,78.54 104.73,77.77 v1(105.17,77.33)
  BOTTOM w0.149: R218.2 107.83,79.96 106.1,78.23 105.81,78.23 105.45,77.87 v1(105.17,77.33)
FPGA_NSTATUS: length 138.2
  TOP w0.149: U34.L16 38.5,22.59 39.31,21.77 v1(39.31,21.31)
  L03_SIG1 w0.081: v1(41.1,45.93) 41.1,44.31 40.44,43.65 40.44,42.45 40.87,42.02 40.87,38.14 39.42,36.68 39.42,34.64 38.83,34.05 38.83,31.7 39.85,30.67 39.85,21.85 v1(39.31,21.31)
  L05_SIG2 w0.081: v1(34.42,59.42) 34.42,54.69 37.37,51.75 37.37,49.66 v1(41.1,45.93)
  L14_SIG5 w0.081: v1(34.42,59.42) 33.08,60.76 33.08,62.45 33.35,62.72 34.12,62.72 35.24,63.84 35.24,64.61 38.49,67.86 63.21,67.86 64.37,66.7 65.53,66.7 65.93,66.3 70.08,66.3 70.5,66.72 70.81,66.72 71.19,66.33 75.27,66.33 77.13,68.2 77.13,69.5 79.59,71.95 81.84,71.95 82.17,72.29 82.17,73.22 83.61,74.66 84.14,74.66 84.66,75.18 84.66,75.47 86.45,77.26 90.28,77.26 90.49,77.47 90.76,77.47 90.98,77.26 92.01,77.26 92.22,77.47 92.5,77.47 92.71,77.26 95.48,77.26 95.69,77.47 95.96,77.47 96.17,77.26 97.21,77.26 97.42,77.47 97.69,77.47 97.9,77.26 98.89,77.26 99.13,77.51 99.44,77.51 99.69,77.26 100.67,77.26 100.88,77.47 101.2,77.47 101.93,76.74 102.22,76.74 102.46,76.5 102.9,76.5 103.45,75.95 v1(104.37,75.95)
  BOTTOM w0.149: R217.2 105.85,81.34 104.67,80.16 104.67,79.03 104.83,78.87 104.83,78.58 104.68,78.42 104.68,78.13 104.83,77.98 104.83,77.62 104.68,77.47 104.68,77.21 104.83,77.06 104.83,76.72 104.37,76.26 v1(104.37,75.95)
FPGA_OSC_CLK_1: length 123.6
  L05_SIG2 w0.081: v1(47.76,31.03) 47.95,31.21 47.95,36.54 47.49,37 47.49,40.99 48.06,41.56 48.06,42.44 47.27,43.23 47.27,43.87 46.42,44.71 v1(45.14,44.71)
  L14_SIG5 w0.081: v1(102.77,74.11) 102.41,74.48 102.41,75.53 102.12,75.82 101.99,75.82 101.29,76.52 100.51,76.52 100.29,76.31 100.02,76.31 99.8,76.52 98.77,76.52 98.56,76.31 98.28,76.31 98.07,76.52 95.31,76.52 95.1,76.31 94.82,76.31 94.61,76.52 93.58,76.52 93.36,76.31 93.09,76.31 92.87,76.52 90.11,76.52 89.9,76.31 89.62,76.31 89.41,76.52 88.43,76.52 88.18,76.27 87.26,76.27 86.68,75.69 85.34,75.69 84.99,75.34 84.99,75.05 84.28,74.33 83.75,74.33 82.5,73.09 82.5,72.15 81.97,71.63 79.88,71.63 78.06,69.81 78.06,67.8 76.22,65.96 63.89,65.96 62.41,67.43 43.12,67.43 38.68,62.99 35.11,62.99 33.93,61.81 33.93,60.57 34.79,59.71 34.79,57.18 35.43,56.54 37.83,56.54 41.49,52.88 41.49,48.54 45.14,44.89 v1(45.14,44.71)
  BOTTOM w0.149: v1(47.76,31.03) 48.19,31.03 49.13,30.09 R239.1
FPGA_PCIE_PERSTN: length 101.8
  L05_SIG2 w0.081: v1(118.72,16.62) 116.68,16.62 114.52,14.46 62.99,14.46 62.43,15.02 59.92,15.02 59.81,14.91 v1(59.44,14.91)
  L16_SIG6 w0.081: v1(107.56,49.27) 107.96,48.87 107.96,45.9 108.27,45.59 108.6,45.59 109.15,45.04 109.51,45.04 109.97,44.58 110.29,44.58 110.58,44.3 110.93,44.3 111.39,43.84 111.62,43.84 112.26,43.2 112.49,43.2 112.71,42.98 112.71,42.27 112.98,42 113.2,42 113.56,41.64 113.56,36.69 116.11,34.13 116.48,34.13 116.74,33.88 116.74,31.31 117.4,30.65 117.4,17.77 118.55,16.62 v1(118.72,16.62)
  BOTTOM w0.149: R183.1 58.36,13.95 58.49,14.08 R184.2 58.49,14.53 59.06,14.53 v1(59.44,14.91)
FPGA_PMBUS_EN: length 98.1
  L03_SIG1 w0.127: v1(19.89,108.72) 20.33,108.28 20.33,105.17 19.83,104.68 19.83,103.63 21.17,102.3 23.07,102.3 23.8,101.56 23.8,89.59 23.03,88.82 23.03,86.71 23.47,86.27 23.47,82.96 23.87,82.56 23.87,78.44 21.57,76.14 21.57,65.41 20.65,64.49 17.88,64.49 17.07,63.68 14.2,63.68 13.34,62.82 13.34,58.44 v1(14.17,57.61)
  L07_SIG3 w0.127: v1(27.5,32.9) 26.11,32.9 25.21,33.8 23.34,33.8 22.67,34.47 22.67,49.44 14.99,57.12 14.65,57.12 v1(14.17,57.61)
  BOTTOM w0.127: SW4.4 13.79,57.99 v1(14.17,57.61) ; U26.5 v1(19.89,108.72)
