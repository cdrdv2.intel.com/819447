# Allegro board FM85_AGILEX_PCIE_DK_CMC_ADI_REVC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_DDIMM2_DQS_N3: length 59.2
  L12_SIG4 w0.089: v1(124.29,81.01) 124.42,80.94 124.74,80.94 124.83,81.03 124.83,81.95 126.24,83.36 126.24,83.82 126.58,84.16 127.12,84.16 127.33,83.96 127.5,83.96 127.71,83.76 127.71,83.26 127.79,83.17 127.97,83.17 128.06,83.26 128.06,83.76 128.26,83.96 128.48,83.96 129.59,85.06 130.14,85.06 130.5,84.7 132.41,84.7 132.89,85.18 133.17,85.18 133.64,84.71 133.77,84.71 133.88,84.83 133.88,84.96 133.46,85.37 133.46,85.94 134.32,86.79 135.03,86.79 135.41,87.17 135.69,87.17 136.33,86.53 136.48,86.53 136.59,86.64 136.59,86.76 135.94,87.41 135.94,87.7 137.19,88.95 143.03,88.95 143.23,88.75 143.23,86.47 143.33,86.37 143.47,86.37 143.58,86.47 143.58,88.75 143.78,88.95 144.1,88.95 144.3,88.75 144.3,87.5 144.39,87.41 144.53,87.41 144.64,87.53 144.64,88.75 144.84,88.95 146.19,88.95 146.76,89.52 155.02,89.52 155.63,90.13 157.24,90.13 160.05,92.95 160.05,93.16 159.75,93.46 159.75,94.37 160.72,95.34 161.28,95.34 161.48,95.14 161.48,94.6 v1(161.76,94.31)
DDR4_DDIMM2_DQS_N4: length 52
  L03_SIG1 w0.076: v2(114.74,81) 114.98,80.86 115.09,80.89 115.09,80.89 115.17,81.03 115.17,82.7 114.95,82.92 114.63,82.92 114.45,83.1 114.45,83.42 114.63,83.6 115.25,83.6 115.36,83.71 115.36,83.86 115.28,83.93 114.63,83.93 114.45,84.11 114.45,84.44 114.63,84.62 115.09,84.62 115.17,84.69 115.17,87.5 115.17,87.5
  L03_SIG1 w0.081: 115.17,87.5 115.08,87.59 114.96,87.59 114.39,87.02 114.13,87.02 113.9,87.25 113.9,87.51 114.47,88.09 114.47,88.2 114.22,88.45 114.1,88.45 113.45,87.8 113.18,87.8 112.96,88.02 112.96,88.29 113.61,88.94 113.61,89.06 113.49,89.18 113.37,89.18 112.51,88.32 112.24,88.32 112.01,88.55 112.01,88.82 112.88,89.68 112.88,89.79 112.75,89.91 112.64,89.91 111.78,89.05 111.51,89.05 111.28,89.28 111.28,89.55 112.14,90.41 112.14,90.52 112.02,90.65 111.91,90.65 111.04,89.79 110.78,89.79 110.55,90.01 110.55,90.28 111.41,91.14 111.41,91.26 110.8,91.86 109.1,91.86 109.02,91.78 109.02,91.26 108.83,91.07 108.51,91.07 108.32,91.26 108.32,91.78 108.24,91.86 107.81,91.86 107.03,92.65 107.03,93.63 106.8,93.85 106.8,95.18 107.16,95.55 108.88,95.55 109,95.66 109,95.8 108.91,95.88 107.57,95.88 107.38,96.07 107.38,96.39 107.57,96.58 108.91,96.58 108.99,96.66 108.99,96.84 108.91,96.92 108.67,96.92 108.48,97.11 108.48,97.67 108.4,97.75 108.23,97.75 108.15,97.67 108.15,97.11 107.96,96.92 107.57,96.92 107.38,97.11 107.38,97.63 107.3,97.71 107.15,97.71 106.49,97.04 106.49,96.84 106.35,96.7 106.15,96.7 106.07,96.62 106.07,96.36 106.2,96.23 106.2,96.02 106.07,95.89 106.07,95.54 106.2,95.42 106.2,95.21 106.07,95.08 106.07,94.7 arc(106.1,94.64) 106.16,94.61 arc(106.23,94.58) 106.26,94.51 106.26,94.46 arc(106.23,94.39) 106.16,94.36 arc(106.1,94.34) 106.07,94.27 106.07,94.22 arc(106.1,94.15) 106.16,94.12 arc(106.23,94.09) 106.26,94.02 106.26,93.97 arc(106.23,93.9) 106.16,93.88 arc(106.1,93.85) 106.07,93.78 106.07,93.47 106.28,93.26 106.46,93.26 v1(106.54,93.34)
DDR4_DDIMM2_DQS_N5: length 51.7
  L03_SIG1 w0.081: v2(105.16,81.01) 105.37,80.89 105.55,80.94 105.77,81.31 105.77,81.74 105.69,81.82 105.31,81.82 105.12,82.01 105.12,82.33 105.31,82.52 105.69,82.52 105.77,82.6 105.77,82.77 105.56,82.99 105.56,83.25 106,83.7 106,83.81 105.88,83.94 105.77,83.94 105.32,83.49 105.05,83.49 104.82,83.72 104.82,83.99 105.27,84.43 105.27,84.55 105.15,84.67 105.03,84.67 104.59,84.22 104.32,84.22 103.57,84.98 103.57,85.24 104.06,85.73 104.06,85.85 103.94,85.97 103.82,85.97 103.33,85.48 103.06,85.48 102.62,85.92 102.62,86.19 103.59,87.16 103.59,87.27 103.47,87.4 103.35,87.4 102.38,86.43 102.12,86.43 101.89,86.65 101.89,86.92 102.86,87.89 102.86,88.01 102.73,88.13 102.62,88.13 101.65,87.16 101.38,87.16 101.15,87.39 101.15,87.65 102.12,88.62 102.12,88.74 102,88.86 101.89,88.86 100.92,87.89 100.65,87.89 100.42,88.12 100.42,88.39 101.39,89.36 101.39,89.47 101.27,89.59 101.15,89.59 100.18,88.62 99.92,88.62 99.69,88.85 99.69,89.12 100.66,90.09 100.66,90.2 100.54,90.33 100.42,90.33 99.45,89.36 99.18,89.36 98.96,89.59 98.96,89.85 99.93,90.82 99.93,90.94 99.8,91.06 99.69,91.06 98.72,90.09 98.45,90.09 97.71,90.83 97.71,91.64 97.63,91.72 96.52,91.72 96.33,91.91 96.33,92.23 96.52,92.42 97.63,92.42 97.71,92.5 97.71,93.59 97.49,93.82 97.49,95.31 97.68,95.49 98.25,95.49 98.33,95.58 98.33,95.75 98.25,95.83 97.68,95.83 97.49,96.02 97.49,96.53 97.29,96.72 96.93,96.72 96.83,96.72 96.42,96.32 96.41,96.25 96.41,95.26 96.54,94.9 96.59,94.82 arc(96.68,94.66) 96.73,94.49 arc(96.74,94.43) 96.74,94.37 96.74,94.24 96.9,94.08 96.9,93.91 96.74,93.75 96.74,93.45 arc(96.76,93.38) 96.8,93.32 arc(96.85,93.28) 96.91,93.27 97.12,93.27 v1(97.19,93.34)
DDR4_DDIMM2_DQS_N6: length 52.6
  L05_SIG2 w0.076: 107.95,82.85 107.96,82.84 107.96,82.84 109.5,81.3 arc(109.56,81.21) 109.57,81.11 109.57,81.01 arc(109.6,80.86) 109.69,80.74 109.71,80.71 arc(109.79,80.66) 109.89,80.64 110.15,80.64 110.18,80.66 110.23,80.76 110.2,80.86 v1(109.95,81.01)
  L05_SIG2 w0.081: 107.95,82.85 106.7,84.1 102.69,84.1 102.61,84.19 102.61,86.35 102.41,86.55 102.1,86.55 101.91,86.35 101.91,84.19 101.83,84.1 101.66,84.1 101.58,84.19 101.58,86.33 101.39,86.52 101.07,86.52 100.87,86.32 100.87,84.19 100.79,84.1 100.62,84.1 100.54,84.19 100.54,86.29 100.35,86.47 100.03,86.47 99.84,86.28 99.84,84.19 99.76,84.1 99.58,84.1 99.5,84.19 99.5,86.17 99.31,86.36 98.99,86.36 98.8,86.17 98.8,84.19 98.72,84.1 98.55,84.1 98.47,84.19 98.47,86.06 98.28,86.25 97.95,86.25 97.77,86.06 97.77,84.19 97.68,84.1 94.39,84.1 88.32,90.17 88.32,90.31 88.15,90.48 88.01,90.48 87.84,90.65 87.84,90.79 87.68,90.95 87.54,90.95 87.37,91.12 87.37,91.53 87.53,91.68 87.53,92.04 87.4,92.17 87.4,92.34 87.5,92.44 87.5,92.79 87.37,92.92 87.37,93.24 87.6,93.47 87.72,93.47 v1(87.84,93.34)
DDR4_DDIMM2_DQS_N7: length 65.7
  L14_SIG5 w0.076: v1(111.54,76.41) 111.81,76.25 111.89,76.27 arc(111.91,76.44) 111.86,76.59 arc(111.79,76.85) 111.85,77.12 111.86,77.14 arc(111.91,77.33) 111.87,77.51 111.86,77.51 arc(111.79,77.79) 111.86,78.06 arc(111.91,78.25) 111.86,78.43 111.86,78.44 arc(111.79,78.71) 111.86,78.98 arc(111.91,79.17) 111.87,79.35 111.86,79.37 arc(111.79,79.62) 111.85,79.87 111.85,79.88 arc(111.86,79.9) 111.87,79.91 arc(111.88,79.92) 111.88,79.94 arc(111.91,80.05) 111.9,80.17 arc(111.89,80.22) 111.86,80.25 111.74,80.38 arc(111.64,80.44) 111.53,80.46 111.42,80.46 arc(111.33,80.47) 111.24,80.51 arc(111.18,80.57) 111.12,80.64 111.05,80.76 arc(111,80.86) 110.98,80.96 110.97,80.98 arc(110.97,81) 110.97,81.01
  L14_SIG5 w0.081: 110.97,81.01 110.97,81.69 111.16,81.88 112.09,81.88 112.18,81.96 112.18,82.13 112.09,82.21 111.16,82.21 110.97,82.4 110.97,82.72 111.16,82.91 112.09,82.91 112.18,82.99 112.18,83.17 112.09,83.25 111.16,83.25 110.97,83.44 110.97,83.68 110.23,84.42 107.5,84.42 107.31,84.61 107.31,85.18 107.5,85.37 107.97,85.37 108.05,85.45 108.05,85.63 107.97,85.71 107.5,85.71 107.31,85.9 107.31,86.16 107.23,86.24 107.05,86.24 106.97,86.16 106.97,84.61 106.78,84.42 105.76,84.42 105.57,84.61 105.57,86.08 105.49,86.16 105.32,86.16 105.23,86.08 105.23,84.61 105.05,84.42 104.37,84.42 104,84.78 104,85.95 103.83,86.12 103.16,86.12 103.08,86.04 103.08,85.36 102.89,85.17 102.57,85.17 102.38,85.36 102.38,86.04 102.3,86.12 102.13,86.12 102.04,86.04 102.04,85.35 101.86,85.16 101.53,85.16 101.34,85.35 101.34,86.04 101.2,86.18 97.75,86.18 97.31,85.75 94.21,85.75 91.17,88.79 88.36,88.79 86.99,90.17 80.9,90.17 80.41,90.65 78.79,90.65 77.79,91.66 77.79,92.15 76.93,93.01 76.93,93.63 77.52,94.22 77.89,94.22 78.25,93.86 78.25,93.52 v1(78.44,93.33)
DDR4_DDIMM2_DQS_N8: length 55.8
  L12_SIG4 w0.089: v1(152.44,94.21) 152.23,94.43 152.23,95.46 152.34,95.57 152.96,95.57 153.86,94.67 154.4,94.67 154.71,94.98 154.71,95.37 154.35,95.73 154.35,96.1 155.04,96.79 155.04,97.07 154.64,97.47 154.21,97.47 153.35,96.61 151.9,96.61 150.94,95.65 150.94,95.36 151.21,95.09 151.21,94.97 151.1,94.85 150.97,94.85 150.7,95.12 150.42,95.12 149.34,94.05 146.4,94.05 145.99,93.64 145.48,93.64 145.33,93.79 144.12,93.79 143.92,93.59 143.92,93.5 143.83,93.41 143.66,93.41 143.58,93.5 143.58,94.12 143.37,94.32 143.05,94.32 142.85,94.12 142.85,93.48 142.76,93.4 142.6,93.4 142.51,93.48 142.51,93.72 142.31,93.92 135.78,93.92 arc(135.61,93.88) 135.47,93.79 134.02,92.34 131.51,92.34 arc(131.39,92.32) 131.29,92.25 129.53,90.49 arc(129.49,90.47) 129.45,90.46 128.6,90.46 arc(128.48,90.44) 128.38,90.37 126.76,88.75 arc(126.73,88.73) 126.68,88.72 124.14,88.72 122.21,86.78 120.81,86.78 119.93,85.91 119.93,84.32 arc(119.9,84.14) 119.8,83.99 119.69,83.89 arc(119.55,83.67) 119.5,83.42 119.5,82.14 arc(119.55,81.88) 119.7,81.65 119.99,81.37 arc(120.05,81.23) 119.99,81.09 119.9,81 arc(119.71,80.92) 119.52,81 v1(119.51,81.01)
DDR4_DDIMM2_DQS_P0: length 118.4
  L12_SIG4 w0.076: v1(108.36,78.25) 108.09,78.4 108.07,78.48 arc(108.18,78.58) 108.33,78.62 108.36,78.62 arc(108.62,78.69) 108.81,78.87 108.86,78.95 arc(108.91,79.06) 108.92,79.17 108.92,79.22 arc(108.91,79.29) 108.88,79.35 108.83,79.44 arc(108.83,79.44) 108.83,79.44 108.83,79.45 arc(108.78,79.63) 108.83,79.82 arc(108.9,80.09) 108.83,80.36 108.81,80.4 arc(108.78,80.57) 108.83,80.74 108.84,80.75 arc(108.88,80.85) 108.9,80.97 108.9,80.97 108.9,81.13 108.91,81.14 108.91,81.29 108.87,81.33 108.87,81.34 108.86,81.35
  L12_SIG4 w0.089: 108.86,81.35 108.11,82.09 108.11,88.19 108.71,88.79 108.71,89.07 108.43,89.35 108.43,89.48 108.55,89.6 108.67,89.6 108.95,89.32 109.24,89.32 109.46,89.54 109.46,89.83 109.18,90.11 109.18,90.23 109.3,90.35 109.43,90.35 109.71,90.07 109.99,90.07 111.06,91.14 111.06,91.43 110.74,91.75 110.74,91.87 110.86,91.99 110.99,91.99 111.31,91.67 111.59,91.67 112.24,92.32 112.24,93.86 112.12,93.97 112.12,94.49 112.53,94.9 112.53,95.38 113.23,96.09 113.74,96.09 114.76,97.11 115.07,97.11 115.85,97.89 115.85,98.45 117.65,100.25 118.86,100.25 119.33,100.71 119.33,101 119.12,101.21 119.12,101.33 119.23,101.45 119.36,101.45 119.57,101.24 119.85,101.24 120.07,101.46 120.55,101.46 120.75,101.66 120.75,101.87 120.84,101.96 121,101.96 121.09,101.87 121.09,101.66 121.29,101.46 122.33,101.46 122.53,101.66 122.53,101.95 122.61,102.04 122.78,102.04 122.87,101.95 122.87,101.66 123.07,101.46 124.06,101.46 124.15,101.37 124.16,101.37 124.99,100.53 125.46,100.53 125.62,100.69 128.02,100.69 130.13,102.81 133.88,102.81 134.38,102.31 136.48,102.31 136.77,102.59 139.32,102.59 139.49,102.43 145.85,102.43 145.87,102.45 145.88,102.45 145.89,102.45 146.03,102.45 146.63,103.05 153.9,103.05 154.73,103.88 158.06,103.88 158.7,103.23 171.25,103.23 171.69,102.8 182.77,102.8 183.08,102.49 186.51,102.49 187.76,101.23 187.76,100.39 188.08,100.08 188.08,99.87 187.93,99.73 187.93,99.53 188.08,99.39 188.08,99.19 187.93,99.05 187.93,98.85 188.08,98.7 188.08,97.36 188.26,97.18 188.26,96.99 188.41,96.84 188.6,96.84 188.75,96.69 188.75,96.5 188.9,96.36 189.08,96.36 189.32,96.12 189.32,95.68 189.52,95.48 190.44,95.48 190.54,95.38 190.54,95.22 190.45,95.13 189.52,95.13 189.32,94.93 189.32,94.71 189.15,94.54 189.15,94.37 189.32,94.2 189.32,93.75 189.23,93.66 v1(188.99,93.66)
DDR4_DDIMM2_DQS_P1: length 95.1
  L12_SIG4 w0.076: v1(122.7,78.25) 122.43,78.4 122.35,78.38 arc(122.33,78.32) 122.3,78.26 arc(122.29,78.22) 122.31,78.19 122.42,77.98 arc(122.5,77.91) 122.6,77.88 122.86,77.88 arc(122.98,77.85) 123.07,77.76 123.16,77.62 123.18,77.6 arc(123.25,77.33) 123.17,77.05 123.16,77.04 arc(123.12,76.86) 123.17,76.68 123.17,76.68 arc(123.31,76.55) 123.49,76.5 123.51,76.5 arc(123.78,76.42) 123.97,76.22 arc(124.1,76.09) 124.28,76.04 124.29,76.04 arc(124.56,75.97) 124.76,75.78 124.77,75.75 arc(124.91,75.62) 125.09,75.58 arc(125.36,75.51) 125.56,75.31 125.57,75.3 arc(125.7,75.17) 125.88,75.12 125.89,75.12 arc(126.07,75.17) 126.21,75.3 arc(126.4,75.5) 126.67,75.58 126.69,75.58 arc(126.87,75.63) 127,75.76 arc(127.2,75.96) 127.47,76.04 127.48,76.04 arc(127.66,76.09) 127.79,76.22 127.8,76.23 arc(128,76.43) 128.27,76.5 arc(128.28,76.5) 128.28,76.5 arc(128.46,76.55) 128.59,76.68 arc(128.6,76.69) 128.6,76.69 128.62,76.73 arc(128.79,76.9) 129.03,76.96 129.18,76.96 arc(129.22,76.96) 129.26,76.98 arc(129.3,77) 129.32,77.03 129.39,77.15 arc(129.63,77.37) 129.94,77.45 arc(130.06,77.48) 130.15,77.57 arc(130.16,77.58) 130.16,77.59 130.17,77.64 arc(130.29,77.81) 130.49,77.88 130.66,77.88 arc(130.94,77.81) 131.14,77.6 131.15,77.59 arc(131.25,77.48) 131.38,77.43 arc(131.7,77.37) 131.94,77.15 131.94,77.14 arc(132.07,77.01) 132.26,76.96 132.27,76.96 arc(132.45,77.01) 132.58,77.14 arc(132.76,77.34) 133.01,77.43 arc(133.13,77.45) 133.25,77.5 133.48,77.73 arc(133.65,77.84) 133.86,77.88 arc(134.07,77.84) 134.24,77.73 134.47,77.5 arc(134.48,77.49) 134.49,77.48 arc(134.51,77.47) 134.53,77.46 arc(134.61,77.44) 134.68,77.44 138.01,77.44 138.45,77.88 arc(138.53,77.89) 138.59,77.94 138.88,78.23 arc(139,78.31) 139.15,78.34 139.54,78.34 arc(139.65,78.37) 139.72,78.46 arc(140.23,78.8) 140.73,78.46 arc(140.8,78.37) 140.91,78.34 141.11,78.34 arc(141.24,78.37) 141.32,78.47 arc(141.38,78.58) 141.47,78.67 arc(141.5,78.7) 141.53,78.73 arc(141.54,78.73) 141.56,78.74 arc(141.96,78.78) 142.29,78.53 142.34,78.45 arc(142.34,78.44) 142.35,78.43 142.42,78.36 arc(142.45,78.34) 142.48,78.34 142.65,78.34 arc(142.76,78.36) 142.85,78.42 142.89,78.46 arc(142.92,78.5) 142.95,78.54 arc(143.14,78.75) 143.42,78.83 147.13,78.83 arc(147.15,78.82) 147.18,78.81
  L12_SIG4 w0.089: 147.18,78.81 148.44,77.54 arc(148.48,77.52) 148.52,77.51 161.26,77.51 arc(161.3,77.52) 161.34,77.54 161.88,78.08 161.88,78.21 160.82,79.27 160.82,79.55 161.05,79.78 161.33,79.78 162.39,78.72 162.52,78.72 162.63,78.84 162.63,78.96 161.57,80.02 161.57,80.31 161.8,80.54 162.09,80.54 163.15,79.48 163.27,79.48 163.39,79.59 163.39,79.72 162.33,80.78 162.33,81.06 162.56,81.29 162.84,81.29 163.9,80.23 164.03,80.23 164.14,80.35 164.14,80.47 162.88,81.74 162.88,82.02 163.09,82.23 163.41,82.23 164.66,80.98 164.78,80.98 165.65,81.86 arc(165.68,81.89) 165.69,81.94 165.69,85.6 arc(165.69,85.68) 165.72,85.76 arc(165.77,85.85) 165.84,85.94 166.73,86.83 arc(166.83,86.89) 166.95,86.92 167.14,86.92 arc(167.18,86.93) 167.22,86.95 167.23,86.95 167.43,87.15 arc(167.45,87.19) 167.46,87.23 167.46,87.43 arc(167.48,87.55) 167.55,87.65 168.83,88.93 168.83,89.05 167.98,89.9 167.98,90.18 168.21,90.41 168.49,90.41 169.34,89.56 169.47,89.56 169.58,89.68 169.58,89.81 168.74,90.65 168.74,90.94 168.96,91.17 169.25,91.17 170.1,90.32 170.22,90.32 170.34,90.43 170.34,90.56 169.49,91.41 169.49,91.69 169.72,91.92 170,91.92 170.85,91.07 170.94,91.07 arc(170.97,91.08) 171,91.1 171.27,91.36 arc(171.56,91.56) 171.9,91.63 173.69,91.63 arc(173.74,91.63) 173.77,91.66 174.69,92.58 arc(174.79,92.65) 174.91,92.67 176.52,92.67 176.68,92.83 176.87,92.83 177.03,92.67 177.21,92.67 177.37,92.83 177.55,92.83 177.71,92.67 177.89,92.67 178.05,92.83 178.24,92.83 178.4,92.67 178.58,92.67 178.74,92.83 178.92,92.83 179.08,92.67 179.71,92.67 arc(179.75,92.68) 179.79,92.7 179.91,92.83 arc(179.94,92.87) 179.96,92.92 arc(179.96,92.93) 179.96,92.95 arc(179.95,93.02) 179.91,93.08 v1(179.64,93.34)
DDR4_DDIMM2_DQS_P2: length 99.5
  L14_SIG5 w0.076: v1(112.34,74.11) 112.07,73.95 112.05,73.88 arc(112.18,73.77) 112.34,73.74 112.34,73.74 arc(112.61,73.66) 112.81,73.46 112.84,73.41 arc(112.88,73.32) 112.89,73.22 arc(112.88,73.12) 112.85,73.04 112.78,72.93 arc(112.74,72.79) 112.77,72.64 112.85,72.46 arc(112.91,72.23) 112.85,71.99 112.83,71.94 arc(112.84,71.64) 113.1,71.47 arc(113.4,71.38) 113.62,71.15 arc(113.74,71.03) 113.9,70.98 arc(114.18,70.88) 114.39,70.68 arc(114.52,70.58) 114.67,70.54 114.76,70.54 arc(115.03,70.47) 115.23,70.27 115.27,70.19 arc(115.34,70.11) 115.44,70.07 115.48,70.06 115.53,70.06 arc(115.56,70.07) 115.59,70.09 115.93,70.42 arc(116.05,70.51) 116.21,70.54 116.34,70.54 arc(116.52,70.5) 116.68,70.4 116.95,70.13 arc(117.03,70.07) 117.13,70.06 arc(117.27,70.09) 117.39,70.17 arc(117.41,70.2) 117.43,70.24 arc(117.43,70.25) 117.44,70.26 arc(117.44,70.27) 117.44,70.28 arc(117.44,70.28) 117.45,70.28 arc(117.86,70.57) 118.35,70.44 arc(118.73,70.31) 119.11,70.44 arc(119.19,70.5) 119.29,70.54 arc(119.37,70.56) 119.46,70.56 arc(119.5,70.56) 119.54,70.56 arc(119.54,70.56) 119.54,70.56 arc(119.63,70.56) 119.71,70.53 arc(119.82,70.48) 119.91,70.4 119.97,70.34 arc(120.34,70.19) 120.71,70.36 arc(121.08,70.55) 121.47,70.41 arc(121.81,70.28) 122.15,70.39 arc(122.68,70.54) 123.18,70.3 123.38,70.09 arc(123.54,70.01) 123.7,70.08 123.94,70.31 arc(124.2,70.49) 124.51,70.55 125.88,70.55 arc(126.01,70.58) 126.13,70.65 126.32,70.85 arc(126.68,71) 127.04,70.85 127.2,70.69 arc(127.35,70.58) 127.53,70.54 arc(127.75,70.47) 127.92,70.3 128.02,70.15 arc(128.09,70.08) 128.19,70.06 128.28,70.06 arc(128.35,70.07) 128.42,70.09 arc(128.52,70.16) 128.59,70.27 arc(128.62,70.32) 128.65,70.36 arc(129.15,70.52) 129.56,70.21 129.6,70.13 arc(129.61,70.11) 129.62,70.11 129.65,70.07 arc(129.72,70.02) 129.8,70 129.91,69.98 arc(129.95,69.98) 129.98,70 arc(129.98,70) 129.99,70 130.04,70.04 arc(130.1,70.1) 130.15,70.18 arc(130.24,70.33) 130.37,70.45 130.38,70.46 arc(130.39,70.47) 130.4,70.48 130.4,70.48 arc(130.41,70.48) 130.41,70.49 130.41,70.49 arc(130.78,70.57) 131.09,70.36 131.22,70.14 arc(131.31,70.06) 131.42,70.03 131.5,70.03 arc(131.63,70.06) 131.72,70.16 131.8,70.29 arc(132.22,70.55) 132.66,70.34 132.82,70.13 arc(132.86,70.1) 132.91,70.09 133.19,70.09 arc(133.23,70.09) 133.26,70.12 133.39,70.25 arc(133.41,70.26) 133.42,70.28 133.42,70.29 133.75,70.62 arc(133.77,70.64) 133.79,70.64 arc(133.81,70.65) 133.84,70.66 arc(133.87,70.68) 133.92,70.69 133.99,70.69 arc(134.01,70.69) 134.03,70.69 134.08,70.7 arc(134.12,70.71) 134.15,70.72 arc(134.27,70.79) 134.36,70.89 134.36,70.89 arc(134.57,71.11) 134.87,71.19 arc(134.87,71.19) 134.87,71.19 arc(135.16,71.11) 135.37,70.9 135.37,70.89 arc(135.52,70.74) 135.73,70.69 135.74,70.69 arc(135.94,70.74) 136.09,70.89 136.1,70.91 arc(136.6,71.2) 137.1,70.91 137.11,70.89 arc(137.11,70.89) 137.11,70.89 arc(137.26,70.74) 137.46,70.69 arc(137.47,70.69) 137.47,70.69 137.48,70.69 arc(137.67,70.74) 137.81,70.88 137.82,70.9 arc(138.31,71.17) 138.79,70.9 arc(138.95,70.74) 139.17,70.68 139.2,70.68 139.24,70.68 arc(139.43,70.74) 139.57,70.88 arc(140.06,71.17) 140.57,70.91 140.58,70.89 arc(140.58,70.89) 140.58,70.89 arc(140.73,70.74) 140.93,70.69 140.95,70.69 arc(141.13,70.73) 141.27,70.86 arc(141.27,70.87) 141.28,70.87 arc(141.8,71.17) 142.32,70.87 arc(142.64,70.67) 142.98,70.83 arc(143.1,70.97) 143.23,71.09 arc(143.34,71.15) 143.47,71.17 143.86,71.17 arc(144,71.22) 144.08,71.35 arc(144.09,71.39) 144.09,71.42 144.09,71.64 arc(144.08,71.68) 144.07,71.72
  L14_SIG5 w0.081: v1(170.29,93.36) 170.44,93.21 170.44,93.12 170.3,92.98 169.64,92.98 168.28,91.63 167.83,91.63 167.71,91.74 167.49,91.74 167.38,91.63 167.16,91.63 167.04,91.74 166.82,91.74 166.71,91.63 166.49,91.63 166.37,91.74 166.15,91.74 166.04,91.63 165.82,91.63 165.7,91.74 165.48,91.74 165.37,91.63 165.15,91.63 165.03,91.74 164.81,91.74 164.7,91.63 163.76,91.63 163.53,91.4 162.36,91.4 160.02,89.06 158.73,89.06 158.64,89.14 158.64,90.02 158.46,90.21 158.13,90.21 157.94,90.02 157.94,89.14 157.86,89.06 157.69,89.06 157.61,89.14 157.61,90.02 157.42,90.21 157.1,90.21 156.91,90.02 156.91,89.14 156.83,89.06 156.65,89.06 156.57,89.14 156.57,90.02 156.38,90.21 156.06,90.21 155.87,90.02 155.87,89.14 155.79,89.06 155.62,89.06 155.54,89.14 155.54,90.02 155.35,90.21 155.02,90.21 154.83,90.02 154.83,89.14 154.75,89.06 154.58,89.06 154.5,89.14 154.5,90.02 154.31,90.21 153.99,90.21 153.8,90.02 153.8,89.14 153.72,89.06 153.54,89.06 153.46,89.14 153.46,90.02 153.27,90.21 152.95,90.21 152.76,90.02 152.76,89.14 152.68,89.06 152.51,89.06 152.43,89.14 152.43,90.02 152.24,90.21 151.91,90.21 151.73,90.02 151.73,89.14 151.64,89.06 151.47,89.06 151.39,89.14 151.39,90.02 151.23,90.18 arc(151.2,90.2) 151.16,90.21 150.98,90.21 arc(150.78,90.12) 150.69,89.92 150.69,89.18 arc(150.65,89.1) 150.57,89.06 149.72,89.06 arc(149.69,89.06) 149.66,89.03 144.57,83.95 arc(144.55,83.92) 144.54,83.88 144.54,72.71 arc(144.54,72.68) 144.52,72.66 144.23,72.37 arc(144.11,72.19) 144.07,71.99 144.07,71.72
DDR4_DDIMM2_DQS_P3: length 59.1
  L12_SIG4 w0.089: v1(161,94.31) 161.2,94.31 161.29,94.4 161.29,95.06 161.2,95.15 160.8,95.15 160.42,94.77 160.42,94.57 160.27,94.43 160.08,94.43 159.94,94.3 159.94,93.54 160.24,93.24 160.24,92.87 157.31,89.94 155.71,89.94 155.1,89.33 146.84,89.33 146.27,88.76 145.8,88.76 145.66,88.62 145.46,88.62 145.32,88.76 144.92,88.76 144.83,88.67 144.83,87.45 144.6,87.22 144.31,87.22 144.11,87.42 144.11,88.67 144.02,88.76 143.85,88.76 143.77,88.67 143.77,86.4 143.55,86.18 143.25,86.18 143.04,86.39 143.04,88.67 142.95,88.76 137.27,88.76 137.16,88.65 137.16,88.43 137.03,88.3 136.81,88.3 136.68,88.17 136.68,87.95 136.54,87.81 136.32,87.81 136.13,87.62 136.13,87.49 136.78,86.84 136.78,86.56 136.56,86.34 136.25,86.34 135.61,86.98 135.49,86.98 135.11,86.6 134.39,86.6 133.66,85.86 133.66,85.45 134.07,85.04 134.07,84.75 133.85,84.52 133.56,84.52 133.09,84.99 132.97,84.99 132.48,84.5 130.43,84.5 130.06,84.87 129.67,84.87 128.56,83.77 128.34,83.77 128.25,83.68 128.25,83.18 128.05,82.98 127.72,82.98 127.51,83.18 127.51,83.68 127.43,83.77 127.25,83.77 127.04,83.97 126.66,83.97 126.43,83.74 126.43,83.28 125.02,81.87 125.02,80.59 v1(125.09,80.55)
DDR4_DDIMM2_DQS_P4: length 51.9
  L03_SIG1 w0.076: 115.3,87.63 115.31,87.61 115.31,87.61 115.35,87.57 115.35,87.28 115.5,87.14 115.5,86.95 115.35,86.81 115.35,84.62 115.17,84.44 114.71,84.44 114.63,84.36 114.63,84.19 114.71,84.11 115.35,84.11 115.53,83.93 115.53,83.63 115.32,83.42 114.71,83.42 114.63,83.35 114.63,83.17 114.71,83.09 115.02,83.09 115.35,82.77 115.35,80.99 115.24,80.8 115.27,80.7 v2(115.54,80.54)
  L03_SIG1 w0.081: v1(105.69,93.34) 105.8,93.34 105.88,93.43 105.88,95.09 105.77,95.21 105.77,95.43 105.88,95.54 105.88,95.76 105.77,95.88 105.77,96.1 105.88,96.21 105.88,96.7 107.08,97.89 107.37,97.89 107.56,97.7 107.56,97.18 107.64,97.1 107.88,97.1 107.96,97.18 107.96,97.74 108.15,97.93 108.48,97.93 108.66,97.74 108.66,97.18 108.75,97.1 108.99,97.1 109.17,96.91 109.17,96.59 108.99,96.4 107.64,96.4 107.56,96.32 107.56,96.15 107.64,96.07 108.99,96.07 109.18,95.88 109.18,95.59 108.95,95.36 107.24,95.36 106.98,95.11 106.98,93.93 107.21,93.7 107.21,92.73 107.89,92.05 108.31,92.05 108.5,91.86 108.5,91.34 108.58,91.25 108.76,91.25 108.84,91.34 108.84,91.86 109.03,92.05 110.88,92.05 111.59,91.33 111.59,91.07 110.73,90.21 110.73,90.09 110.85,89.97 110.97,89.97 111.83,90.83 112.1,90.83 112.33,90.6 112.33,90.33 111.46,89.47 111.46,89.36 111.59,89.24 111.7,89.24 112.56,90.1 112.83,90.1 113.06,89.87 113.06,89.6 112.2,88.74 112.2,88.62 112.32,88.5 112.43,88.5 113.3,89.36 113.56,89.36 113.79,89.13 113.79,88.87 113.14,88.22 113.14,88.1 113.26,87.98 113.38,87.98 114.03,88.63 114.29,88.63 114.65,88.28 114.65,88.01 114.08,87.44 114.08,87.32 114.2,87.2 114.32,87.2 114.89,87.77 115.15,87.77 115.3,87.63
DDR4_DDIMM2_DQS_P5: length 51.8
  L03_SIG1 w0.081: v1(96.34,93.34) 96.4,93.4 arc(96.52,93.58) 96.56,93.78 96.56,94.37 arc(96.56,94.41) 96.55,94.45 arc(96.51,94.59) 96.44,94.72 96.37,94.82 96.23,95.22 96.23,95.23 96.23,96.27 96.26,96.41 96.76,96.91 96.93,96.91 97.37,96.91 97.67,96.6 97.67,96.09 97.75,96.01 98.33,96.01 98.52,95.82 98.52,95.5 98.33,95.31 97.75,95.31 97.67,95.23 97.67,93.89 97.9,93.67 97.9,92.42 97.71,92.24 96.59,92.24 96.51,92.15 96.51,91.98 96.59,91.9 97.71,91.9 97.9,91.71 97.9,90.9 98.53,90.27 98.64,90.27 99.61,91.24 99.88,91.24 100.11,91.01 100.11,90.75 99.14,89.78 99.14,89.66 99.26,89.54 99.38,89.54 100.35,90.51 100.61,90.51 100.84,90.28 100.84,90.01 99.87,89.04 99.87,88.93 99.99,88.81 100.11,88.81 101.08,89.78 101.34,89.78 101.57,89.55 101.57,89.28 100.6,88.31 100.6,88.2 100.73,88.07 100.84,88.07 101.81,89.04 102.08,89.04 102.31,88.81 102.31,88.55 101.34,87.58 101.34,87.46 101.46,87.34 101.57,87.34 102.54,88.31 102.81,88.31 103.04,88.08 103.04,87.82 102.07,86.85 102.07,86.73 102.19,86.61 102.31,86.61 103.28,87.58 103.54,87.58 103.77,87.35 103.77,87.08 102.8,86.11 102.8,86 103.14,85.66 103.25,85.66 103.74,86.15 104.01,86.15 104.24,85.92 104.24,85.66 103.75,85.17 103.75,85.05 104.39,84.41 104.51,84.41 104.96,84.85 105.22,84.85 105.45,84.62 105.45,84.36 105.01,83.91 105.01,83.79 105.13,83.67 105.24,83.67 105.69,84.12 105.96,84.12 106.19,83.89 106.19,83.62 105.74,83.18 105.74,83.06 105.95,82.85 105.95,82.52 105.76,82.34 105.38,82.34 105.3,82.25 105.3,82.08 105.38,82 105.76,82 105.95,81.81 105.95,81.27 105.76,80.94 105.85,80.62 v2(105.96,80.55)
DDR4_DDIMM2_DQS_P6: length 52.5
  L05_SIG2 w0.076: v1(110.74,80.55) 110.49,80.7 110.38,80.67 110.32,80.56 110.23,80.46 109.89,80.46 arc(109.73,80.5) 109.59,80.59 109.56,80.61 arc(109.44,80.8) 109.4,81.01 109.4,81.11 arc(109.39,81.15) 109.37,81.17 107.83,82.71 107.83,82.71 107.82,82.72
  L05_SIG2 w0.081: 107.82,82.72 106.62,83.92 102.62,83.92 102.43,84.11 102.43,86.27 102.34,86.37 102.18,86.37 102.09,86.28 102.09,84.11 101.91,83.92 101.58,83.92 101.39,84.11 101.39,86.25 101.31,86.33 101.15,86.33 101.06,86.24 101.06,84.11 100.87,83.92 100.55,83.92 100.36,84.11 100.36,86.21 100.28,86.29 100.11,86.29 100.02,86.2 100.02,84.11 99.83,83.92 99.51,83.92 99.32,84.11 99.32,86.09 99.23,86.18 99.07,86.18 98.99,86.1 98.99,84.11 98.8,83.92 98.47,83.92 98.28,84.11 98.28,85.99 98.2,86.07 98.03,86.07 97.95,85.99 97.95,84.11 97.76,83.92 94.31,83.92 87.19,91.04 87.19,91.6 87.34,91.75 87.34,91.96 87.21,92.09 87.21,92.41 87.31,92.51 87.31,92.72 87.19,92.84 87.19,93.15 v1(86.99,93.34)
DDR4_DDIMM2_DQS_P7: length 65.8
  L14_SIG5 w0.076: v1(112.34,75.95) 112.07,76.1 112.05,76.19 arc(112.09,76.44) 112.02,76.68 arc(111.97,76.86) 112,77.03 112.02,77.05 arc(112.09,77.33) 112.02,77.6 112.02,77.6 arc(111.97,77.79) 112.02,77.97 112.02,77.97 arc(112.09,78.25) 112.02,78.52 112.02,78.53 arc(111.97,78.71) 112.02,78.89 112.02,78.9 arc(112.09,79.17) 112.02,79.44 112.01,79.46 arc(111.96,79.62) 112,79.79 112.01,79.8 arc(112.01,79.81) 112.02,79.81 arc(112.03,79.84) 112.05,79.86 arc(112.09,80.04) 112.08,80.22 arc(112.04,80.3) 111.99,80.37 111.86,80.5 arc(111.71,80.6) 111.53,80.64 111.42,80.64 arc(111.38,80.64) 111.35,80.66 arc(111.31,80.69) 111.27,80.73 111.2,80.86 arc(111.17,80.92) 111.15,80.99 111.15,80.99 111.16,81 111.16,81.01
  L14_SIG5 w0.081: v1(77.58,93.36) 77.78,93.16 77.95,93.16 78.07,93.28 78.07,93.49 78.07,93.49 78.07,93.79 77.82,94.04 77.6,94.04 77.12,93.56 77.12,93.08 77.97,92.23 77.97,91.73 78.87,90.84 80.49,90.84 80.98,90.35 87.06,90.35 88.44,88.97 91.24,88.97 94.29,85.93 97.23,85.93 97.67,86.37 101.27,86.37 101.53,86.12 101.53,85.42 101.61,85.34 101.78,85.34 101.86,85.42 101.86,86.12 102.05,86.3 102.37,86.3 102.56,86.12 102.56,85.43 102.64,85.35 102.82,85.35 102.9,85.43 102.9,86.12 103.09,86.3 103.91,86.3 104.19,86.03 104.19,84.86 104.44,84.61 104.97,84.61 105.05,84.69 105.05,86.16 105.24,86.35 105.56,86.35 105.75,86.16 105.75,84.69 105.83,84.61 106.71,84.61 106.79,84.69 106.79,86.24 106.98,86.43 107.3,86.43 107.49,86.24 107.49,85.97 107.57,85.89 108.04,85.89 108.23,85.7 108.23,85.38 108.04,85.19 107.57,85.19 107.49,85.11 107.49,84.69 107.57,84.61 110.31,84.61 111.16,83.76 111.16,83.51 111.24,83.43 112.17,83.43 112.36,83.24 112.36,82.92 112.17,82.73 111.24,82.73 111.16,82.65 111.16,82.48 111.24,82.39 112.17,82.39 112.36,82.21 112.36,81.88 112.17,81.69 111.24,81.69 111.16,81.61 111.16,81.01
DDR4_DDIMM2_DQS_P8: length 55.8
  L12_SIG4 w0.089: v1(151.59,94.21) 151.86,94.21 152.04,94.39 152.04,95.54 152.26,95.76 153.04,95.76 153.94,94.86 154.32,94.86 154.52,95.05 154.52,95.29 154.16,95.65 154.16,96.18 154.85,96.87 154.85,96.99 154.56,97.28 154.29,97.28 153.43,96.42 151.98,96.42 151.13,95.57 151.13,95.44 151.4,95.17 151.4,94.89 151.17,94.66 150.89,94.66 150.62,94.93 150.5,94.93 149.42,93.86 146.47,93.86 146.07,93.45 145.4,93.45 145.25,93.6 144.2,93.6 144.11,93.52 144.11,93.42 143.91,93.22 143.59,93.22 143.38,93.42 143.38,94.04 143.29,94.13 143.13,94.13 143.04,94.04 143.04,93.41 142.84,93.21 142.52,93.21 142.32,93.41 142.32,93.64 142.23,93.73 135.78,93.73 arc(135.69,93.71) 135.61,93.66 134.1,92.15 131.51,92.15 arc(131.46,92.14) 131.43,92.12 129.66,90.36 arc(129.57,90.29) 129.45,90.27 128.6,90.27 arc(128.55,90.26) 128.52,90.23 126.81,88.53 124.22,88.53 122.29,86.59 120.89,86.59 120.13,85.83 120.13,84.32 arc(120.08,84.07) 119.93,83.86 119.83,83.75 arc(119.73,83.6) 119.69,83.42 119.69,82.14 arc(119.73,81.95) 119.84,81.79 120.12,81.5 arc(120.18,81.44) 120.22,81.36 arc(120.23,81.14) 120.12,80.95 119.99,80.82 arc(119.96,80.65) 120.1,80.55 v1(120.31,80.55)
DDR4_DDIMM2_PAR: length 85.8
  L12_SIG4 w0.089: v1(125.22,94.64) 125.38,94.8 125.38,95.01 125.29,95.1 125.16,95.1 125.07,95.19 125.07,95.35 125.16,95.44 125.29,95.44 125.38,95.53 125.38,95.7 125.29,95.78 125.16,95.78 125.07,95.87 125.07,96.04 125.16,96.13 125.29,96.13 125.38,96.22 125.38,96.54 125.23,96.69 124.73,96.69 124.64,96.6 124.64,95.75 124.55,95.66 124.38,95.66 124.3,95.75 124.3,96.6 124.21,96.69 124.04,96.69 123.95,96.6 123.95,95.75 123.86,95.66 123.7,95.66 123.61,95.75 123.61,97.18 123.52,97.26 123.36,97.26 123.27,97.18 123.27,95.75 123.18,95.66 123.01,95.66 122.92,95.75 122.92,96.71 122.82,96.81 122.67,96.81 122.58,96.72 122.58,95.77 122.49,95.68 122.31,95.68 122.19,95.8 122.19,96 122.1,96.09 121.92,96.09 121.84,96.17 121.84,96.34 121.92,96.43 122.1,96.43 122.19,96.52 122.19,96.79 122.03,96.94 122.03,97.34 121.88,97.49 121.47,97.49 121.38,97.4 121.38,95.77 121.29,95.67 121.13,95.67 121.04,95.76 121.04,97.4 120.95,97.49 120.79,97.49 120.7,97.4 120.7,95.77 120.6,95.67 120.44,95.67 120.36,95.76 120.36,97.4 120.27,97.49 120.1,97.49 119.75,97.15 119.42,97.15 119.14,96.87 119.14,96.75 119.86,96.03 119.86,95.9 119.75,95.79 119.62,95.79 118.9,96.5 118.78,96.5 118.66,96.39 118.66,96.26 119.04,95.88 119.04,95.75 118.93,95.64 118.8,95.64 118.42,96.02 118.29,96.02 118.17,95.9 118.17,95.09 117.99,94.91 117.99,94.8 118.08,94.71 118.8,94.71 118.88,94.62 118.88,94.46 118.8,94.37 118.08,94.37 117.99,94.28 117.99,94.26 117.76,94.03 117.2,94.03 117.03,93.86 117.03,93.02 117.13,92.92 117.53,92.92 117.62,93 117.62,93.57 117.71,93.66 117.88,93.66 117.96,93.57 117.96,92.35 118.19,92.13 118.77,92.13 118.86,92.22 118.86,93.88 118.95,93.97 119.11,93.97 119.2,93.88 119.2,92.22 119.29,92.13 119.45,92.13 119.8,92.47 120.11,92.47 120.44,92.14 120.44,91.6 120.24,91.4 117.14,91.4 116.19,90.45 115.06,90.45 114.73,90.12 114.39,90.12 112.56,88.29 112.56,87.72 113.6,86.68 113.6,83.91 112.99,83.3 112.99,82.64 112.82,82.47 112.82,81.87 113.17,81.53 113.5,80.72 113.8,80.42 arc(113.89,80.29) 113.92,80.13 113.92,79.69 arc(113.98,79.39) 114.16,79.13 114.25,79.04 arc(114.3,78.96) 114.31,78.87 114.31,78.36 arc(114.3,78.12) 114.27,77.88 arc(114.27,77.84) 114.27,77.81 arc(114.26,77.73) 114.24,77.65 arc(114.2,77.56) 114.16,77.46 arc(114.15,77.27) 114.22,77.1 arc(114.23,76.64) 113.79,76.52 arc(113.67,76.53) 113.57,76.47 arc(113.53,76.4) 113.5,76.32 arc(113.4,76.15) 113.23,76.05 arc(113.13,76.01) 113.05,75.95 112.62,75.51 arc(112.49,75.43) 112.35,75.4 arc(112.13,75.34) 111.99,75.17 arc(111.83,74.99) 111.59,74.94 arc(111.33,74.88) 111.18,74.66 arc(111.13,74.58) 111.06,74.53 arc(110.98,74.5) 110.9,74.48 arc(110.86,74.47) 110.81,74.48 arc(110.78,74.48) 110.74,74.48 arc(110.56,74.44) 110.42,74.31 110.33,74.21 arc(110.28,74.09) 110.33,73.97 110.44,73.85 arc(110.66,73.74) 110.89,73.77 arc(110.99,73.83) 111.07,73.92 arc(111.11,73.98) 111.18,74.01 arc(111.33,74.04) 111.49,74.03 arc(111.65,74.07) 111.79,74.16 112.01,74.38 arc(112.19,74.5) 112.41,74.55 arc(112.51,74.57) 112.59,74.62 112.99,75.02 arc(113.05,75.07) 113.1,75.12 arc(113.14,75.14) 113.19,75.16 arc(113.3,75.19) 113.39,75.26 arc(113.42,75.29) 113.46,75.31 arc(113.61,75.35) 113.75,75.38 arc(113.77,75.38) 113.79,75.38 arc(114.15,75.33) 114.31,75 114.27,74.47 arc(114.29,74.29) 114.39,74.13 arc(114.43,74.09) 114.47,74.06 arc(114.55,74.01) 114.64,74.01 arc(114.89,73.99) 115.07,73.81 arc(115.12,73.74) 115.21,73.71 arc(115.31,73.7) 115.4,73.69 arc(115.64,73.71) 115.87,73.74 arc(115.94,73.77) 115.99,73.83 arc(116.18,74) 116.44,74.01 arc(116.52,74) 116.59,74.02 arc(116.63,74.05) 116.67,74.07 arc(116.72,74.12) 116.75,74.19 arc(116.86,74.38) 117.05,74.48 arc(117.16,74.51) 117.25,74.58 117.52,74.85 arc(117.62,75.11) 117.52,75.37 117.38,75.51 arc(117.21,75.58) 117.05,75.51 116.59,75.05 arc(116.54,75.01) 116.49,74.97 arc(116.43,74.94) 116.37,74.94 arc(116.26,74.94) 116.16,74.91 arc(116.09,74.88) 116.01,74.87 115.9,74.87 arc(115.7,74.91) v1(115.53,75.03)
DDR4_DDIMM2_RESET_N: length 87
  L12_SIG4 w0.089: v1(147.34,98.64) 147.26,98.56 146.78,98.56 146.63,98.71 146.63,98.97 146.72,99.06 147.44,99.06 147.56,99.18 147.56,99.31 147.47,99.4 146.72,99.4 146.63,99.49 146.63,99.56 146.54,99.65 146.37,99.65 146.23,99.51 146.23,98.56 146.12,98.44 145.99,98.44 145.16,99.28 144.49,99.28 144.04,98.84 143.05,98.84 142.6,99.28 141.88,99.28 141.54,98.94 141.05,98.94 140.89,98.77 140.71,98.77 140.54,98.94 140.25,98.94 139.9,99.28 139.48,99.28 139.14,98.94 138.73,98.94 138.57,98.78 138.38,98.78 138.22,98.94 137.83,98.94 137.49,99.28 136.28,99.28 136.18,99.18 135.36,99.18 135.22,99.04 135.22,98.92 135.14,98.83 134.97,98.83 134.88,98.92 134.88,99.04 134.79,99.13 134.49,99.13 133.96,98.6 133.83,98.6 133.33,99.1 133.2,99.1 133.09,98.98 133.09,98.86 133.94,98 133.94,97.85 133.83,97.74 133.64,97.74 132.7,98.67 132.58,98.67 132.43,98.53 132.43,98.37 133.25,97.55 133.25,97.38 132.99,97.12 132.82,97.12 132.34,97.6 131.76,97.6 131.57,97.79 131.57,98.71 131.44,98.83 130.9,98.83 130.82,98.75 130.82,97.84 130.99,97.66 130.99,97.36 130.79,97.15 130.56,97.15 130.33,97.38 130.33,97.51 130.4,97.58 130.4,97.71 130.29,97.82 130.16,97.82 130.09,97.75 129.96,97.75 129.81,97.9 129.81,98.03 129.91,98.13 129.91,98.26 129.8,98.38 129.67,98.38 129.57,98.27 129.44,98.27 129.29,98.42 129.17,98.42 129.08,98.34 129.08,98.15 130.32,96.91 130.32,96.78 129.74,96.2 129.61,96.2 128.8,97.01 128.8,97.13 129.03,97.36 129.03,97.48 128.91,97.6 128.79,97.6 128.56,97.38 128.44,97.38 128.28,97.53 128.16,97.53 128.04,97.41 128.04,97.29 128.66,96.67 128.66,96.54 128.4,96.28 128.4,96.15 128.51,96.04 128.64,96.04 128.9,96.3 129.03,96.3 129.37,95.96 129.37,95.83 129.18,95.64 128.73,95.64 127.11,94.02 126.98,94.02 126.61,94.4 126.48,94.4 126.37,94.28 126.37,94.15 126.74,93.78 126.74,93.65 126.63,93.53 126.5,93.53 126.12,93.91 126,93.91 125.88,93.79 125.88,93.67 126.26,93.29 126.26,93.17 126.11,93.02 123.17,93.02 120.71,90.56 119.48,90.56 119.32,90.4 119.2,90.4 118.77,90.83 118.65,90.83 118.53,90.71 118.53,90.59 118.95,90.16 118.95,90.03 118.84,89.92 118.71,89.92 118.29,90.34 118.16,90.34 118.04,90.23 118.04,90.1 118.47,89.68 118.47,89.55 118.35,89.43 118.23,89.43 117.8,89.86 117.68,89.86 117.56,89.74 117.56,89.62 117.98,89.19 117.98,89.06 117.87,88.95 117.74,88.95 117.32,89.37 117.19,89.37 117.07,89.26 117.07,89.13 117.5,88.71 117.5,88.58 117.36,88.44 116.86,88.44 116.26,87.84 116.13,87.84 115.33,88.65 115.2,88.65 115.09,88.53 115.09,88.41 115.89,87.6 115.89,87.48 114.98,86.56 114.54,86.56 114.3,86.31 114.3,84.75 114.51,84.53 114.64,84.53 114.85,84.74 115.03,84.74 115.12,84.65 115.12,84.52 114.88,84.29 114.88,84.16 115,84.04 115.12,84.04 115.28,84.2 115.41,84.2 115.53,84.09 115.53,83.96 115.37,83.8 115.37,83.67 115.56,83.48 115.56,81.33 116.66,80.23 116.66,80.06 116.72,80 116.72,79.4 arc(116.78,79.17) 116.72,78.94 arc(116.66,78.71) 116.72,78.48 116.73,78.46 arc(116.9,78.3) 117.12,78.25 117.12,78.25 arc(117.35,78.19) 117.52,78.02 arc(117.58,77.79) 117.52,77.56 117.52,77.56 arc(117.46,77.33) 117.52,77.1 v1(117.92,76.41)
  BOTTOM w0.149: v1(147.34,98.64) R88.2 146.71,99.38 R87.1
DDR4_DDIMM2_RZQ: length 6
  BOTTOM w0.149: v1(118.71,76.87) 118.31,77.56 arc(118.25,77.79) 118.31,78.02 arc(118.38,78.25) 118.31,78.48 118.31,78.48 arc(118.25,78.71) 118.31,78.94 arc(118.38,79.17) 118.32,79.4 118.31,79.4 arc(118.25,79.63) 118.31,79.86 arc(118.38,80.09) 118.32,80.31 118.3,80.35 arc(118.25,80.57) 118.31,80.78 arc(118.36,80.89) 118.37,81.01 118.37,81.33 117.91,81.79 R37.1
DDR4_DDIMM2_TDQS_N9: length 120.4
  L12_SIG4 w0.076: v1(107.56,76.87) 107.81,77.02 arc(107.85,77.06) 107.84,77.12 107.81,77.18 arc(107.8,77.19) 107.8,77.19 107.75,77.24 arc(107.72,77.26) 107.69,77.27 arc(107.68,77.28) 107.67,77.28 107.57,77.28 arc(107.36,77.32) 107.19,77.44 arc(107.1,77.55) 107.04,77.69 arc(107.03,77.83) 107.07,77.95 107.14,78.12 arc(107.16,78.16) 107.15,78.2 107.13,78.32 arc(107.12,78.37) 107.09,78.42 arc(107.03,78.57) 107,78.74 107,78.93 arc(107.05,79.15) 107.17,79.33 107.4,79.56 arc(107.45,79.63) 107.46,79.72 107.46,80.99 107.45,81.01 107.45,81.04
  L12_SIG4 w0.089: v1(189.84,99.34) 190.18,99.01 190.18,97.91 190.09,97.83 189.65,97.83 189.56,97.91 189.56,98.88 189.08,99.36 189.08,99.73 189.22,99.87 190.07,99.87 190.28,100.07 190.28,100.49 190.08,100.69 188.78,100.69 188.57,100.89 188.57,101.29 188.92,101.63 188.92,102.02 187.28,103.66 186.43,103.66 186.15,103.38 185.97,103.38 185.69,103.66 185.36,103.66 185.08,103.38 184.9,103.38 184.62,103.66 184.29,103.66 184.01,103.38 183.84,103.38 183.56,103.66 179.46,103.66 179.45,103.66 178.36,103.66 178.36,103.66 171.97,103.66 171.78,103.85 164.8,103.85 162.12,103.85 161.32,104.65 159.94,104.65 159.74,104.45 159.74,104.11 159.65,104.02 159.49,104.02 159.4,104.11 159.4,104.45 159.2,104.65 154.51,104.65 153.72,103.86 150.24,103.86 150.15,103.95 150.15,104.41 149.95,104.61 149.63,104.61 149.36,104.34 149.15,104.34 148.89,104.61 148.56,104.61 148.36,104.41 148.36,103.95 148.28,103.86 148.11,103.86 148.02,103.95 148.02,104.41 147.82,104.61 147.5,104.61 147.3,104.41 147.3,103.95 147.21,103.86 145.81,103.86 145.63,103.68 144.85,103.68 140.6,103.68 140.5,103.57 129.84,103.57 129.39,103.12 129.1,103.12 127.65,101.67 126.02,101.67 124.89,102.8 123.99,102.8 123.91,102.89 123.91,103.17 123.71,103.37 123.38,103.37 123.18,103.17 123.18,102.89 123.05,102.75 120.77,102.75 120.68,102.84 120.68,103.22 120.48,103.42 120.16,103.42 119.96,103.22 119.96,102.84 119.87,102.75 119.06,102.75 117.76,101.46 117.36,101.46 117.14,101.24 117.14,100.83 116.84,100.53 116.28,100.53 113.84,98.09 113.84,97.2 113.5,96.86 112.79,96.86 111.72,95.79 111.72,95.38 111.25,94.91 111.25,93.89 111.03,93.67 111.03,93.15 107.45,89.57 107.45,81.04
DDR4_DDIMM2_TDQS_N10: length 94.7
  L12_SIG4 w0.076: v1(121.9,76.87) 122.16,77.02 122.16,77.1 arc(122.15,77.12) 122.14,77.14 arc(122.03,77.21) 121.9,77.24 arc(121.72,77.2) 121.59,77.07 121.56,77.02 arc(121.53,76.95) 121.53,76.87 121.53,76.82 arc(121.54,76.81) 121.54,76.8 arc(121.54,76.78) 121.54,76.75 arc(121.55,76.74) 121.55,76.72 121.57,76.69 arc(121.61,76.63) 121.66,76.58 arc(121.7,76.54) 121.75,76.51 arc(121.79,76.5) 121.83,76.5 121.92,76.5 arc(122.19,76.42) 122.38,76.22 arc(122.4,76.18) 122.42,76.15 122.44,76.13 arc(122.51,76.07) 122.6,76.04 arc(122.64,76.03) 122.68,76.04 arc(122.72,76.04) 122.76,76.04 arc(122.79,76.04) 122.82,76.04 122.82,76.04 arc(123.01,75.95) 123.15,75.8 123.16,75.78 arc(123.16,75.78) 123.16,75.78 123.18,75.75 arc(123.31,75.62) 123.49,75.58 arc(123.76,75.51) 123.96,75.31 123.97,75.3 arc(124.11,75.17) 124.29,75.12 124.3,75.12 arc(124.57,75.04) 124.77,74.84 124.82,74.75 arc(124.88,74.69) 124.98,74.66 125.09,74.66 125.1,74.66 arc(125.37,74.58) 125.56,74.38 arc(125.69,74.25) 125.87,74.2 125.89,74.2 arc(126.07,74.25) 126.2,74.38 arc(126.41,74.58) 126.69,74.66 arc(126.79,74.67) 126.89,74.71 arc(126.94,74.75) 126.99,74.81 127,74.83 arc(127.08,74.95) 127.19,75.04 arc(127.33,75.1) 127.48,75.12 127.48,75.12 arc(127.66,75.17) 127.8,75.3 arc(128,75.5) 128.27,75.58 128.28,75.58 arc(128.46,75.63) 128.6,75.76 arc(128.79,75.96) 129.06,76.04 129.07,76.04 arc(129.25,76.09) 129.39,76.22 129.4,76.23 arc(129.6,76.43) 129.87,76.5 arc(130.05,76.55) 130.19,76.68 130.25,76.79 arc(130.37,76.91) 130.54,76.96 130.67,76.96 arc(130.94,76.88) 131.14,76.68 arc(131.27,76.55) 131.46,76.5 131.46,76.5 arc(131.73,76.43) 131.94,76.23 131.94,76.22 arc(132.07,76.09) 132.26,76.04 132.26,76.04 arc(132.45,76.09) 132.58,76.22 arc(132.78,76.42) 133.05,76.5 133.06,76.5 133.07,76.5 133.21,76.5 133.66,76.96 133.85,76.96 138.45,76.96 arc(138.53,76.97) 138.59,77.02 138.88,77.31 arc(139,77.39) 139.15,77.42 139.41,77.42 arc(139.44,77.42) 139.46,77.43 139.58,77.46 139.85,77.72 arc(140.02,77.84) 140.22,77.88 140.29,77.88 arc(140.45,77.84) 140.59,77.75 140.83,77.52 arc(140.86,77.49) 140.89,77.47 140.91,77.46 arc(141.07,77.44) 141.22,77.51 arc(141.22,77.52) 141.22,77.52 141.38,77.67 arc(141.41,77.7) 141.45,77.73 arc(141.46,77.74) 141.47,77.75 arc(141.49,77.77) 141.52,77.78 arc(141.52,77.79) 141.53,77.8 arc(141.55,77.81) 141.56,77.82 arc(141.57,77.82) 141.58,77.83 arc(141.69,77.87) 141.81,77.88 arc(141.81,77.88) 141.81,77.88 arc(141.89,77.87) 141.96,77.86 arc(142.22,77.7) 142.36,77.43 142.36,77.43 arc(142.38,77.37) 142.42,77.32 arc(142.45,77.3) 142.49,77.3 142.78,77.3 arc(143.1,77.36) 143.38,77.55 143.58,77.75 arc(143.76,77.87) 143.96,77.91 144.51,77.91
  L12_SIG4 w0.089: 144.51,77.91 144.56,77.86 147.2,77.86 149.22,75.83 156.03,75.83 157.08,76.88 161.71,76.88 166.45,81.61 166.45,85.54 172.03,91.12 173.9,91.12 174.78,92 175.73,92 175.91,92.17 176.07,92.17 176.25,92 176.42,92 176.59,92.17 176.76,92.17 176.93,92 177.1,92 177.28,92.17 177.45,92.17 177.62,92 177.79,92 177.96,92.17 178.13,92.17 178.31,92 178.47,92 178.65,92.17 178.82,92.17 178.99,92 179.16,92 179.33,92.17 179.5,92.17 179.68,92 180.02,92 180.99,92.97 180.99,93.64 180.75,93.88 179.59,93.88 179.09,93.39 177.79,93.39 177.28,93.9 177.28,94.16 177.19,94.25 176.18,94.25 175.98,94.45 175.98,94.78 176.18,94.98 176.47,94.98 176.62,95.13 176.81,95.13 176.96,94.98 177.19,94.98 177.28,95.07 177.28,95.76 177.64,96.11 177.92,96.11 178.47,95.57 178.59,95.57 178.71,95.68 178.71,95.81 178.16,96.36 178.16,96.8 178.5,97.13 179.68,97.13 179.88,96.93 179.88,95.65 179.97,95.56 180.14,95.56 180.23,95.65 180.23,96.93 180.43,97.13 180.62,97.13 180.82,97.34 180.82,97.86 180.73,97.95 v1(180.49,97.95)
DDR4_DDIMM2_TDQS_N11: length 97.9
  L14_SIG5 w0.076: 134.75,70.15 134.73,70.15 arc(134.73,70.15) 134.73,70.15 134.67,70.14 134.67,70.12 arc(134.59,70.08) 134.52,70.03 134.39,69.89 arc(134.36,69.87) 134.32,69.84 arc(134.2,69.77) 134.06,69.72 arc(133.9,69.64) 133.75,69.53 133.69,69.47 arc(133.64,69.42) 133.58,69.37 133.33,69.19 arc(133.29,69.16) 133.26,69.13 arc(133.22,69.11) 133.18,69.11 133.12,69.11 arc(133.11,69.11) 133.11,69.11 arc(133.09,69.11) 133.07,69.11 arc(132.87,69.17) 132.73,69.32 arc(132.53,69.52) 132.25,69.6 arc(131.98,69.52) 131.78,69.32 131.78,69.32 arc(131.46,69.14) 131.14,69.32 131.14,69.33 arc(130.94,69.52) 130.67,69.6 130.66,69.6 arc(130.39,69.52) 130.19,69.32 arc(130.05,69.19) 129.87,69.14 129.87,69.14 arc(129.68,69.19) 129.55,69.32 129.54,69.33 arc(129.34,69.53) 129.07,69.6 129.06,69.6 arc(128.79,69.52) 128.6,69.32 arc(128.46,69.19) 128.28,69.14 128.27,69.14 arc(128.09,69.19) 127.96,69.32 127.94,69.34 arc(127.75,69.53) 127.49,69.6 127.46,69.6 arc(127.2,69.52) 127,69.32 arc(126.87,69.19) 126.69,69.14 126.68,69.14 arc(126.5,69.18) 126.36,69.31 126.36,69.32 arc(126.32,69.38) 126.27,69.44 126.11,69.6 125.87,69.6 arc(125.6,69.52) 125.41,69.32 arc(125.28,69.19) 125.1,69.14 125.09,69.14 arc(124.91,69.18) 124.77,69.31 124.76,69.34 arc(124.65,69.46) 124.51,69.55 arc(124.44,69.57) 124.37,69.58 124.16,69.58 arc(124.05,69.56) 123.97,69.5 123.9,69.44 arc(123.85,69.38) 123.81,69.32 arc(123.68,69.19) 123.5,69.14 123.49,69.14 arc(123.31,69.18) 123.18,69.31 123.16,69.34 arc(122.97,69.53) 122.72,69.6 122.68,69.6 arc(122.47,69.55) 122.3,69.43 arc(121.91,69.26) 121.51,69.43 arc(121.01,69.59) 120.6,69.27 120.57,69.21 arc(120.55,69.18) 120.52,69.17 120.49,69.16 120.46,69.15 arc(120.17,69.2) 119.95,69.39 arc(119.85,69.5) 119.73,69.58 arc(119.64,69.61) 119.54,69.62 arc(119.5,69.62) 119.46,69.62 arc(119.36,69.62) 119.27,69.59 arc(119.16,69.53) 119.08,69.45 118.91,69.26 arc(118.91,69.25) 118.9,69.24 arc(118.82,69.17) 118.71,69.14 118.68,69.14 arc(118.66,69.14) 118.64,69.14 arc(118.5,69.21) 118.39,69.32 118.39,69.32 arc(118.19,69.52) 117.92,69.6 117.89,69.6 arc(117.63,69.52) 117.44,69.32 arc(117.31,69.19) 117.13,69.14 117.12,69.14 arc(116.93,69.19) 116.8,69.32 116.8,69.32 arc(116.8,69.33) 116.79,69.33 arc(116.59,69.53) 116.32,69.6 116.3,69.6 arc(116.04,69.52) 115.85,69.32 arc(115.72,69.19) 115.54,69.14 115.52,69.14 arc(115.35,69.18) 115.21,69.31 115.19,69.34 arc(115.01,69.52) 114.77,69.6 arc(114.55,69.66) 114.37,69.8 arc(114.26,69.91) 114.11,69.98 113.84,70.06 arc(113.8,70.08) 113.77,70.1 113.51,70.37 arc(113.42,70.45) 113.32,70.5 arc(113.25,70.52) 113.18,70.53 113.03,70.53 arc(112.94,70.54) 112.87,70.58 arc(112.81,70.64) 112.76,70.71 arc(112.7,70.8) 112.62,70.87 112.57,70.9 arc(112.51,70.93) 112.45,70.95 112.33,70.98 arc(112.31,70.98) 112.29,70.98 arc(112.23,71) 112.17,71.02 arc(112.11,71.05) 112.06,71.09 arc(112.04,71.12) 112.02,71.15 arc(112.01,71.18) 111.99,71.2 arc(111.96,71.31) 111.97,71.42 112,71.57 arc(112.01,71.61) 112.02,71.64 arc(112.04,71.7) 112.05,71.76 arc(112.05,71.8) 112.06,71.84 112.06,71.86 arc(112.07,71.96) 112.03,72.05 112.03,72.05 arc(112,72.09) 111.97,72.12 arc(111.97,72.12) 111.97,72.13 arc(111.8,72.25) 111.61,72.32 111.56,72.33 arc(111.52,72.34) 111.48,72.34 111.46,72.34 arc(111.35,72.37) 111.27,72.46 111.22,72.54 arc(111.17,72.73) 111.22,72.91 111.22,72.92 arc(111.35,73.05) 111.52,73.1 111.54,73.1 arc(111.72,73.05) 111.86,72.92 111.86,72.91 arc(111.88,72.87) 111.9,72.82 arc(111.9,72.81) 111.9,72.8 arc(111.9,72.8) 111.9,72.79 arc(111.91,72.76) 111.91,72.73 arc(111.89,72.68) 111.85,72.65 111.65,72.65 arc(111.62,72.66) 111.59,72.68 v1(111.54,72.73)
  L14_SIG5 w0.081: v1(171.14,99.34) 171.4,99.34 171.48,99.26 171.48,98.85 171.34,98.71 171.34,98.51 171.48,98.38 171.48,98.18 171.34,98.04 171.34,97.84 171.48,97.71 171.48,97.5 171.34,97.37 171.34,97.17 171.48,97.03 171.48,96.83 171.34,96.7 171.34,96.5 171.48,96.36 171.48,95.86 171.36,95.74 171.36,95.49 171.48,95.37 171.48,95.21 171.29,95.02 171.29,94.76 171.17,94.64 171.17,94.4 171.29,94.29 171.29,93.82 171.55,93.56 171.55,92.46 169.88,90.78 169.33,90.78 168.96,90.41 167.67,90.41 167.52,90.57 167.33,90.57 167.18,90.41 167,90.41 166.85,90.57 166.66,90.57 166.51,90.41 166.33,90.41 166.18,90.57 165.99,90.57 165.84,90.41 165.66,90.41 165.51,90.57 165.32,90.57 165.17,90.41 164.99,90.41 164.84,90.57 164.65,90.57 164.5,90.41 162.43,90.41 160.25,88.23 155.43,88.23 155.24,88.05 155.24,87.43 155.16,87.35 154.98,87.35 154.9,87.43 154.9,88.05 154.71,88.23 154.39,88.23 154.2,88.05 154.2,87.43 154.12,87.35 153.95,87.35 153.87,87.43 153.87,88.05 153.68,88.23 149.82,88.23 145.15,83.56 145.15,72.35 144.63,71.84 144.63,70.62 144.22,70.21 143.2,70.21 143,69.87 arc(142.66,69.67) 142.32,69.87 142.31,69.89 arc(142.09,70.11) 141.8,70.19 141.79,70.19 arc(141.5,70.11) 141.28,69.89 141.28,69.89 arc(141.14,69.75) 140.94,69.69 arc(140.93,69.69) 140.93,69.69 arc(140.73,69.74) 140.58,69.89 140.58,69.89 arc(140.36,70.11) 140.07,70.19 140.06,70.19 arc(139.77,70.11) 139.55,69.89 139.55,69.89 arc(139.4,69.75) 139.2,69.69 arc(139.2,69.69) 139.2,69.69 arc(139,69.74) 138.85,69.89 138.84,69.89 arc(138.63,70.11) 138.34,70.19 138.33,70.19 arc(138.03,70.11) 137.82,69.89 137.82,69.89 arc(137.67,69.75) 137.47,69.69 arc(137.47,69.69) 137.47,69.69 arc(137.46,69.69) 137.46,69.69 137.46,69.69 arc(137.26,69.75) 137.11,69.9 arc(136.6,70.19) 136.09,69.9 arc(136.08,69.88) 136.07,69.86 136.04,69.82 arc(135.9,69.73) 135.73,69.69 arc(135.73,69.69) 135.73,69.69 arc(135.53,69.75) 135.38,69.89 135.38,69.89 arc(135.2,70.09) 134.94,70.19 arc(134.85,70.18) 134.76,70.16 arc(134.76,70.16) 134.75,70.15
DDR4_DDIMM2_TDQS_N12: length 56.4
  L12_SIG4 w0.076: 125.73,81.7 125.73,81.69 125.52,81.69 125.34,81.51 125.34,81.1 arc(125.32,81.01) 125.32,80.91 arc(125.33,80.87) 125.35,80.84 125.45,80.66 arc(125.46,80.62) 125.47,80.58 125.46,80.41 125.4,80.3 arc(125.32,80.22) 125.21,80.18 125.08,80.18 arc(124.88,80.14) 124.71,80.03 124.68,80 arc(124.66,79.98) 124.64,79.95 124.61,79.9 arc(124.55,79.74) 124.54,79.57 arc(124.55,79.5) 124.58,79.43 arc(124.58,79.42) 124.58,79.41 124.56,79.32 v1(124.29,79.17)
  L12_SIG4 w0.089: 125.73,81.7 125.96,81.92 127.03,81.92 127.75,82.64 128.27,82.64 128.72,83.09 128.72,83.56 128.97,83.82 128.98,83.82 129.13,83.97 129.62,83.97 129.85,83.73 131.22,83.73 131.62,84.13 136.56,84.13 136.67,84.23 136.9,84.23 139.87,84.23 140.22,84.58 141.38,84.58 141.38,84.59 142.76,84.59 147.23,89.06 155.16,89.06 155.81,89.7 157.51,89.7 158.2,90.39 158.49,90.39 158.64,90.24 158.76,90.24 158.88,90.36 158.88,90.48 158.73,90.63 158.73,90.92 158.96,91.15 159.24,91.15 159.39,91 159.52,91 159.63,91.11 159.63,91.24 159.48,91.39 159.48,91.67 159.71,91.9 160,91.9 160.14,91.75 160.27,91.75 160.39,91.87 160.39,91.99 160.24,92.14 160.24,92.43 160.78,92.97 160.99,92.97 162.14,94.12 162.14,95.64 161.96,95.82 160.75,95.82 160.55,96.02 160.55,96.34 160.75,96.54 162.04,96.54 162.14,96.64 162.14,96.83 162.34,97.03 163.22,97.03 163.33,97.14 163.33,97.27 163.22,97.38 162.32,97.38 162.11,97.58 162.11,97.62 v1(161.79,97.95)
DDR4_DDIMM2_TDQS_N13: length 52.2
  L03_SIG1 w0.076: v2(114.73,79.17) arc(114.99,79.19) 115.02,79.45 115.01,79.46 115.01,79.48 114.96,79.54 arc(114.89,79.6) 114.8,79.62 114.59,79.62 arc(114.49,79.64) 114.4,79.7 114.33,79.77 arc(114.25,79.89) 114.22,80.04 114.22,80.23 arc(114.23,80.3) 114.27,80.35 114.29,80.37 arc(114.33,80.42) 114.34,80.49 114.34,80.59 arc(114.33,80.63) 114.31,80.66 114.25,80.72 arc(114.25,80.72) 114.25,80.72 114.24,80.73 arc(114.18,80.83) 114.16,80.94 114.16,81.16 arc(114.17,81.23) 114.21,81.28 arc(114.23,81.31) 114.23,81.34 114.23,81.35 114.23,81.88 arc(114.23,81.93) 114.22,81.98 arc(114.2,82.05) 114.16,82.11 arc(114.04,82.34) 114,82.59
  L03_SIG1 w0.081: v1(106.57,99) 106.69,99 106.83,98.87 106.83,98.54 107.07,98.3 107.64,98.3 107.87,98.54 107.87,98.67 108.13,98.93 108.13,99.23 107.27,100.08 107.27,100.2 107.4,100.32 107.51,100.32 108.34,99.49 108.66,99.49 108.89,99.72 108.89,99.99 108.53,100.34 108.53,100.47 108.64,100.58 108.77,100.58 109.06,100.29 109.32,100.29 109.56,100.53 109.56,101.42 109.85,101.7 109.85,102.35 109.39,102.81 108.67,102.81 108.48,102.62 108.48,102.44 108.4,102.36 108.23,102.36 108.15,102.44 108.15,102.87 107.96,103.06 106.19,103.06 105.97,102.84 105.97,101.71 106.17,101.52 106.82,101.52 107.05,101.29 107.05,101.09 106.73,100.78 106,100.78 105.78,100.56 105.78,99.87 104.96,99.05 104.96,98.43 105.25,98.14 105.25,97.95 105.44,97.77 105.82,97.77 105.9,97.68 105.9,97.51 105.82,97.43 105.44,97.43 105.25,97.24 105.25,96.79 105.17,96.71 104.31,96.71 104.12,96.52 104.12,96.19 104.31,96.01 105.17,96.01 105.25,95.93 105.25,95.75 105.17,95.67 104.32,95.67 104.13,95.48 104.13,95.16 104.32,94.97 105.17,94.97 105.25,94.89 105.25,93.89 104.93,93.58 104.93,93.18 107.55,90.56 109.33,90.56 112.58,87.31 113.13,87.31 113.97,86.47 arc(113.99,86.44) 114,86.4 114,82.59
