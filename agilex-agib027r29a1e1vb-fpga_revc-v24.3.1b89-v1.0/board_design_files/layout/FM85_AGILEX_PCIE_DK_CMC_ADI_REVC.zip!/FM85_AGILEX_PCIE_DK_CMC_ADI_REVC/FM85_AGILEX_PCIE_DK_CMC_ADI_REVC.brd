# Allegro board FM85_AGILEX_PCIE_DK_CMC_ADI_REVC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
AVST8_DATA5: length 117.3
  L07_SIG3 w0.089: v1(104.37,78.71) 103.92,79.16 103.92,80.5 99.87,84.54 88.71,84.54 86.85,86.41 79.16,86.41 75.73,82.97 75.73,82.73 73.51,80.5 70.93,80.5 70.62,80.2 65.2,80.2 52.19,67.19 45.16,67.19 41.77,63.8 41.77,60.72 40.87,59.81 40.52,59.81 35.1,54.39 35.1,49.37 34.76,49.03 34.76,45.92 33.74,44.91 33.74,37.76 33.85,37.66 33.85,35.2 34.09,34.95 34.09,30.74 34.33,30.5 34.42,30.5 34.87,30.06 34.87,30 35.63,29.24 35.63,29.24 35.83,29.04 35.83,29.04 36.34,28.53 37.12,28.53 37.49,28.9 v1(37.5,28.9)
AVST8_DATA6: length 113.3
  L07_SIG3 w0.089: v1(36.49,28.9) 37.06,29.47 37.06,29.94 37.87,30.75 37.87,31.03 38.26,31.42 38.26,33.24 38.24,33.26 38.24,33.38 38.74,33.89 38.74,36.34 38.48,36.6 38.48,38.61 37.57,39.52 37.57,43.05 37.45,43.18 37.45,44.72 40.39,47.66 42.48,47.66 43.35,48.53 46.67,48.53 46.76,48.62 46.76,50.01 46.85,50.09 47.03,50.09 47.12,50.01 47.12,49.68 47.2,49.59 47.56,49.59 47.65,49.5 47.65,49.33 47.56,49.24 47.2,49.24 47.12,49.15 47.12,48.77 48.04,47.84 54.01,47.84 54.14,47.97 54.36,47.97 54.48,47.84 54.7,47.84 54.83,47.97 55.04,47.97 55.17,47.84 55.39,47.84 55.51,47.97 55.73,47.97 55.86,47.84 57.08,47.84 61.9,52.66 61.9,61.73 63.58,63.41 77.16,63.41 78.39,64.64 78.39,69.29 77.98,69.69 77.98,71.64 79.91,73.57 79.93,73.57 79.97,73.61 80.57,73.61 80.63,73.66 84.06,73.66 85.46,75.07 87.35,75.07 87.55,75.26 88.18,75.26 88.41,75.49 88.76,75.49 89.61,75.98 89.68,76.01 89.75,76.02 89.82,76.01 89.89,75.99 89.96,75.96 90.02,75.91 90.44,75.49 91.16,75.49 91.35,75.3 91.63,75.3 91.82,75.49 92.9,75.49 93.09,75.3 93.36,75.3 93.55,75.49 93.95,75.49 94.8,75.98 94.87,76.01 94.95,76.02 95.02,76.01 95.09,75.99 95.16,75.96 95.22,75.91 95.64,75.49 95.95,75.49 96.42,75.02 96.7,75.02 96.77,75.01 96.84,74.98 97.77,74.45 97.83,74.4 98.2,74.02 99.2,74.02 99.45,73.77 99.73,73.77 99.98,74.02 100.74,74.02 101.03,73.73 101.34,73.73 101.63,74.03 102.33,74.03 102.62,73.73 102.93,73.73 103.15,73.95 103.15,74.12 103.57,74.54 v1(103.57,74.57)
AVST8_DATA7: length 119.1
  L07_SIG3 w0.089: v1(104.37,74.11) 103.95,74.53 103.95,74.72 103.73,74.94 103.42,74.94 103.13,74.65 102.43,74.65 102.13,74.94 101.82,74.94 101.53,74.65 100.83,74.65 100.54,74.94 99.98,74.94 99.73,74.69 99.45,74.69 99.17,74.98 98.2,74.98 97.7,75.48 97.43,75.48 96.43,76.48 95.28,76.48 95.1,76.3 94.82,76.3 94.61,76.51 93.94,76.51 93.6,76.18 91.4,76.18 90.99,75.77 90.46,75.77 90.45,75.78 90.16,76.07 90.07,76.14 89.97,76.19 89.86,76.22 89.74,76.23 89.28,76.23 89.03,76.48 88.63,76.48 88.16,76.01 87.71,76.01 87.1,75.4 85.33,75.4 83.92,74 80.49,74 80.43,73.94 79.83,73.94 79.79,73.9 79.77,73.9 77.59,71.72 77.59,69.85 77.25,69.52 77.25,69.19 78.05,68.39 78.05,64.78 77.02,63.75 63.44,63.75 61.57,61.87 61.57,53.51 56.36,48.3 49.07,48.3 48.53,48.84 48.53,50.21 48.13,50.61 46.35,50.61 46.17,50.44 46.17,49.13 46.08,49.04 45.91,49.04 45.82,49.13 45.82,50.55 45.73,50.64 45.56,50.64 45.46,50.54 45.46,49.13 45.37,49.04 45.19,49.04 45.11,49.13 45.11,50.36 45.02,50.45 44.84,50.45 44.75,50.36 44.75,49.13 44.66,49.04 44.48,49.04 44.39,49.13 44.39,49.85 44.31,49.94 44.13,49.94 44.04,49.85 44.04,49.13 43.95,49.04 43.34,49.04 42.29,47.99 40.25,47.99 37.12,44.86 37.12,43.04 37.24,42.91 37.24,39.38 38.15,38.47 38.15,36.46 38.41,36.21 38.41,34.57 37.9,34.06 37.9,31.77 37.65,31.53 37.59,31.53 36.97,30.9 v1(36.49,30.9)
AVST8_READY: length 143.3
  L05_SIG2 w0.081: v1(34.32,61.62) 33.37,60.67 33.37,53.15 34,52.51 34,47.81 35.86,45.95 35.86,44.44 37.61,42.7 37.61,39.01 38.15,38.47 38.15,34.76 37.96,34.57 37.96,31.44 v1(38.5,30.9)
  L07_SIG3 w0.089: v1(38.5,30.9) 38.5,31.19 38.59,31.28 38.59,32.69 38.75,32.84 39.55,32.84 39.78,33.08 39.78,33.89 39.07,34.6 39.07,36.48 38.82,36.74 38.82,38.75 37.94,39.62 37.94,43.6 38.6,44.27 38.6,45.4 40.52,47.32 42.72,47.32 43.51,48.12 47.01,48.12 47.72,47.4 55.37,47.4 55.46,47.31 55.46,46.88 55.57,46.76 55.7,46.76 55.81,46.88 55.81,47.31 55.9,47.4 56.08,47.4 56.17,47.31 56.17,46.77 56.26,46.68 56.43,46.68 56.52,46.77 56.52,47.31 56.61,47.4 56.79,47.4 56.88,47.31 56.88,47.01 56.97,46.92 57.15,46.92 57.24,47.01 57.24,47.51 62.23,52.5 62.23,61.59 63.72,63.08 77.3,63.08 78.72,64.51 78.72,69.46 78.32,69.87 78.32,71.5 80.05,73.23 80.07,73.23 80.11,73.27 80.71,73.27 80.72,73.28 81.29,73.28 81.3,73.29 81.67,73.29 81.67,73.28 82.73,73.28 82.73,73.29 83.06,73.29 83.06,73.28 83.73,73.28 83.73,73.29 84.06,73.29 84.06,73.28 84.23,73.28 85.62,74.67 87.42,74.67 87.8,75.05 88.33,75.05 88.69,74.7 89.29,74.7 89.61,75.01 90.22,75.01 90.47,74.76 90.99,74.76 91.31,75.08 91.68,75.08 91.94,74.82 91.94,74.82 91.95,74.81 92.16,74.81 92.2,74.76 92.82,74.76 93.07,75.01 93.59,75.01 93.91,74.7 94.48,74.7 94.8,75.01 95.42,75.01 95.75,74.69 96.05,74.69 96.54,74.2 96.71,74.2 97.01,74.02 97.34,73.69 97.9,73.69 98.28,73.3 98.56,73.3 98.82,73.56 99.94,73.56 100.23,73.27 100.57,73.27 101.02,72.82 101.34,72.82 101.63,73.11 102.21,73.11 102.59,72.73 v1(103.57,72.73)
AVST8_VALID_HPS_RSTN: length 116.8
  TOP w0.149: v1(36.07,33.58) 37.51,33.58 38.01,33.08 38.01,32.66 38.5,32.17 U34.B16
  L07_SIG3 w0.089: v1(36.07,33.58) 36.07,34.31 37.16,35.4 37.16,36.04 36.32,36.88 36.32,38.4 35.75,38.96 35.75,42.74 35.42,43.07 35.42,45.1 37.1,46.78 37.44,46.78 38.07,47.41 38.07,48.29 37.92,48.44 37.92,50.33 38.73,51.14 38.73,51.76 38.4,52.09 38.4,52.42 38.73,52.74 38.73,54.85 43.71,59.83 43.71,64.23 45.67,66.19 52.62,66.19 63.91,77.48 73.71,77.48 74.02,77.78 84.42,77.78 88.35,81.71 94.24,81.71 94.33,81.8 94.33,82.47 94.41,82.56 94.59,82.56 94.68,82.47 94.68,81.8 94.77,81.71 94.95,81.71 95.04,81.8 95.04,82.47 95.13,82.56 95.3,82.56 95.39,82.47 95.39,81.8 95.48,81.71 95.66,81.71 95.75,81.8 95.75,82.47 95.84,82.56 96.01,82.56 96.1,82.47 96.1,81.8 96.19,81.71 96.37,81.71 96.46,81.8 96.46,82.47 96.55,82.56 96.73,82.56 96.81,82.47 96.81,81.8 96.9,81.71 97.08,81.71 97.17,81.8 97.17,82.47 97.26,82.56 97.44,82.56 97.53,82.47 97.53,81.8 97.61,81.71 98.19,81.71 99.13,80.77 99.48,80.77 100.44,79.8 101.35,79.8 v1(101.98,79.17)
  BOTTOM w0.149: v1(101.98,79.17) 101.98,79.45 102.39,79.85 102.39,80.26 102.37,80.28 102.37,80.83 102.86,81.32 R6280.2
B_M10_CRC_ERROR: length 24.1
  L14_SIG5 w0.081: v1(123.08,29.66) 123.03,29.71 123.03,30.03 123.38,30.39 123.38,30.89 123.35,30.92 123.35,37.56 123.96,38.17 123.96,39.27 124.27,39.59 124.3,39.59 v1(124.31,39.61)
  BOTTOM w0.149: v1(123.08,29.66) 131.68,29.66 134.34,32.32 U105.8
BMC_BUF_TCK: length 47.9
  L12_SIG4 w0.089: v1(47.25,14.34) 46.89,14.7 46.05,14.7 45.17,15.59 40.68,15.59 40.1,15 35.25,15 34.85,15.4 33.38,15.4 32.79,15.98 23.84,15.98 22.3,17.53 22.3,23.37 22.79,23.86 22.79,25.3 23.29,25.8 25.27,25.8 25.87,26.4 25.87,30.07 26.76,30.97 27.09,30.97 27.96,31.84 27.96,32.14 28.35,32.52 30.12,32.52 v1(30.5,32.9)
BMC_BUF_TDI: length 46.8
  L12_SIG4 w0.089: v1(48.52,14.34) 47.79,14.34 47.09,15.04 46.19,15.04 45.31,15.92 43.15,15.92 42.56,16.51 41.13,16.51 39.97,15.34 35.37,15.34 35.11,15.61 33.46,15.61 32.86,16.22 24.08,16.22 22.63,17.67 22.63,23.24 23.12,23.73 23.12,25.17 23.35,25.39 26.54,25.39 27.06,25.91 27.06,30.47 v1(28.5,31.9)
BMC_BUF_TDO: length 50.8
  TOP w0.149: v1(53.21,14.67) 53.22,14.67 53.22,14.69 53.46,14.46 U39.3
  L07_SIG3 w0.089: v1(29.5,32.9) 29.94,32.9 30.91,33.87 30.91,34.43 30.53,34.81 30.53,35.94 29.92,36.55 29.92,37.18 30.16,37.42 30.57,37.42 30.92,37.78 30.92,38.06 31.16,38.3 31.76,38.3 32.02,38.04 32.02,36.68 31.49,36.15 31.49,35.6 31.79,35.3 31.79,33.73 31.05,32.99 31.05,29.97 33.12,27.9 33.12,27.75 33.34,27.53 33.5,27.53 34.12,26.9 34.12,26.75 34.34,26.53 34.5,26.53 34.91,26.11 34.91,25.77 36.15,24.53 39.24,24.53 41.5,22.27 41.5,21.04 41.73,20.81 41.73,19.69 41.19,19.15 41.19,18.4 42.57,17.01 43.63,17.01 46.7,13.94 49.05,13.94 49.35,13.64 51.58,13.64 52.61,14.67 v1(53.21,14.67)
BMC_BUF_TMS: length 48.2
  L12_SIG4 w0.089: v1(28.5,30.9) 28.08,30.49 28.08,25.9 26.46,24.28 24.26,24.28 23.87,23.89 23.87,22.62 23.69,22.44 23.33,22.44 23.12,22.23 23.12,18.75 23.34,18.53 23.65,18.53 24.03,18.15 24.03,17.22 24.81,16.44 32.69,16.44 33.03,16.79 34.89,16.79 36.03,15.65 39.72,15.65 41.1,17.03 43.38,17.03 44.16,16.25 45.44,16.25 46.33,15.37 47.23,15.37 47.89,14.71 48.22,14.71 48.22,14.72 49.49,14.72 50.14,14.06 50.14,13.52 50.5,13.16 v1(50.87,13.16)
BUF1_CLK0_N: length 3.4
  TOP w0.102: U24.3 56.92,36.37 56.79,36.23 56.79,35.14 56.52,34.88 56.52,34.76 R986.1 56.9,34.38 C466.2
BUF1_CLK0_P: length 3.4
  TOP w0.102: C465.2 55.89,34.38 R985.1 56.29,34.79 56.29,34.97 56.56,35.24 56.56,36.24 56.42,36.37 U24.2
BUF1_CLK1_N: length 3.9
  TOP w0.102: C468.2 60.41,33.6 60.41,34.25 R988.1 60.1,34.79 60.1,35.11 59.29,35.92 59.29,36.23 59.42,36.37 U24.8
BUF1_CLK1_P: length 3.9
  TOP w0.102: C467.2 59.84,33.69 59.84,34.16 R987.1 59.87,34.61 59.87,35.01 59.06,35.83 59.06,36.24 58.92,36.37 U24.7
BUF1_Q0_N: length 3.2
  TOP w0.102: R929.2 63.49,37.69 63.39,37.8 62.7,37.8 62.47,38.02 62.21,38.02 62.06,38.18 62.06,38.44 61.96,38.54 61.58,38.54 61.44,38.4 U24.13
BUF1_Q0_P: length 2.8
  TOP w0.102: U24.14 61.46,38.9 61.6,38.77 62.05,38.77 62.79,38.03 63.14,38.03 R928.2
BUF1_Q1_N: length 3.5
  TOP w0.102: U24.16 61.44,39.9 61.58,40.04 62.09,40.04 62.21,39.92 62.78,39.92 62.95,39.75 63.14,39.75 63.31,39.92 63.81,39.92 R931.2
BUF1_Q1_P: length 3.3
  TOP w0.102: R930.2 63.81,40.15 62.3,40.15 62.18,40.27 61.6,40.27 61.46,40.4 U24.17
BUF1_Q3_N: length 1.1
  TOP w0.149: U24.23 59.42,43.27 v1(59.76,43.61)
BUF1_Q3_P: length 1
  TOP w0.149: U24.24 58.92,43.45 v1(59.05,43.57)
BUF2_CLK0_N: length 7.5
  BOTTOM w0.102: U25.3 211.84,59.96 211.98,59.82 211.98,59.62 211.86,59.5 211.86,59.27 211.98,59.14 211.98,58.91 212.22,58.67 212.38,58.67 212.56,58.5 212.74,58.5 212.91,58.67 213.09,58.67 213.27,58.5 213.45,58.5 213.62,58.67 213.78,58.67 213.88,58.57 213.88,58.21 213.73,58.06 213.73,57.85 213.88,57.7 213.88,57.48 R996.1 213.9,56.71 213.9,56.05 C474.2
BUF2_CLK0_P: length 7
  BOTTOM w0.102: C473.2 214.13,56.02 214.13,56.71 R993.1 214.11,57.51 214.11,58.67 213.88,58.9 212.31,58.9 212.21,59 212.21,59.83 212.34,59.96 U25.2
BUF2_CLK1_N: length 4.9
  BOTTOM w0.102: C476.2 210.01,56.42 210.01,56.96 R998.1 209.99,57.72 209.99,57.88 209.71,58.16 209.71,59.29 209.48,59.52 209.48,59.82 209.34,59.96 U25.8
BUF2_CLK1_P: length 5
  BOTTOM w0.102: C475.2 210.24,56.56 210.24,56.96 R997.1 210.22,57.78 210.22,57.98 209.94,58.25 209.94,59.39 209.71,59.61 209.71,59.83 209.84,59.96 U25.7
BUF2_Q0_N: length 3.7
  BOTTOM w0.102: R933.2 205.68,60.53 205.93,60.53 206.15,60.75 206.15,61.51 206.88,62.24 207.19,62.24 207.33,62.1 U25.13
BUF2_Q0_P: length 3.7
  BOTTOM w0.102: U25.14 207.35,62.6 207.21,62.47 206.79,62.47 205.92,61.6 205.92,60.85 205.84,60.76 205.71,60.76 R932.2
BUF2_Q1_N: length 2.7
  BOTTOM w0.102: R935.2 205.57,63.36 205.8,63.36 206.18,63.74 206.34,63.74 206.44,63.63 206.69,63.63 206.8,63.74 207.09,63.74 207.22,63.6 U25.16
BUF2_Q1_P: length 2.7
  BOTTOM w0.102: U25.17 207.26,64.1 207.12,63.97 206.08,63.97 205.71,63.59 205.57,63.59 R934.2
BUF2_Q2_N: length 3.2
  BOTTOM w0.116: U25.21 208.34,67.05 208.47,67.18 208.47,67.34 208.22,67.6 206.77,67.6 v1(206.52,67.35)
BUF2_Q2_P: length 3.6
  BOTTOM w0.116: v1(206.51,68.14) 206.81,67.84 208.32,67.84 208.71,67.44 208.71,67.18 208.84,67.05 U25.22
BUFF1_IMP_SEL: length 11.5
  TOP w0.149: U24.19 62.22,41.4 62.36,41.55 R267.1 62.82,42.63 63,42.82 63,46.2 62.37,46.84 60.09,46.84 59.25,46 R268.1
BUFF1_OE0N: length 4.6
  TOP w0.149: R269.1 R270.1 54.05,42.43 54.58,41.9 U24.31
BUFF1_OE1N: length 3.7
  TOP w0.149: U24.32 54.25,41.4 R272.1 R271.1
BUFF1_OE2N: length 5.5
  TOP w0.149: U24.36 54.48,39.4 54.19,39.1 54.19,36.07 53.63,35.51 R983.1
BUFF1_OE3N: length 5.6
  TOP w0.149: U24.37 54.7,38.9 54.53,38.73 54.53,35.73 53.47,34.67 R984.1
BUFF2_IMP_SEL: length 4.4
  BOTTOM w0.149: U25.19 207.31,65.1 207.22,65.19 206.05,65.19 205.87,65.37 204.8,65.37 R994.1 R995.1
BUFF2_OE0N: length 4.9
  BOTTOM w0.149: U25.31 214.63,65.6 214.76,65.74 R294.1 215.84,66.14 215.95,66.25 217.24,66.25 R293.1
BUFF2_OE1N: length 3.5
  BOTTOM w0.149: R303.1 R304.1 215.4,64.72 215.27,64.59 214.76,64.59 214.26,65.1 U25.32
BUFF2_OE2N: length 2.9
  BOTTOM w0.149: U25.36 214.54,63.1 214.62,63.18 215.55,63.18 215.84,62.88 R291.1
BUFF2_OE3N: length 2.9
  BOTTOM w0.149: U25.37 214.09,62.6 214.51,62.18 214.51,62 214.94,61.57 215.69,61.57 R292.1
CH01_RUN: length 7.6
  BOTTOM w0.149: v1(183.67,23.83) 183.94,23.83 C1966.2 184.64,24.16 184.89,24.41 186.9,24.41 v1(187.48,23.83) ; v1(183.67,23.83) 183.16,23.83 183.01,23.98 R6081.2 182.89,24.46 R6080.1 ; v1(183.67,23.83) 183.67,23.59 R6079.1
  vias: v1(191.29,23.83) v1(192.56,25.1)
CH02_RUN: length 1.3
  TOP w0.203: R6086.2 213.17,98.03 v1(212.86,98.03) 212.56,98.03 C7614.2
  vias: v1(209.05,98.03) v1(216.67,98.03) v1(217.94,96.76)
CH23_RUN: length 16.4
  L07_SIG3 w0.089: v1(74.54,59.5) v1(75.81,60.77)
  L14_SIG5 w0.203: v1(74.54,59.5) 73.99,58.95 71.29,58.95 v1(70.73,59.5) 70.27,59.03 67.39,59.03 v1(66.92,59.5) 66.47,59.95 65.07,59.95 64.84,59.72 64.84,59.21 v1(65.22,58.83)
  BOTTOM w0.149: R6093.2 66.34,60.09 v1(66.92,59.5) ; C7624.2 67.31,59.88 v1(66.92,59.5) ; R6092.1 67.13,58.92 66.92,59.12 v1(66.92,59.5)
CLK_100M_CXL_CONN_C_N: length 3.6
  TOP w0.102: J6.B12 215.33,23.18 215.15,23 214.61,23 214.24,22.63 213.2,22.63 R186.1
CLK_100M_CXL_CONN_C_P: length 3.7
  TOP w0.102: J6.B11 215.33,22.58 215.15,22.77 214.71,22.77 214.34,22.4 213.28,22.4 212.87,21.99 R185.1
CLK_CXL_CONN_N: length 34.7
  L03_SIG1 w0.079: v1(213.63,52.78) 213.83,52.58 213.83,49.25 214.08,49.01 214.08,23.28 213.36,22.56 212.06,22.56 211.98,22.64 v1(211.98,22.95)
  BOTTOM w0.102: v1(213.63,52.78) 213.89,53.04 213.89,54.36 C474.1
CLK_CXL_CONN_P: length 35.1
  L03_SIG1 w0.079: v1(214.37,52.78) 214.06,52.48 214.06,49.34 214.31,49.1 214.31,23.19 213.45,22.33 212.06,22.33 211.98,22.25 v1(211.98,21.94)
  BOTTOM w0.102: C473.1 214.12,54.36 214.12,53.04 v1(214.37,52.78)
CLK_DDR4_CH0_N: length 53.9
  TOP w0.102: v1(94.17,30.36) 93.95,30.59 arc(93.92,30.61) 93.88,30.62 85.78,30.62 arc(85.42,30.55) 85.12,30.34 arc(84.64,30.02) 84.07,29.91 71.34,29.91 arc(71.23,29.89) 71.14,29.83 arc(70.88,29.65) 70.56,29.59 66.55,29.59 arc(65.58,29.4) 64.76,28.85 64.01,28.1 arc(63.25,27.59) 62.35,27.41 62.25,27.41 arc(62.18,27.38) 62.15,27.31 62.15,27.12 arc(62.12,27.05) 62.05,27.02 v1(61.67,27.02)
  L05_SIG2 w0.076: 101.4,42.63 101.43,42.66 arc(101.46,42.67) 101.49,42.68 arc(101.53,42.69) 101.56,42.71 101.65,42.8 arc(101.73,42.86) 101.83,42.87 102.1,42.87 102.57,43.34 102.94,43.34 103,43.4 103.06,43.5 103.03,43.6 v1(102.77,43.75)
  L05_SIG2 w0.079: v1(94.17,30.36) 93.94,30.6 arc(93.92,30.61) 93.89,30.62 93.81,30.62 arc(93.44,30.77) 93.29,31.14 93.29,31.73 arc(93.4,32.3) 93.72,32.78 97.93,36.98 arc(98.03,37.05) 98.16,37.08 100.7,37.08 101.34,37.73 arc(101.37,37.76) 101.37,37.8 101.37,42.55 arc(101.38,42.59) 101.4,42.63
CLK_DDR4_CH0_P: length 53.9
  TOP w0.102: v1(61.67,28.03) 62.05,28.03 arc(62.12,28) 62.15,27.93 62.15,27.74 arc(62.18,27.67) 62.25,27.64 62.35,27.64 arc(63.16,27.8) 63.85,28.26 64.6,29.01 arc(65.5,29.61) 66.55,29.82 67.09,29.82 67.23,29.96 67.45,29.96 67.59,29.82 67.8,29.82 67.94,29.96 68.16,29.96 68.3,29.82 68.51,29.82 68.65,29.96 68.87,29.96 69.01,29.82 69.22,29.82 69.36,29.96 69.58,29.96 69.72,29.82 70.56,29.82 arc(70.79,29.86) 70.98,29.99 arc(71.14,30.1) 71.34,30.14 84.07,30.14 arc(84.55,30.23) 84.95,30.51 arc(85.33,30.76) 85.78,30.85 93.88,30.85 arc(93.92,30.86) 93.95,30.88 v1(94.17,31.1)
  L05_SIG2 w0.076: v1(103.57,43.29) 103.32,43.43 103.21,43.41 103.15,43.29 103.01,43.16 102.64,43.16 102.21,42.73 arc(102.17,42.7) 102.14,42.7 101.83,42.7 arc(101.8,42.69) 101.77,42.67 101.6,42.5
  L05_SIG2 w0.079: 101.6,42.5 101.6,37.8 arc(101.58,37.67) 101.51,37.57 100.82,36.88 arc(100.79,36.86) 100.75,36.85 98.16,36.85 arc(98.12,36.84) 98.09,36.82 93.88,32.61 arc(93.61,32.21) 93.51,31.73 93.51,31.14 arc(93.6,30.93) 93.81,30.85 93.89,30.85 arc(93.92,30.85) 93.94,30.87 v1(94.17,31.1)
CLK_DDR4_CH1_N: length 108.3
  TOP w0.102: v2(140.58,29.57) 140.38,29.77 140.31,29.77 140.18,29.9 136.32,29.9 135.21,30.36 132.47,30.36 arc(132.29,30.33) 132.13,30.25 arc(131.85,30.1) 131.52,30.04 121.52,30.04 arc(121.4,30.02) 121.3,29.95 arc(121.15,29.85) 120.98,29.82 97.53,29.82 arc(96.86,29.95) 96.29,30.34 95.08,31.54 arc(94.9,31.67) 94.68,31.71 85.34,31.71 arc(85.24,31.69) 85.15,31.63 arc(84.24,31.02) 83.15,30.8 72.51,30.8 arc(72,30.9) 71.57,31.19 70.54,32.23 arc(69.73,32.56) 68.92,32.23 arc(68.1,31.68) 67.14,31.49 62.16,31.49 62.02,31.35 61.81,31.35 61.67,31.49 61.45,31.49 61.31,31.35 61.09,31.35 60.95,31.49 60.74,31.49 60.6,31.35 60.38,31.35 60.24,31.49 59.56,31.49 arc(59.45,31.41) 59.31,31.38 v2(58.94,31.38)
  L03_SIG1 w0.076: 134.71,37.04 134.71,37.06 134.7,37.06 arc(134.69,37.08) 134.69,37.11 134.69,37.22 arc(134.6,37.66) 134.35,38.03 arc(134.27,38.21) 134.32,38.4 arc(134.36,38.48) 134.38,38.56 arc(134.39,38.69) 134.38,38.81 arc(134.36,38.88) 134.32,38.94 arc(134.3,38.98) 134.28,39.02 arc(134.28,39.12) 134.28,39.22 arc(134.29,39.28) 134.31,39.34 arc(134.39,39.6) 134.33,39.86 arc(134.28,39.99) 134.28,40.13 arc(134.28,40.16) 134.3,40.2 134.38,40.35 arc(134.43,40.56) 134.36,40.76 134.31,40.84 arc(134.27,41) 134.34,41.15 arc(134.41,41.27) 134.43,41.4 arc(134.35,41.68) 134.19,41.92 133.74,42.36 arc(133.63,42.43) 133.51,42.46 132.99,42.46 arc(132.96,42.46) 132.92,42.48 132.58,42.83 arc(132.49,42.89) 132.37,42.91 132.14,42.91 arc(132.04,42.89) 131.95,42.83 131.61,42.5 arc(131.56,42.47) 131.51,42.45 131.36,42.45 arc(131.32,42.46) 131.29,42.48 130.92,42.86 arc(130.83,42.92) 130.72,42.94 130.57,42.94 arc(130.54,42.94) 130.5,42.96 130.18,43.29 arc(130.09,43.35) 129.98,43.37 129.75,43.37 arc(129.64,43.35) 129.55,43.29 129.21,42.95 arc(129.18,42.93) 129.15,42.93 128.89,42.93 arc(128.72,42.87) 128.6,42.74 arc(128.56,42.69) 128.5,42.7 arc(128.5,42.7) 128.49,42.7 v1(128.27,42.83)
  L03_SIG1 w0.079: 134.71,37.04 134.71,35.8 arc(134.72,35.73) 134.74,35.66 arc(134.77,35.6) 134.82,35.54 138.47,31.88 140.14,31.88 141.34,30.69 141.34,30.12 141.12,29.9 140.66,29.9 140.58,29.82 v2(140.58,29.57)
CLK_DDR4_CH1_P: length 108.4
  TOP w0.102: v2(140.58,30.46) 140.38,30.25 140.31,30.25 140.18,30.13 136.37,30.13 135.26,30.59 132.47,30.59 arc(132.22,30.55) 132,30.43 arc(131.77,30.31) 131.52,30.27 121.52,30.27 arc(121.31,30.23) 121.14,30.11 arc(121.07,30.07) 120.98,30.05 97.53,30.05 arc(96.95,30.17) 96.45,30.5 95.24,31.7 arc(94.98,31.88) 94.68,31.94 85.34,31.94 arc(85.15,31.9) 84.99,31.79 arc(84.15,31.23) 83.15,31.03 72.51,31.03 arc(72.09,31.12) 71.73,31.36 70.7,32.39 arc(69.73,32.79) 68.76,32.39 arc(68.02,31.89) 67.14,31.72 59.56,31.72 arc(59.42,31.81) 59.26,31.84 58.67,31.84 arc(58.6,31.83) 58.55,31.79 58.22,31.46 arc(58.13,31.4) 58.03,31.38 v2(57.92,31.38)
  L03_SIG1 w0.076: v1(129.07,42.37) 128.82,42.51 arc(128.76,42.65) 128.89,42.75 129.15,42.75 arc(129.25,42.77) 129.34,42.83 129.68,43.17 arc(129.71,43.19) 129.75,43.2 129.98,43.2 arc(130.02,43.19) 130.05,43.17 130.38,42.84 arc(130.47,42.78) 130.57,42.76 130.72,42.76 arc(130.76,42.75) 130.79,42.73 131.17,42.36 arc(131.25,42.3) 131.36,42.28 131.51,42.28 arc(131.63,42.3) 131.74,42.37 132.07,42.71 arc(132.11,42.73) 132.14,42.74 132.37,42.74 arc(132.42,42.73) 132.46,42.7 132.8,42.36 arc(132.89,42.3) 132.99,42.28 133.51,42.28 arc(133.57,42.27) 133.62,42.23 134.06,41.79 arc(134.19,41.6) 134.25,41.38 arc(134.25,41.33) 134.22,41.28 arc(134.09,41.02) 134.16,40.74 134.21,40.66 arc(134.25,40.55) 134.22,40.43 134.14,40.28 arc(134.12,40.22) 134.1,40.15 arc(134.11,39.96) 134.17,39.77 arc(134.21,39.6) 134.16,39.43 arc(134.12,39.34) 134.1,39.23 arc(134.1,39.11) 134.11,39 arc(134.13,38.91) 134.18,38.83 arc(134.19,38.8) 134.2,38.77 arc(134.21,38.68) 134.21,38.59 arc(134.19,38.54) 134.17,38.5 arc(134.09,38.19) 134.22,37.91 arc(134.43,37.59) 134.51,37.22 134.51,37.11 arc(134.5,37.08) 134.49,37.06 134.48,37.06 134.48,37.04
  L03_SIG1 w0.079: v2(140.58,30.46) 140.58,30.21 140.66,30.12 141.02,30.12 141.11,30.21 141.11,30.59 140.05,31.66 138.38,31.66 134.66,35.38 arc(134.53,35.57) 134.48,35.8 134.48,37.04
CLK_DDR4_CH2_N: length 91.2
  TOP w0.102: R232.1 62.08,25.47 63.1,25.47 v1(63.36,25.21)
  L16_SIG6 w0.076: v1(124.29,73.65) 124.56,73.84 arc(124.6,73.95) 124.5,74.02 124.27,74.02 arc(124.1,73.98) 123.97,73.85 123.91,73.75 arc(123.75,73.58) 123.53,73.53 123.47,73.53 arc(123.32,73.49) 123.21,73.38 123.18,73.32 arc(123.02,73.16) 122.79,73.1 122.64,73.1 arc(122.5,73.06) 122.39,72.95 122.34,72.86 arc(122.18,72.7) 121.95,72.64 121.85,72.64 arc(121.71,72.6) 121.6,72.49 121.53,72.37 arc(121.36,72.2) 121.14,72.14 121.08,72.14 arc(120.94,72.1) 120.83,72 120.8,71.94 arc(120.63,71.78) 120.41,71.72 120.26,71.72 arc(120.11,71.68) 120,71.57 119.98,71.52 arc(119.81,71.36) 119.59,71.3 119.47,71.3 arc(119.33,71.26) 119.22,71.15 119.15,71.02 arc(118.98,70.86) 118.76,70.8 118.71,70.8 arc(118.57,70.76) 118.46,70.67 arc(118.27,70.48) 118.01,70.41 arc(117.77,70.34) 117.57,70.17 117.52,70.1 arc(117.34,69.96) 117.13,69.91 arc(116.95,69.87) 116.83,69.74 116.75,69.61 arc(116.61,69.47) 116.42,69.42 116.23,69.42 arc(116.09,69.38) 115.98,69.27 115.93,69.18 arc(115.76,69.02) 115.54,68.96 115.52,68.96 arc(115.38,68.92) 115.27,68.81 115.22,68.72 arc(115.05,68.56) 114.83,68.5 114.81,68.5 arc(114.8,68.5) 114.79,68.5 arc(114.73,68.49) 114.67,68.5 arc(114.65,68.5) 114.64,68.5 114.64,68.5 arc(114.49,68.46) 114.38,68.35 114.36,68.31 arc(114.19,68.14) 113.97,68.08 113.91,68.08 arc(113.77,68.04) 113.66,67.93 113.58,67.79 arc(113.41,67.63) 113.19,67.57 113.08,67.57 arc(112.94,67.53) 112.83,67.42 112.79,67.34 arc(112.62,67.18) 112.39,67.12 112.29,67.12 arc(112.15,67.08) 112.04,66.97 111.99,66.88 arc(111.82,66.72) 111.6,66.66 111.5,66.66 arc(111.35,66.62) 111.24,66.51 111.22,66.47 arc(111.02,66.27) 110.76,66.2 110.72,66.2 arc(110.57,66.17) 110.46,66.08 arc(110.45,66.06) 110.44,66.04 110.39,65.95 arc(110.25,65.79) 110.04,65.73 109.82,65.73 arc(109.75,65.71) 109.69,65.66 109.58,65.5 arc(109.45,65.37) 109.28,65.3 109.09,65.27 arc(108.98,65.22) 108.9,65.13 108.82,65 arc(108.66,64.84) 108.43,64.78 108.33,64.78 arc(108.19,64.74) 108.08,64.63 108.05,64.58 arc(107.88,64.41) 107.65,64.35 107.42,64.35 arc(107.28,64.31) 107.17,64.21 107.13,64.13 arc(106.99,63.99) 106.79,63.94 106.69,63.94 arc(106.59,63.91) 106.51,63.84 106.41,63.66 arc(106.25,63.5) 106.02,63.44 105.8,63.44 arc(105.72,63.41) 105.65,63.35 105.57,63.2 arc(105.4,63.04) 105.18,62.98 105.12,62.98 arc(104.98,62.94) 104.87,62.83 104.84,62.78 arc(104.68,62.62) 104.45,62.56 104.3,62.56 arc(104.16,62.52) 104.05,62.41 104,62.32 arc(103.83,62.16) 103.61,62.1 103.55,62.1 arc(103.4,62.06) 103.3,61.95 103.21,61.8 arc(103.04,61.63) 102.82,61.57 102.76,61.57 arc(102.61,61.53) 102.5,61.42 102.43,61.3 arc(102.29,61.16) 102.09,61.11 101.96,61.11 arc(101.81,61.07) 101.7,60.96 101.65,60.87 arc(101.49,60.71) 101.26,60.65 101.1,60.65 arc(100.99,60.63) 100.91,60.57 100.66,60.32 arc(100.54,60.24) 100.4,60.22 100.38,60.22 arc(100.29,60.2) 100.22,60.15 99.91,59.85 arc(99.78,59.75) 99.62,59.72 99.41,59.72 99.39,59.7 99.37,59.7
  L16_SIG6 w0.079: 99.37,59.7 99.36,59.7 arc(99.32,59.69) 99.29,59.67 98.8,59.18 arc(98.64,59.07) 98.45,59.03 98.43,59.03 arc(98.34,59.01) 98.26,58.96 97.99,58.66 arc(97.82,58.53) 97.6,58.49 97.47,58.49 arc(97.36,58.46) 97.28,58.39 97.12,58.18 arc(96.98,58.06) 96.81,58.02 96.7,58.02 arc(96.53,57.98) 96.41,57.86 96.34,57.72 arc(96.15,57.54) 95.91,57.47 95.79,57.47 arc(95.61,57.43) 95.48,57.3 95.45,57.25 arc(95.28,57.09) 95.07,57.03 94.92,57.03 arc(94.82,57.01) 94.74,56.96 94.5,56.68 arc(94.32,56.55) 94.11,56.51 94.02,56.51 arc(93.92,56.48) 93.83,56.42 93.7,56.24 arc(93.51,56.08) 93.27,56.02 93.18,56.02 arc(93.04,55.99) 92.95,55.9 92.85,55.76 arc(92.67,55.59) 92.43,55.53 92.36,55.53 arc(92.18,55.49) 92.05,55.36 91.98,55.25 arc(91.82,55.09) 91.6,55.03 91.5,55.03 arc(91.41,55.01) 91.33,54.96 91.05,54.65 arc(90.88,54.52) 90.67,54.48 90.58,54.48 arc(90.47,54.45) 90.39,54.38 90.27,54.22 arc(90.07,54.06) 89.83,54 89.7,54 arc(89.54,53.95) 89.42,53.83 89.4,53.8 arc(89.2,53.61) 88.93,53.53 88.52,53.53 arc(88.32,53.56) 88.14,53.65 arc(87.96,53.74) 87.76,53.77 87.56,53.77 arc(87.46,53.72) 87.41,53.62 87.41,53.61 arc(87.42,53.58) 87.43,53.56 v1(87.74,53.25) 87.43,52.94 arc(87.41,52.9) 87.41,52.86 arc(87.44,52.76) 87.48,52.67 87.54,52.57 arc(87.58,52.48) 87.6,52.38 87.6,51.19 arc(87.56,51.01) 87.46,50.86 87.3,50.7 arc(87.18,50.61) 87.04,50.54 arc(86.9,50.48) 86.78,50.38 86.52,50.13 arc(86.47,50.08) 86.4,50.04 86.15,49.91 arc(85.16,49.29) 84.27,48.53 83.9,48.16 arc(83.66,48) 83.38,47.94 82.89,47.94 arc(82.4,47.73) 82.19,47.23 82.19,46.63 arc(82.14,46.4) 82.01,46.19 79.92,44.1 arc(79.39,43.75) 78.77,43.63 arc(77.59,43.39) 76.59,42.72 76.37,42.5 arc(75.82,42.14) 75.18,42.01 74.4,42.01 arc(74.04,41.94) 73.75,41.74 73.59,41.59 arc(73.53,41.55) 73.46,41.54 70.65,41.54 arc(69,40.85) 68.32,39.21 68.32,35.25 arc(68.25,34.9) 68.05,34.61 67.52,34.08 arc(67.19,33.59) 67.08,33 67.08,31.93 arc(66.87,30.9) 66.29,30.03 65.86,29.6 65.38,29.12 arc(64.65,28.03) 64.4,26.75 64.4,26.14 arc(64.2,25.67) 63.72,25.47 63.64,25.47 arc(63.61,25.46) 63.59,25.44 v1(63.36,25.21)
CLK_DDR4_CH2_P: length 91.2
  TOP w0.102: v1(63.36,25.95) 63.1,25.7 62.08,25.7 R231.1
  L16_SIG6 w0.076: 99.37,59.93 99.39,59.93 99.41,59.9 99.62,59.9 arc(99.71,59.92) 99.79,59.97 100.09,60.28 arc(100.22,60.36) 100.38,60.39 100.4,60.39 arc(100.47,60.41) 100.53,60.45 100.78,60.69 arc(100.93,60.79) 101.1,60.83 101.26,60.83 arc(101.4,60.86) 101.5,60.96 101.55,61.05 arc(101.72,61.22) 101.96,61.28 102.09,61.28 arc(102.2,61.31) 102.28,61.39 102.35,61.51 arc(102.52,61.69) 102.76,61.75 102.82,61.75 arc(102.95,61.79) 103.05,61.89 103.14,62.04 arc(103.32,62.21) 103.55,62.27 103.61,62.27 arc(103.74,62.31) 103.84,62.41 103.9,62.5 arc(104.07,62.67) 104.3,62.73 104.45,62.73 arc(104.59,62.77) 104.69,62.87 104.72,62.92 arc(104.89,63.09) 105.12,63.16 105.18,63.16 arc(105.31,63.19) 105.41,63.29 105.5,63.44 arc(105.63,63.57) 105.8,63.62 106.02,63.62 arc(106.16,63.65) 106.26,63.75 106.36,63.93 arc(106.5,64.07) 106.69,64.12 106.79,64.12 arc(106.9,64.15) 106.97,64.22 107.01,64.29 arc(107.19,64.47) 107.42,64.53 107.65,64.53 arc(107.79,64.57) 107.9,64.67 107.92,64.72 arc(108.1,64.89) 108.33,64.96 108.43,64.96 arc(108.57,64.99) 108.67,65.09 108.75,65.22 arc(108.88,65.37) 109.05,65.44 109.25,65.48 arc(109.35,65.52) 109.43,65.6 109.54,65.76 arc(109.66,65.87) 109.82,65.91 110.04,65.91 arc(110.15,65.94) 110.23,66.03 110.28,66.12 arc(110.3,66.15) 110.32,66.18 arc(110.49,66.33) 110.72,66.38 110.76,66.38 arc(110.93,66.43) 111.06,66.55 111.09,66.6 arc(111.26,66.77) 111.5,66.84 111.6,66.84 arc(111.73,66.87) 111.83,66.97 111.89,67.06 arc(112.06,67.23) 112.29,67.3 112.39,67.3 arc(112.53,67.33) 112.63,67.43 112.67,67.51 arc(112.85,67.68) 113.08,67.74 113.19,67.74 arc(113.32,67.78) 113.42,67.88 113.51,68.02 arc(113.68,68.2) 113.91,68.26 113.97,68.26 arc(114.1,68.29) 114.2,68.39 114.23,68.44 arc(114.4,68.61) 114.64,68.67 114.64,68.67 arc(114.67,68.67) 114.69,68.67 arc(114.73,68.67) 114.77,68.67 arc(114.79,68.67) 114.81,68.67 114.83,68.67 arc(114.96,68.71) 115.06,68.81 115.12,68.9 arc(115.29,69.07) 115.52,69.14 115.54,69.14 arc(115.68,69.17) 115.78,69.27 115.83,69.36 arc(116,69.53) 116.23,69.6 116.42,69.6 arc(116.52,69.62) 116.6,69.7 116.67,69.83 arc(116.87,70.02) 117.13,70.09 arc(117.27,70.12) 117.38,70.21 117.44,70.28 arc(117.69,70.49) 118,70.58 arc(118.18,70.64) 118.31,70.76 arc(118.48,70.92) 118.71,70.98 118.76,70.98 arc(118.89,71.01) 118.99,71.11 119.07,71.24 arc(119.24,71.41) 119.47,71.48 119.59,71.48 arc(119.72,71.51) 119.82,71.61 119.85,71.66 arc(120.02,71.83) 120.26,71.9 120.41,71.9 arc(120.55,71.93) 120.65,72.03 120.68,72.09 arc(120.85,72.26) 121.08,72.32 121.14,72.32 arc(121.27,72.36) 121.37,72.46 121.45,72.58 arc(121.62,72.75) 121.85,72.82 121.95,72.82 arc(122.09,72.85) 122.19,72.95 122.24,73.04 arc(122.41,73.21) 122.64,73.28 122.79,73.28 arc(122.93,73.31) 123.03,73.41 123.06,73.47 arc(123.23,73.64) 123.47,73.7 123.53,73.7 arc(123.66,73.74) 123.76,73.83 123.82,73.94 arc(124.01,74.13) 124.27,74.2 124.56,74.2 arc(124.83,74.18) v1(125.09,74.11)
  L16_SIG6 w0.079: v1(63.36,25.95) 63.59,25.72 arc(63.61,25.7) 63.64,25.7 63.72,25.7 arc(64.04,25.83) 64.17,26.14 64.17,26.75 arc(64.44,28.12) 65.22,29.28 66.12,30.19 arc(66.66,30.99) 66.85,31.93 66.85,33 arc(66.98,33.67) 67.36,34.24 67.89,34.77 arc(68.03,34.99) 68.09,35.25 68.09,39.21 arc(68.84,41.02) 70.65,41.77 73.4,41.77 arc(73.44,41.77) 73.47,41.79 73.58,41.9 arc(73.96,42.15) 74.4,42.24 75.18,42.24 arc(75.74,42.35) 76.21,42.66 76.43,42.89 arc(77.5,43.61) 78.77,43.86 arc(79.3,43.96) 79.75,44.26 81.84,46.35 arc(81.93,46.48) 81.96,46.63 81.96,47.23 arc(82.23,47.9) 82.89,48.17 83.38,48.17 arc(83.57,48.21) 83.74,48.32 84.11,48.69 arc(85.03,49.48) 86.05,50.11 86.3,50.24 arc(86.33,50.26) 86.36,50.29 86.62,50.55 arc(86.78,50.67) 86.97,50.76 arc(87.06,50.8) 87.14,50.86 87.3,51.02 arc(87.35,51.1) 87.37,51.19 87.37,52.38 arc(87.36,52.41) 87.35,52.45 87.29,52.55 arc(87.22,52.68) 87.18,52.81 arc(87.18,52.82) 87.18,52.83 arc(87.15,52.93) 87.09,53.02 v1(86.85,53.25) 87.16,53.56 arc(87.18,53.58) 87.18,53.61 87.18,53.62 arc(87.29,53.89) 87.56,54 87.76,54 arc(88.03,53.96) 88.27,53.84 arc(88.39,53.78) 88.52,53.76 88.93,53.76 arc(89.09,53.8) 89.2,53.92 89.22,53.95 arc(89.42,54.15) 89.7,54.23 89.83,54.23 arc(89.97,54.26) 90.08,54.36 90.21,54.52 arc(90.37,54.66) 90.58,54.7 90.67,54.7 arc(90.78,54.73) 90.88,54.8 91.16,55.11 arc(91.32,55.22) 91.5,55.26 91.6,55.26 arc(91.71,55.29) 91.79,55.37 91.85,55.48 arc(92.07,55.69) 92.36,55.76 92.43,55.76 arc(92.56,55.8) 92.66,55.88 92.76,56.03 arc(92.94,56.19) 93.18,56.25 93.27,56.25 arc(93.41,56.28) 93.52,56.38 93.65,56.55 arc(93.81,56.69) 94.02,56.74 94.11,56.74 arc(94.23,56.76) 94.33,56.83 94.57,57.11 arc(94.73,57.22) 94.92,57.26 95.07,57.26 arc(95.17,57.29) 95.25,57.37 95.28,57.42 arc(95.5,57.63) 95.79,57.7 95.91,57.7 arc(96.04,57.74) 96.14,57.84 96.22,57.97 arc(96.42,58.18) 96.7,58.25 96.81,58.25 arc(96.88,58.27) 96.94,58.32 97.1,58.53 arc(97.26,58.67) 97.47,58.71 97.6,58.71 arc(97.72,58.74) 97.82,58.81 98.09,59.11 arc(98.25,59.22) 98.43,59.26 98.45,59.26 arc(98.55,59.28) 98.64,59.34 99.13,59.83 arc(99.23,59.9) 99.36,59.93 99.37,59.93
CLK_DDR4_CH3_N: length 98.4
  L14_SIG5 w0.076: 119.08,81.36 119.08,81.34 119.08,81.33 arc(119.06,81.31) 119.06,81.29 119.06,81.16 arc(119.08,81.01) 119.16,80.88 arc(119.19,80.83) 119.21,80.77 arc(119.26,80.59) 119.25,80.4 arc(119.23,80.35) 119.21,80.29 arc(119.16,80.08) 119.21,79.87 arc(119.27,79.61) 119.19,79.36 119.18,79.33 arc(119.14,79.16) 119.19,78.98 arc(119.26,78.74) 119.22,78.49 119.24,78.4 v1(119.51,78.25)
  L14_SIG5 w0.079: 119.08,81.36 119.08,82.29 arc(119.11,82.43) 119.19,82.54 arc(119.28,82.61) 119.39,82.65 arc(119.43,82.66) 119.46,82.66 120.45,82.66 arc(120.46,82.66) 120.46,82.66 120.5,82.64 120.56,82.58 arc(120.58,82.55) 120.59,82.51 v1(120.59,82.28)
  L16_SIG6 w0.076: v1(119.51,78.25) 119.29,78.37 arc(119.2,78.39) 119.13,78.33 119.09,78.27 arc(119.08,78.21) 119.09,78.15 119.19,77.98 arc(119.24,77.78) 119.19,77.59 119.13,77.48 arc(119.1,77.36) 119.13,77.24 119.24,77.05 arc(119.29,76.87) 119.24,76.69 119.14,76.51 arc(119.11,76.41) 119.14,76.3 119.25,76.12 arc(119.3,75.91) 119.25,75.7 119.2,75.62 arc(119.17,75.49) 119.2,75.36 119.25,75.28 arc(119.31,75.07) 119.25,74.86 119.14,74.67 arc(119.11,74.57) 119.14,74.46 119.23,74.3 arc(119.29,74.11) 119.23,73.92 119.12,73.72 arc(119.09,73.61) 119.12,73.5 119.17,73.42 arc(119.22,73.09) 119.06,72.8 arc(118.85,72.68) 118.6,72.64 arc(118.49,72.61) 118.42,72.51 arc(118.4,72.48) 118.39,72.44 arc(118.36,72.38) 118.35,72.31 arc(118.35,72.22) 118.37,72.14 118.38,72.1 arc(118.39,72.08) 118.4,72.07 118.4,72.06 arc(118.45,71.97) 118.47,71.87 118.47,71.77 arc(118.37,71.51) 118.12,71.37 117.97,71.35 arc(117.77,71.28) 117.63,71.13 117.58,71.07 arc(117.37,70.87) 117.1,70.8 arc(116.94,70.76) 116.82,70.64 116.78,70.56 arc(116.62,70.4) 116.39,70.34 116.23,70.34 arc(116.08,70.3) 115.98,70.19 115.92,70.1 arc(115.76,69.94) 115.53,69.88 115.49,69.88 arc(115.34,69.84) 115.24,69.73 115.19,69.64 arc(115.02,69.48) 114.8,69.42 114.64,69.42 arc(114.49,69.38) 114.39,69.27 114.33,69.18 arc(114.17,69.02) 113.94,68.96 113.9,68.96 arc(113.73,68.92) 113.61,68.79 113.55,68.7 arc(113.39,68.53) 113.16,68.47 113.02,68.47 arc(112.91,68.44) 112.83,68.36 112.77,68.26 arc(112.61,68.1) 112.38,68.04 112.29,68.04 arc(112.15,68) 112.04,67.89 111.93,67.71 arc(111.84,67.62) 111.71,67.58 111.51,67.58 arc(111.36,67.54) 111.26,67.44 111.17,67.28 arc(111.02,67.14) 110.83,67.09 110.69,67.09 arc(110.54,67.05) 110.43,66.94 110.42,66.92 arc(110.26,66.76) 110.03,66.7 109.95,66.7 arc(109.77,66.65) 109.64,66.53 arc(109.39,66.29) 109.06,66.19 arc(108.9,66.14) 108.79,66.02 108.78,66 arc(108.61,65.84) 108.39,65.78 108.33,65.78 arc(108.18,65.74) 108.07,65.63 107.96,65.44 arc(107.85,65.33) 107.7,65.29 107.4,65.29 arc(107.25,65.25) 107.14,65.14 107.01,64.92 arc(106.93,64.83) 106.8,64.8 106.75,64.8 arc(106.6,64.76) 106.49,64.64 106.43,64.54 arc(106.29,64.41) 106.11,64.36 105.9,64.36 arc(105.73,64.31) 105.61,64.19 105.54,64.08 arc(105.41,63.95) 105.23,63.9 105.16,63.9 arc(105.02,63.86) 104.91,63.75 104.84,63.63 arc(104.67,63.46) 104.45,63.4 104.35,63.4 arc(104.2,63.36) 104.09,63.25 104.05,63.17 arc(103.88,63) 103.65,62.94 103.51,62.94 arc(103.36,62.9) 103.26,62.8 103.23,62.74 arc(103.06,62.58) 102.84,62.52 102.71,62.52 arc(102.56,62.48) 102.46,62.38 102.38,62.25 arc(102.25,62.11) 102.06,62.06 101.93,62.06 arc(101.79,62.02) 101.68,61.91 101.63,61.82 arc(101.47,61.66) 101.24,61.6 101.13,61.6 arc(101.03,61.58) 100.94,61.52 100.66,61.24 arc(100.54,61.16) 100.4,61.14 100.38,61.14 arc(100.29,61.12) 100.22,61.07 99.9,60.75 arc(99.82,60.7) 99.73,60.68 99.41,60.68 99.39,60.65 99.37,60.65
  L16_SIG6 w0.079: v1(54.87,31.38) 54.56,31.38 arc(54.5,31.41) 54.48,31.46 54.48,31.54 arc(54.55,31.72) 54.73,31.79 59.47,31.79 arc(59.52,31.79) 59.58,31.8 arc(62.07,32.55) 64.18,34.07 66.58,36.46 arc(67.16,37.34) 67.37,38.37 67.37,40.11 arc(67.51,40.86) 67.94,41.49 68.3,41.86 arc(68.94,42.28) 69.69,42.43 70.65,42.43 arc(71.3,42.56) 71.84,42.92 73.99,45.08 arc(75.27,45.93) 76.78,46.23 80.49,46.23 arc(81.2,46.53) 81.49,47.24 81.49,47.48 arc(81.66,48.3) 82.12,48.99 82.37,49.24 arc(82.89,49.59) 83.5,49.71 84.26,49.71 arc(84.8,49.82) 85.27,50.13 85.91,50.78 arc(86.27,51.31) 86.39,51.93 86.39,53.48 arc(86.39,53.52) 86.4,53.56 86.44,53.68 arc(86.46,53.71) 86.48,53.75 arc(86.54,53.82) 86.61,53.89 arc(87.32,54.37) 88.17,54.53 88.89,54.53 arc(89.16,54.61) 89.36,54.8 89.41,54.9 arc(89.53,55.02) 89.7,55.06 89.76,55.06 arc(90.02,55.12) 90.21,55.29 90.36,55.48 arc(90.44,55.55) 90.54,55.57 90.7,55.57 arc(90.91,55.62) 91.09,55.74 91.28,55.96 arc(91.36,56.01) 91.45,56.03 91.6,56.03 arc(91.82,56.09) 91.98,56.25 92.05,56.36 arc(92.18,56.49) 92.36,56.53 92.43,56.53 arc(92.67,56.59) 92.85,56.76 92.95,56.9 arc(93.04,56.99) 93.18,57.02 93.27,57.02 arc(93.51,57.08) 93.7,57.24 93.83,57.42 arc(93.92,57.48) 94.02,57.51 94.11,57.51 arc(94.32,57.55) 94.5,57.68 94.7,57.91 arc(94.78,57.97) 94.88,57.99 95.03,57.99 arc(95.25,58.05) 95.41,58.21 95.52,58.39 arc(95.65,58.52) 95.83,58.57 95.9,58.57 arc(96.15,58.64) 96.34,58.82 96.34,58.83 arc(96.48,58.97) 96.68,59.02 96.71,59.02 arc(96.97,59.09) 97.18,59.26 97.31,59.43 arc(97.39,59.5) 97.49,59.52 97.58,59.52 arc(97.79,59.57) 97.97,59.69 98.15,59.9 arc(98.23,59.95) 98.33,59.97 98.42,59.97 arc(98.6,60.01) 98.75,60.11 99.26,60.62 arc(99.3,60.65) 99.33,60.65 99.37,60.65
CLK_DDR4_CH3_P: length 98.9
  L14_SIG5 w0.076: 118.97,78.55 119.06,78.57 arc(119.09,78.74) 119.04,78.9 arc(118.96,79.15) 119.02,79.42 119.04,79.44 arc(119.09,79.62) 119.05,79.79 arc(118.98,80.08) 119.05,80.37 arc(119.07,80.41) 119.08,80.44 arc(119.08,80.57) 119.05,80.7 arc(119.03,80.74) 119.01,80.77 arc(118.92,80.95) 118.88,81.16 118.88,81.29 arc(118.88,81.31) 118.86,81.33 118.86,81.34 118.86,81.36
  L14_SIG5 w0.079: 118.86,81.36 118.86,82.29 arc(118.9,82.51) 119.03,82.7 arc(119.17,82.81) 119.33,82.87 arc(119.4,82.89) 119.46,82.89 120.48,82.89 arc(120.49,82.89) 120.5,82.89 120.62,83.03 v1(120.62,83.28) ; v1(118.71,78.71) 118.72,78.69 118.97,78.55
  L16_SIG6 w0.076: 99.37,60.88 99.39,60.88 99.41,60.86 99.69,60.86 arc(99.75,60.87) 99.8,60.9 100.09,61.2 arc(100.22,61.28) 100.38,61.31 100.4,61.31 arc(100.47,61.33) 100.53,61.37 100.81,61.65 arc(100.96,61.74) 101.13,61.78 101.24,61.78 arc(101.38,61.81) 101.48,61.91 101.53,62 arc(101.7,62.17) 101.93,62.24 102.06,62.24 arc(102.16,62.26) 102.23,62.33 102.3,62.46 arc(102.47,62.64) 102.71,62.7 102.84,62.7 arc(102.97,62.74) 103.07,62.83 103.1,62.89 arc(103.27,63.06) 103.51,63.12 103.65,63.12 arc(103.79,63.16) 103.89,63.26 103.94,63.34 arc(104.11,63.51) 104.35,63.58 104.45,63.58 arc(104.58,63.61) 104.68,63.71 104.76,63.84 arc(104.93,64.01) 105.16,64.08 105.23,64.08 arc(105.32,64.1) 105.39,64.17 105.45,64.28 arc(105.64,64.47) 105.9,64.54 106.11,64.54 arc(106.21,64.56) 106.28,64.63 106.33,64.73 arc(106.51,64.91) 106.75,64.97 106.8,64.97 arc(106.84,64.98) 106.86,65.01 106.99,65.23 arc(107.16,65.41) 107.4,65.47 107.7,65.47 arc(107.76,65.49) 107.81,65.53 107.92,65.72 arc(108.09,65.89) 108.33,65.96 108.39,65.96 arc(108.53,65.99) 108.63,66.09 108.64,66.11 arc(108.81,66.29) 109.05,66.36 arc(109.3,66.44) 109.49,66.63 arc(109.69,66.81) 109.95,66.87 110.03,66.87 arc(110.17,66.91) 110.27,67.01 110.28,67.03 arc(110.45,67.2) 110.69,67.27 110.83,67.27 arc(110.94,67.29) 111.01,67.37 111.1,67.53 arc(111.27,67.7) 111.51,67.76 111.71,67.76 arc(111.75,67.77) 111.78,67.8 111.89,67.98 arc(112.06,68.15) 112.29,68.22 112.38,68.22 arc(112.52,68.25) 112.62,68.35 112.67,68.45 arc(112.82,68.6) 113.02,68.65 113.16,68.65 arc(113.3,68.69) 113.4,68.79 113.46,68.88 arc(113.64,69.07) 113.9,69.14 113.94,69.14 arc(114.08,69.17) 114.18,69.27 114.23,69.36 arc(114.4,69.53) 114.64,69.6 114.8,69.6 arc(114.93,69.63) 115.03,69.73 115.08,69.82 arc(115.25,69.99) 115.49,70.06 115.53,70.06 arc(115.67,70.09) 115.77,70.19 115.82,70.28 arc(115.99,70.45) 116.23,70.52 116.39,70.52 arc(116.53,70.55) 116.63,70.65 116.67,70.73 arc(116.85,70.91) 117.1,70.98 arc(117.29,71.03) 117.43,71.16 117.48,71.23 arc(117.68,71.43) 117.95,71.53 118.09,71.55 arc(118.23,71.62) 118.29,71.77 118.29,71.87 arc(118.28,71.91) 118.26,71.96 118.25,71.96 arc(118.23,72) 118.22,72.03 118.2,72.08 arc(118.17,72.2) 118.17,72.33 arc(118.19,72.43) 118.23,72.53 arc(118.24,72.55) 118.25,72.58 arc(118.39,72.75) 118.6,72.82 arc(118.79,72.85) 118.95,72.94 arc(119.05,73.12) 119.01,73.33 118.97,73.41 arc(118.91,73.61) 118.97,73.81 119.08,74.01 arc(119.11,74.11) 119.08,74.21 118.99,74.38 arc(118.93,74.57) 118.99,74.76 119.1,74.95 arc(119.13,75.07) 119.1,75.19 119.05,75.27 arc(118.99,75.49) 119.05,75.71 119.09,75.79 arc(119.13,75.91) 119.09,76.03 118.99,76.22 arc(118.93,76.41) 118.99,76.6 119.09,76.78 arc(119.11,76.87) 119.09,76.96 118.98,77.15 arc(118.92,77.36) 118.98,77.57 119.04,77.68 arc(119.07,77.78) 119.04,77.89 118.94,78.06 arc(118.9,78.21) 118.94,78.36 118.97,78.42 arc(118.99,78.51) 118.93,78.59 v1(118.71,78.71)
  L16_SIG6 w0.079: 99.37,60.88 99.33,60.88 arc(99.21,60.86) 99.1,60.78 98.59,60.28 arc(98.51,60.22) 98.42,60.2 98.33,60.2 arc(98.14,60.16) 97.98,60.05 97.8,59.85 arc(97.7,59.77) 97.58,59.75 97.49,59.75 arc(97.29,59.7) 97.12,59.56 97,59.4 arc(96.87,59.29) 96.71,59.25 96.68,59.25 arc(96.37,59.17) 96.15,58.95 96.14,58.94 arc(96.04,58.84) 95.9,58.8 95.83,58.8 arc(95.54,58.72) 95.33,58.51 95.21,58.32 arc(95.13,58.25) 95.03,58.22 94.88,58.22 arc(94.69,58.18) 94.53,58.07 94.33,57.83 arc(94.23,57.76) 94.11,57.74 94.02,57.74 arc(93.81,57.69) 93.65,57.55 93.52,57.38 arc(93.41,57.28) 93.27,57.25 93.18,57.25 arc(92.94,57.19) 92.76,57.03 92.66,56.88 arc(92.56,56.8) 92.43,56.76 92.36,56.76 arc(92.07,56.69) 91.85,56.48 91.79,56.37 arc(91.71,56.29) 91.6,56.26 91.45,56.26 arc(91.26,56.22) 91.11,56.11 90.92,55.9 arc(90.82,55.82) 90.7,55.8 90.54,55.8 arc(90.34,55.75) 90.17,55.61 90.03,55.43 arc(89.91,55.33) 89.76,55.29 89.7,55.29 arc(89.42,55.22) 89.21,55.01 89.16,54.92 arc(89.05,54.8) 88.89,54.76 88.17,54.76 arc(87.24,54.58) 86.44,54.05 arc(86.37,53.97) 86.3,53.89 arc(86.26,53.82) 86.22,53.75 86.18,53.63 arc(86.17,53.55) 86.16,53.48 86.16,51.93 arc(86.06,51.39) 85.75,50.94 85.11,50.29 arc(84.72,50.03) 84.26,49.94 83.5,49.94 arc(82.8,49.8) 82.21,49.4 81.96,49.15 arc(81.44,48.39) 81.26,47.48 81.26,47.24 arc(81.04,46.69) 80.49,46.46 76.78,46.46 arc(75.18,46.14) 73.83,45.24 71.68,43.09 arc(71.21,42.77) 70.65,42.66 69.69,42.66 arc(68.85,42.49) 68.14,42.02 67.78,41.66 arc(67.3,40.95) 67.14,40.11 67.14,38.37 arc(66.95,37.42) 66.42,36.63 64.02,34.23 arc(61.97,32.76) 59.55,32.02 arc(59.51,32.02) 59.47,32.02 54.73,32.02 arc(54.39,31.88) 54.25,31.54 54.25,31.46 arc(54.23,31.41) 54.17,31.38 v1(53.86,31.38)
CLK_MAX10_100M: length 9.8
  TOP w0.149: R385.1 35.3,15.93 35.3,16.75 34.99,17.06 34.99,20.13 34.72,20.4 30.99,20.4 v1(30.5,19.9)
CLK_SYS_100M_N: length 103
  L07_SIG3 w0.076: 117.06,34.48 117.06,34.49 117.07,34.5 arc(117.08,34.52) 117.09,34.54 arc(117.09,34.6) 117.09,34.66 arc(117.09,34.7) 117.09,34.74 arc(117.12,34.84) 117.17,34.93 117.35,35.11 arc(117.37,35.14) 117.38,35.18 117.38,36.07 arc(117.39,36.17) 117.41,36.27 arc(117.43,36.37) 117.44,36.47 117.44,37.04 arc(117.43,37.14) 117.41,37.24 arc(117.39,37.34) 117.38,37.44 117.38,37.59 arc(117.38,37.64) 117.38,37.68 arc(117.38,37.87) 117.44,38.05 arc(117.49,38.23) 117.43,38.41 arc(117.4,38.51) 117.38,38.6 arc(117.38,38.61) 117.38,38.61 arc(117.39,38.69) 117.4,38.77 arc(117.43,38.9) 117.47,39.03 arc(117.49,39.19) 117.44,39.34 arc(117.37,39.67) 117.52,39.98 arc(117.52,39.99) 117.53,39.99 arc(117.55,40.04) 117.54,40.1 arc(117.51,40.14) 117.48,40.19 arc(117.48,40.19) 117.48,40.19 arc(117.43,40.22) 117.37,40.21 v1(117.12,40.07)
  L07_SIG3 w0.085: 117.06,34.48 117.06,31.45 116.64,31.03 116.64,16.76 115.64,15.76 69.64,15.76 68.62,16.78 68.62,17.06 63.28,22.4 61.3,22.4 60.31,23.39 59.69,23.39 56.79,20.49 56.79,20.46 56.59,20.25 56.54,20.25 56.52,20.23 54.84,20.23 54.15,19.54 50.97,19.54 48.5,22 48.5,22.46 arc(48.52,22.5) 48.56,22.52 arc(48.59,22.53) 48.61,22.57 48.61,22.72 arc(48.59,22.76) 48.56,22.77 arc(48.52,22.79) 48.5,22.82 48.5,22.97 arc(48.52,23.01) 48.56,23.03 arc(48.59,23.04) 48.61,23.08 48.61,23.23 arc(48.59,23.27) 48.56,23.28 arc(48.52,23.3) 48.5,23.34 48.5,23.48 arc(48.52,23.52) 48.56,23.54 arc(48.59,23.55) 48.61,23.59 48.61,23.74 arc(48.59,23.78) 48.56,23.79 arc(48.52,23.81) 48.5,23.85 48.5,24.11 47.91,24.7 47.4,24.7 47.31,24.79 v1(47.31,25.1)
CLK_SYS_100M_P: length 103.1
  L07_SIG3 w0.076: v1(117.91,40.53) 117.66,40.38 arc(117.62,40.33) 117.63,40.27 arc(117.65,40.24) 117.68,40.2 arc(117.73,40.03) 117.65,39.87 arc(117.65,39.86) 117.65,39.86 arc(117.55,39.65) 117.59,39.43 arc(117.66,39.2) 117.63,38.97 arc(117.6,38.86) 117.58,38.74 arc(117.57,38.67) 117.56,38.6 arc(117.57,38.55) 117.59,38.51 arc(117.66,38.23) 117.6,37.96 arc(117.55,37.84) 117.55,37.71 arc(117.56,37.65) 117.56,37.59 117.56,37.44 arc(117.57,37.36) 117.58,37.29 arc(117.61,37.16) 117.62,37.04 117.62,36.47 arc(117.61,36.34) 117.58,36.22 arc(117.57,36.14) 117.56,36.07 117.56,35.18 arc(117.54,35.07) 117.48,34.98 117.3,34.8 arc(117.28,34.77) 117.27,34.73 arc(117.27,34.69) 117.27,34.66 arc(117.26,34.6) 117.27,34.55 arc(117.27,34.52) 117.28,34.5 117.29,34.49 117.29,34.48
  L07_SIG3 w0.085: v1(47.31,24.08) 47.31,24.39 47.4,24.48 47.82,24.48 48.28,24.02 48.28,21.91 50.87,19.31 54.24,19.31 54.93,20 56.61,20 56.64,20.03 56.68,20.03 57.02,20.36 57.02,20.4 59.79,23.16 60.22,23.16 61.21,22.17 63.19,22.17 68.39,16.97 68.39,16.68 69.54,15.53 115.74,15.53 116.87,16.67 116.87,30.93 117.29,31.35 117.29,34.48
COMP_0P8: length 4.2
  L16_SIG6 w0.081: v1(70.5,72.55) 71.93,72.55 v1(72.57,71.9)
  BOTTOM w0.149: C7661.2 v1(75.55,71.28) ; v1(72.57,71.9) R5926.1
COMP_1P2: length 8.6
  TOP w0.254: U118.H6 190.73,78.72 v1(190.15,78.14)
  L07_SIG3 w0.089: v1(189.72,82) 189.72,81.69 191.14,80.27 191.14,79.14 v1(190.15,78.14)
  BOTTOM w0.254: C7663.2 188.73,78.14 v1(190.15,78.14) 190.36,77.93 190.61,77.93 190.93,77.61 C2004.2
CORE_PMBUS_SCL: length 353
  TOP w0.225: R309.2 18.2,104.98 16.86,104.98 16.61,105.23 v1(16.61,105.74)
  L07_SIG3 w0.089: v1(16.61,105.74) 17.95,104.39 20,104.39 20.97,105.36 24.2,105.36 24.77,104.8 31.85,104.8 33.86,106.8 59.26,106.8 62.68,110.22 235.26,110.22 235.9,109.58 242.05,109.58 252.23,99.41 252.23,67.75 251.02,66.54 251.02,56.3 252.72,54.6 252.72,52.49 251.43,51.2 251.43,49.47 252.12,48.78 252.12,26.41 248.61,22.9 240.18,22.9 239.65,22.37 237.51,22.37 236.36,21.23 229.71,21.23 229.27,21.68 228.34,21.68 v1(227.97,21.3)
  L16_SIG6 w0.081: v1(16.61,105.74) 16.6,105.74 16.6,109.02 v1(17.13,109.54)
  BOTTOM w0.149: U26.2 17.51,109.17 v1(17.13,109.54)
CORE_PMBUS_SDA: length 348.4
  TOP w0.149: v1(19.44,105.92) 19.78,105.58 R310.2
  L07_SIG3 w0.089: v1(229.11,21.3) 230.15,20.26 236.14,20.26 236.78,20.9 236.78,21.3 237.61,22.13 239.75,22.13 240.26,22.64 248.88,22.64 252.36,26.12 252.36,51.79 253.17,52.6 253.17,98.81 241.5,110.47 62.59,110.47 59.16,107.04 34.08,107.04 32.71,108.42 26.24,108.42 24.73,106.92 20.44,106.92 v1(19.44,105.92)
  L16_SIG6 w0.081: v1(19.92,109.45) 19.92,109.31 18.91,108.31 18.91,106.54 19.44,106.01 v1(19.44,105.92)
  BOTTOM w0.149: v1(19.92,109.45) 19.63,109.45 19.44,109.64 18.64,109.64 18.47,109.47 U26.3
CPU_1V2_RESETN: length 238.2
  L07_SIG3 w0.089: v1(249.25,54.18) 249.19,54.24 249.19,66.42 251.02,68.25 251.02,98.75 242.28,107.5 235.5,107.5 234.22,108.77 196.92,108.77 196.06,107.91 189.62,107.91 187.68,105.97 175.95,105.97 173.63,108.29 128.95,108.29 124.81,104.14 109.61,104.14 109.35,104.4 100.63,104.4 100.21,103.98 100.21,89.59 104.23,85.56 104.78,85.56 105.04,85.3 105.04,84.84 106.82,83.07 107.36,83.07 108.73,81.7 108.73,74.95 v1(108.35,74.57)
CPU_RESETN: length 282.6
  L07_SIG3 w0.089: v1(30.5,21.9) 30.91,21.49 33.48,21.49 33.85,21.11 34.16,21.11 34.53,21.49 36.61,21.49 37.12,22 37.12,22.06 37.34,22.28 38.65,22.28 38.87,22.06 38.87,20.99 39.25,20.61 39.41,20.61 39.81,20.21 39.81,14.34 40.73,13.43 44.21,13.43 45.12,12.52 45.39,12.11 45.58,11.65 45.61,11.51 46.93,10.18 49,10.18 49.64,9.54 58.02,9.54 60.96,6.59 126.73,6.59 127.94,7.81 127.98,7.81 128.89,8.72 128.92,8.72 129.04,8.87 129.05,8.88 129.08,8.93 129.37,9.21 129.41,9.24 131.27,11.1 131.59,11.1 134.22,13.73 137.03,13.73 137.33,13.43 138.16,13.43 176.3,13.43 179.51,16.63 195.33,16.63 196.79,18.09 198.73,18.09 200.31,16.51 210.19,16.51 211.74,18.06 211.8,18.06 212.03,18.29 212.03,18.31 214.57,20.85 214.99,20.85 216.77,22.62 218.21,22.62 218.91,21.92 222.33,21.92 222.73,22.32 229.3,22.32 229.7,21.92 236.37,21.92 237.31,22.86 237.58,22.86 244.16,29.43 244.16,29.83 248.18,33.85 249.66,33.85 251.15,35.34 251.15,46.71 249.53,48.34 v1(249.25,48.34)
  L14_SIG5 w0.081: v1(249.25,48.34) 247.95,49.64 247.95,65.44 247.15,66.25 v1(245.19,66.25)
  BOTTOM w0.149: R365.1 245.18,66.24 v1(245.19,66.25)
CXL_PERST1_N: length 16.8
  TOP w0.149: v1(219.72,33.38) 219.72,33.38 J6.A29
  L03_SIG1 w0.081: v1(219.72,33.38) 221.51,33.38 222.89,32.01 v1(222.89,21.92)
  BOTTOM w0.149: R187.2 222.26,22.56 v1(222.89,21.92)
CXL_PERST2_N: length 2.6
  TOP w0.149: J7.A11 219.72,51.29 v1(219.72,51.29)
  BOTTOM w0.149: v1(219.72,51.29) 219.4,50.97 R188.2
CXL_PERST3_N: length 2.1
  TOP w0.149: v1(218.83,61.55) 219.37,62.09 J7.A29
CXL_PERSTN: length 203.4
  TOP w0.149: v1(219.03,24.01) 219.03,23.3 219.72,22.61 220.68,22.61 J6.A11
  L03_SIG1 w0.081: v1(245.06,58.12) 245.06,56.77 249.65,52.19 249.65,47.39 v1(249.37,47.12)
  L07_SIG3 w0.089: v1(249.37,47.12) 248.26,47.12 247.33,46.19 247.33,41.81 244.75,39.23 244.75,35.24 243.05,33.54 243.05,29.35 237.28,23.58 237.01,23.58 236.07,22.65 230,22.65 229.6,23.04 229.4,23.04 228.69,23.04 227.08,24.65 223.5,24.65 222.24,23.39 220.7,23.39 219.91,24.18 219.2,24.18 v1(219.03,24.01)
  L12_SIG4 w0.089: v1(142.93,34.06) 142.93,32.41 146.85,28.49 161.94,28.49 161.99,28.44 171.15,28.44 172.29,27.31 176.45,27.31 177.73,26.03 177.73,22.25 179.37,20.61 179.37,19.54 180.54,18.37 190.53,18.37 190.64,18.49 192.27,18.49 192.38,18.37 194.34,18.37 194.65,18.69 196.64,18.69 196.88,18.93 197.87,18.93 198.66,18.14 199.15,18.14 200.22,17.06 202.03,17.06 202.53,16.57 209.09,16.57 212.29,19.77 213.84,19.77 215.16,21.1 215.16,21.44 215.54,21.82 215.54,22.15 215.53,22.16 216.75,23.39 217.24,23.39 217.47,23.62 217.47,23.95 217.53,24.01 v1(219.03,24.01)
  L14_SIG5 w0.081: v1(245.06,58.12) 245.06,57.22 243.69,55.84 238.47,55.84 237.26,57.06 225.56,57.06 222.15,60.47 218.89,60.47 v1(218.83,60.53) 218.83,51.11 v1(217.7,49.98)
  BOTTOM w0.149: R370.1 R366.1 ; v1(219.03,24.01) 219.03,23.71 220.13,22.61 220.24,22.61 R187.1 ; R188.1 217.79,50.08 v1(217.7,49.98) ; v1(142.93,34.06) 143,34 143,32.81 142.78,32.59 U19.2
CXL_PRSNTX1_N: length 88.7
  TOP w0.149: v1(223.78,23.35) 223.78,23.3 223.24,23.3 223.12,23.18 J6.A12
  L16_SIG6 w0.081: v1(223.78,23.35) 223.6,23.53 223.6,30.95 224.99,32.34 224.99,36.55 223.89,37.65 223.89,61.89 224.25,62.25 224.25,68.73 222.17,70.81 211.69,70.81 210.43,69.55 208.09,69.55 205.14,72.5 205.14,89.05 v5(205.6,89.51)
CXL_PRSNTX4_N: length 77.4
  TOP w0.149: J6.A30 222.72,33.98 222.98,34.25 222.98,34.45 223.38,34.85 223.64,34.85 v1(223.95,35.17)
  L16_SIG6 w0.081: v5(205.6,90.16) 204.75,89.31 204.75,72.56 207.99,69.32 210.53,69.32 211.78,70.57 222.08,70.57 223.89,68.76 223.89,62.22 223.65,61.99 223.65,37.55 223.89,37.32 223.89,35.23 v1(223.95,35.17)
CXL_PRSNTX8_N: length 59.9
  TOP w0.149: v1(223.18,51.89) J7.A12
  L16_SIG6 w0.081: v5(205.6,90.81) 204.52,89.73 204.52,77.74 204.52,72.46 207.89,69.09 210.62,69.09 211.88,70.34 221.98,70.34 223.59,68.73 223.59,62.44 223.41,62.25 223.41,52.11 v1(223.18,51.89)
CXL_PRSNTX16_N: length 49.8
  TOP w0.149: J7.A30 v1(223.22,62.69)
  L16_SIG6 w0.081: v1(223.22,62.69) 223.36,62.82 223.36,68.63 221.88,70.11 211.98,70.11 210.72,68.85 207.8,68.85 204.29,72.36 204.29,72.61 204.29,90.15 v5(205.6,91.46)
CXL_RX_N0: length 95.3
  TOP w0.116: J6.A3 v6(222.08,17.78)
  L16_SIG6 w0.085: v6(222.08,17.78) 221.95,17.66 arc(221.87,17.6) 221.78,17.59 216.55,17.59 arc(216.5,17.59) 216.44,17.59 arc(213.9,18.32) 211.68,19.75 arc(211.48,19.96) 211.31,20.18 210.5,21.4 arc(210.49,21.42) 210.48,21.44 210.29,21.89 arc(210.22,22.1) 210.17,22.31 arc(209.94,22.99) 209.52,23.58 209.49,23.6 arc(208.54,24.24) 207.41,24.46 204.87,24.46 arc(204.5,24.39) 204.19,24.18 204.07,24.06 arc(203.05,23.38) 201.85,23.14 199.03,23.14 arc(197.89,23.37) 196.93,24.01 195.66,25.28 arc(194.68,25.94) 193.51,26.17 185.68,26.17 arc(185.19,26.24) 184.73,26.43 arc(184.18,26.66) 183.58,26.74 180.48,26.74 arc(179.93,26.85) 179.46,27.16 arc(179.12,27.46) 178.74,27.7 arc(178.65,27.73) 178.56,27.74 174.07,27.74 arc(172.06,28.14) 170.35,29.29 169.13,30.5 arc(167.28,31.74) 165.09,32.17 164.26,32.17 arc(161.57,32.71) 159.29,34.23 152.29,41.23 arc(151.9,41.49) 151.44,41.58 146.45,41.58 arc(145.88,41.7) 145.39,42.02 144.31,43.1 144.02,43.22 143.56,43.22 arc(143.44,43.25) 143.34,43.32 143.06,43.59 arc(142.88,43.71) 142.65,43.76 142.57,43.76 arc(142.43,43.79) 142.33,43.89 142.3,43.94 arc(142.11,44.13) 141.85,44.2 141.74,44.2 arc(141.65,44.22) 141.59,44.28 141.47,44.49 arc(141.27,44.69) 141,44.76 140.86,44.76 arc(140.59,44.69) 140.39,44.49 140.33,44.39 arc(140.27,44.16) 140.33,43.94 140.37,43.87 arc(140.38,43.81) 140.34,43.75 v1(140.06,43.6)
