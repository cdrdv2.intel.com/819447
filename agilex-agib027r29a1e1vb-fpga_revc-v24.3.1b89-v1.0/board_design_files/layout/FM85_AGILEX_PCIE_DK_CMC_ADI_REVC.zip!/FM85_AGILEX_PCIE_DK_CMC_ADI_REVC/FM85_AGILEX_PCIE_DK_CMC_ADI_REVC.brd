# Allegro board FM85_AGILEX_PCIE_DK_CMC_ADI_REVC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_DDIMM_DQ5: length 101.7
  L03_SIG1 w0.081: v2(137.84,78.71) 138.07,78.71 138.63,78.71 arc(138.82,78.75) 138.98,78.87 arc(139.03,78.92) 139.1,78.96 139.43,79.15 arc(139.47,79.16) 139.51,79.16 arc(139.67,79.1) 139.8,78.98 arc(139.82,78.94) 139.83,78.9 arc(139.84,78.83) 139.88,78.77 140.03,78.62 140.38,78.62 140.63,78.37 140.84,78.37 140.87,78.34 141.21,78.34 141.67,77.88 141.97,77.88 142.43,78.34 142.77,78.34 142.8,78.37 143.01,78.37 143.26,78.62 143.57,78.62 143.82,78.37 145.31,78.37 145.83,77.85 154.91,77.85 155.68,78.63 155.68,79.36 155.68,87 162.91,94.22 164.92,94.22 165.24,94.54 165.24,97.4 165.36,97.52 166.45,97.52 166.53,97.6 166.53,98.3 166.61,98.38 166.79,98.38 166.87,98.3 166.87,97.6 166.95,97.52 167.12,97.52 167.2,97.6 167.2,98.3 167.28,98.38 167.46,98.38 167.54,98.3 167.54,97.6 167.62,97.52 167.79,97.52 167.87,97.6 167.87,98.3 167.96,98.38 168.13,98.38 168.21,98.3 168.21,97.6 168.29,97.52 168.46,97.52 168.54,97.6 168.54,98.3 168.63,98.38 168.8,98.38 168.88,98.3 168.88,97.6 168.96,97.52 169.13,97.52 169.21,97.6 169.21,98.3 169.3,98.38 169.47,98.38 169.55,98.3 169.55,97.6 169.63,97.52 169.8,97.52 169.89,97.6 169.89,98.3 169.97,98.38 170.14,98.38 170.22,98.3 170.22,97.6 170.3,97.52 170.47,97.52 170.56,97.6 170.56,98.3 170.64,98.38 170.81,98.38 170.89,98.3 170.89,97.6 170.97,97.52 171.15,97.52 171.23,97.6 171.23,98.3 171.31,98.38 171.48,98.38 171.56,98.3 171.56,97.6 171.64,97.52 171.82,97.52 171.9,97.6 171.9,98.3 171.98,98.38 172.15,98.38 172.23,98.3 172.23,97.6 172.31,97.52 172.49,97.52 172.57,97.6 172.57,98.3 172.65,98.38 172.82,98.38 172.9,98.3 172.9,97.6 172.98,97.52 173.16,97.52 173.24,97.6 173.24,98.07 173.32,98.15 173.49,98.15 173.57,98.07 173.57,97.6 173.65,97.52 178.29,97.52 178.42,97.64 178.42,99.29 178.73,99.61 180.5,99.61 183.82,102.92 183.82,105.17 183.56,105.43 183.56,106.11 184.84,107.38 193.94,107.38 194.38,106.94 194.38,106.11 193.73,105.45 193.73,102.64 193.32,102.24 193.3,102.24 193.3,102.21 v1(193.32,102.21)
DDR4_DDIMM_DQ6: length 101.6
  L03_SIG1 w0.081: v2(138.63,77.33) 138.63,77.07 139.72,75.99 142.03,75.99 142.16,76.11 142.17,76.11 142.54,76.48 143.26,76.48 143.86,75.88 149.82,75.88 150.18,75.52 150.58,75.52 150.58,75.52 155.4,75.52 155.41,75.52 155.43,75.52 155.74,75.21 158.73,75.21 162.71,79.18 164.59,79.18 167.04,81.63 167.04,85.55 168.24,86.75 168.24,87.39 172.42,91.57 173.71,91.57 174.82,92.69 177.97,92.69 179.13,93.85 179.13,94.37 181.42,96.66 182.5,96.66 183.15,97.32 187.16,97.32 189.97,100.13 189.97,100.57 190.29,100.89 190.29,101.24 189.92,101.62 188.63,101.62 186.95,99.93 185.41,99.93 185.18,100.16 185.18,100.67 185.26,100.75 185.98,100.75 186.06,100.83 186.06,101 185.98,101.09 185.21,101.09 185.13,101.17 185.13,101.34 185.21,101.42 185.98,101.42 186.06,101.5 186.06,101.67 185.98,101.76 185.21,101.76 185.13,101.84 185.13,102.01 185.21,102.09 185.98,102.09 186.06,102.17 186.06,102.35 185.98,102.43 185.21,102.43 185.13,102.51 185.13,102.68 185.21,102.76 185.98,102.76 186.06,102.84 186.06,103.02 185.98,103.1 185.21,103.1 185.13,103.18 185.13,103.35 185.21,103.43 185.98,103.43 186.06,103.51 186.06,103.69 185.98,103.77 185.21,103.77 185.13,103.85 185.13,104.02 185.21,104.1 185.98,104.1 186.06,104.18 186.06,104.36 185.98,104.44 185.21,104.44 185.13,104.52 185.13,104.69 185.21,104.77 185.98,104.77 186.06,104.85 186.06,105.03 185.98,105.11 185.21,105.11 185.13,105.19 185.13,105.41 185.71,105.99 186.5,105.99 186.7,105.79 186.7,105.08 186.78,105 187.65,105 187.74,104.92 187.74,104.75 187.65,104.67 186.78,104.67 186.7,104.59 186.7,104.41 186.78,104.33 187.65,104.33 187.74,104.25 187.74,104.08 187.65,104 186.78,104 186.7,103.92 186.7,103.68 186.9,103.48 188.02,103.48 188.19,103.66 v1(188.19,105.57)
DDR4_DDIMM_DQ7: length 102
  L03_SIG1 w0.081: v1(187.29,101.09) 187.29,101.93 187.55,102.19 187.55,102.78 187.63,102.86 187.8,102.86 187.88,102.78 187.88,102.19 187.96,102.11 188.14,102.11 188.22,102.19 188.22,102.97 188.3,103.06 188.47,103.06 188.55,102.97 188.55,102.19 188.64,102.11 188.81,102.11 188.89,102.19 188.89,102.97 188.97,103.06 189.14,103.06 189.22,102.97 189.22,102.13 189.4,101.95 190.05,101.95 190.63,101.38 190.63,100.75 190.56,100.68 190.56,100.68 190.35,100.47 190.35,99.79 190.21,99.65 190.21,99.17 187.97,96.92 183.23,96.92 182.63,96.33 181.56,96.33 179.46,94.23 179.46,93.71 178.11,92.35 174.96,92.35 173.85,91.24 172.56,91.24 168.57,87.25 168.57,86.61 167.37,85.41 167.37,81.49 164.68,78.8 162.79,78.8 160.13,76.13 160.13,75.02 159.98,74.87 159.63,74.87 159.55,74.79 159.55,74.53 159.47,74.45 159.3,74.45 159.22,74.53 159.22,74.79 159.14,74.87 158.96,74.87 158.88,74.79 158.88,74.53 158.8,74.45 158.63,74.45 158.55,74.53 158.55,74.79 158.47,74.87 158.29,74.87 158.21,74.79 158.21,74.53 158.13,74.45 157.96,74.45 157.88,74.53 157.88,74.79 157.79,74.87 157.62,74.87 157.54,74.79 157.54,74.53 157.46,74.45 157.29,74.45 157.21,74.53 157.21,74.79 157.12,74.87 156.95,74.87 156.87,74.79 156.87,74.53 156.79,74.45 156.62,74.45 156.53,74.53 156.53,74.79 156.45,74.87 156.28,74.87 156.2,74.79 156.2,74.53 156.12,74.45 155.95,74.45 155.86,74.53 155.86,74.79 155.78,74.87 155.58,74.87 155.26,75.19 151.02,75.19 150.83,75 150.83,74.53 150.66,74.37 150.19,74.37 150.11,74.45 150.11,74.77 150.03,74.85 149.85,74.85 149.77,74.77 149.77,74.45 149.69,74.37 149.42,74.37 149.33,74.45 149.33,75.42 149.25,75.5 149.08,75.5 149,75.42 149,74.45 148.92,74.37 148.74,74.37 148.66,74.45 148.66,75.42 148.58,75.5 148.41,75.5 148.33,75.42 148.33,74.45 148.25,74.37 148.07,74.37 147.99,74.45 147.99,75.42 147.91,75.5 147.74,75.5 147.66,75.42 147.66,74.45 147.58,74.37 147.4,74.37 147.32,74.45 147.32,75.42 147.24,75.5 147.07,75.5 146.99,75.42 146.99,74.45 146.91,74.37 146.73,74.37 146.65,74.45 146.65,75.42 146.57,75.5 146.4,75.5 146.32,75.42 146.32,74.45 146.24,74.37 146.06,74.37 145.98,74.45 145.98,75.42 145.9,75.5 145.73,75.5 145.65,75.42 145.65,74.45 145.56,74.37 145.39,74.37 145.31,74.45 145.31,75.42 145.23,75.5 145.06,75.5 144.98,75.42 144.98,74.45 144.89,74.37 144.72,74.37 144.64,74.45 144.64,75.42 144.56,75.5 144.39,75.5 144.31,75.42 144.31,74.45 144.22,74.37 144.09,74.37 143.97,74.49 143.97,75.14 143.89,75.22 143.35,75.22 143.07,75.5 142.3,75.5 142.14,75.34 142.14,75.18 142.05,75.1 141.77,75.1 141.35,75.52 140.59,75.52 140.27,75.2 139.77,75.2 139.25,75.72 139.11,75.72 137.95,76.87 v2(137.84,76.87)
DDR4_DDIMM_DQ8: length 74.3
  L05_SIG2 w0.081: v1(183.04,105.57) 182.5,106.11 180.18,106.11 180.03,105.96 180.03,103.62 179.87,103.45 178.79,103.45 177.5,102.16 177.5,98.32 176.73,97.55 171.84,97.55 171.76,97.63 171.76,97.92 171.68,98 171.51,98 171.43,97.92 171.43,97.63 171.35,97.55 171.17,97.55 171.09,97.63 171.09,97.92 171.01,98 170.84,98 170.76,97.92 170.76,97.63 170.67,97.55 170.5,97.55 170.42,97.63 170.42,97.92 170.34,98 170.17,98 170.09,97.92 170.09,97.63 170,97.55 169.83,97.55 169.75,97.63 169.75,97.92 169.67,98 169.5,98 169.41,97.92 169.41,97.63 169.33,97.55 169.16,97.55 169.08,97.63 169.08,97.92 169,98 168.83,98 168.74,97.92 168.74,97.63 168.66,97.55 168.49,97.55 168.41,97.63 168.41,97.92 168.33,98 168.16,98 168.07,97.92 168.07,97.63 167.99,97.55 167.14,97.55 166.12,96.53 147.57,96.53 142.77,91.73 135.19,91.73 135.14,91.68 135.06,91.68 132.68,89.31 132.68,81.86 133.05,81.49 v1(133.05,80.55)
DDR4_DDIMM_DQ9: length 73.9
  L05_SIG2 w0.081: v1(132.26,81.01) 132.26,84.49 131.81,84.95 131.81,89.59 135.32,93.1 135.68,93.1 135.87,92.91 143.3,92.91 147.25,96.87 163.81,96.87 164.46,97.51 166.28,97.51 167.14,98.37 174.61,98.37 176.77,100.53 176.77,102 179.39,104.62 179.39,105.01 179.16,105.24 179.16,106.24 179.37,106.44 182.72,106.44 183.45,105.72 183.45,105.25 182.2,104 v1(182.2,102.29)
DDR4_DDIMM_DQ10: length 75.6
  L05_SIG2 w0.081: v1(133.05,79.63) 132.15,79.63 131.54,80.24 131.54,84.12 131.1,84.55 131.1,89.96 135.99,94.85 142.72,94.85 142.94,95.06 143.07,95.06 143.74,95.73 144.62,95.73 147,98.11 150.37,98.11 155.14,102.87 171.15,102.87 171.23,102.95 171.23,103.91 171.34,104.02 171.48,104.02 171.57,103.93 171.57,102.95 171.65,102.87 171.82,102.87 171.9,102.95 171.9,103.67 171.98,103.75 172.16,103.75 172.24,103.67 172.24,102.95 172.32,102.87 172.49,102.87 172.57,102.95 172.57,103.67 172.65,103.75 172.83,103.75 172.91,103.67 172.91,102.95 172.99,102.87 173.16,102.87 173.24,102.95 173.24,103.67 173.32,103.75 173.5,103.75 173.58,103.67 173.58,102.95 173.66,102.87 173.83,102.87 173.91,102.95 173.91,103.67 173.99,103.75 174.17,103.75 174.25,103.67 174.25,102.95 174.33,102.87 174.5,102.87 174.58,102.95 174.58,103.71 174.66,103.79 174.83,103.79 174.92,103.7 174.92,102.95 175,102.87 176.85,102.87 177.09,103.11 v1(177.09,105.57)
DDR4_DDIMM_DQ11: length 76.5
  L05_SIG2 w0.081: v1(132.26,79.17) 133.12,79.17 133.44,79.49 133.44,79.77 133.15,80.06 132.93,80.06 132.52,80.47 132.09,80.47 131.87,80.69 131.87,84.25 131.87,84.26 131.87,84.41 131.44,84.84 131.44,87.36 131.47,87.4 131.47,89.72 135.46,93.72 142.85,93.72 143.55,94.41 143.55,94.46 143.78,94.7 144.06,94.7 147.13,97.77 151.7,97.77 153.78,99.86 163.12,99.86 163.2,99.94 163.2,100.46 163.28,100.54 163.45,100.54 163.53,100.46 163.53,99.94 163.62,99.86 163.79,99.86 163.87,99.94 163.87,100.46 163.95,100.54 164.12,100.54 164.2,100.46 164.2,99.94 164.29,99.86 164.46,99.86 164.54,99.94 164.54,100.46 164.62,100.54 164.79,100.54 164.88,100.46 164.88,99.94 164.96,99.86 165.13,99.86 165.21,99.94 165.21,100.46 165.29,100.54 165.46,100.54 165.55,100.46 165.55,99.94 165.63,99.86 165.8,99.86 165.88,99.94 165.88,100.46 165.96,100.54 166.14,100.54 166.22,100.46 166.22,99.94 166.3,99.86 166.47,99.86 166.55,99.94 166.55,100.46 166.63,100.54 166.81,100.54 166.89,100.46 166.89,99.94 166.97,99.86 167.14,99.86 167.22,99.94 167.22,100.46 167.3,100.54 167.48,100.54 167.56,100.46 167.56,99.94 167.64,99.86 167.81,99.86 167.89,99.94 167.89,100.46 167.97,100.54 168.15,100.54 168.23,100.46 168.23,99.94 168.31,99.86 168.48,99.86 168.56,99.94 168.56,100.46 168.64,100.54 168.82,100.54 168.9,100.46 168.9,99.94 168.98,99.86 169.15,99.86 169.23,99.94 169.23,100.46 169.32,100.54 169.49,100.54 169.57,100.46 169.57,99.94 169.65,99.86 169.82,99.86 169.9,99.94 169.9,100.46 169.99,100.54 170.16,100.54 170.24,100.46 170.24,99.94 170.32,99.86 170.49,99.86 170.58,99.94 170.58,100.46 170.66,100.54 170.83,100.54 170.91,100.46 170.91,99.94 170.99,99.86 175.13,99.86 v1(176.24,100.96)
DDR4_DDIMM_DQ12: length 73.8
  TOP w0.149: v1(184.73,105.01) 184.74,105.02 J2.14
  L05_SIG2 w0.081: v1(184.73,105.01) 184.73,102.36 183.48,101.1 183.48,98.53 180.08,95.13 177.84,95.13 176.79,94.07 172.4,94.07 172.13,93.8 169.69,93.8 169.55,93.67 169.55,93.09 169.43,92.97 169.09,92.97 169.01,93.05 169.01,93.44 168.93,93.52 168.75,93.52 168.67,93.44 168.67,93.07 168.57,92.97 168.42,92.97 168.34,93.05 168.34,93.44 168.26,93.52 168.08,93.52 168,93.44 168,93.07 167.9,92.97 167.75,92.97 167.67,93.05 167.67,93.44 167.59,93.52 167.41,93.52 167.33,93.44 167.33,93.07 167.23,92.97 166.97,92.97 166.89,92.89 166.89,92.61 166.81,92.53 166.64,92.53 166.56,92.61 166.56,92.89 166.47,92.97 166.3,92.97 166.22,92.89 166.22,92.61 166.14,92.53 165.97,92.53 165.88,92.61 165.88,92.89 165.8,92.97 165.63,92.97 165.55,92.89 165.55,92.61 165.47,92.53 165.3,92.53 165.21,92.61 165.21,92.89 165.13,92.97 164.96,92.97 164.88,92.89 164.88,92.61 164.8,92.53 164.63,92.53 164.54,92.61 164.54,92.89 164.46,92.97 164.29,92.97 164.21,92.89 164.21,92.61 164.13,92.53 163.95,92.53 163.87,92.61 163.87,92.89 163.79,92.97 163.08,92.97 159.41,89.31 137.5,89.31 136.47,88.28 136.47,88.25 136.45,88.22 136.45,82.76 136.24,82.56 v1(136.24,80.55)
DDR4_DDIMM_DQ13: length 74.5
  L05_SIG2 w0.081: v1(136.24,79.63) 136.24,79.94 136.65,80.35 136.65,82.49 136.78,82.63 136.78,88.09 137.67,88.97 159.97,88.97 163.19,92.19 164.11,92.19 164.19,92.11 164.19,90.76 164.28,90.68 164.45,90.68 164.53,90.76 164.53,92.11 164.61,92.19 164.78,92.19 164.86,92.11 164.86,90.76 164.95,90.68 165.12,90.68 165.2,90.76 165.2,92.11 165.28,92.19 165.45,92.19 165.54,92.11 165.54,90.76 165.62,90.68 165.79,90.68 165.87,90.76 165.87,92.11 165.95,92.19 166.12,92.19 166.21,92.11 166.21,90.76 166.29,90.68 166.46,90.68 166.54,90.76 166.54,92.11 166.62,92.19 169.13,92.19 169.81,92.87 171.89,92.87 172.11,93.09 172.11,93.31 172.54,93.74 177.5,93.74 178.56,94.79 180.22,94.79 184.34,98.91 184.34,100.03 184.16,100.21 184.02,100.21 183.89,100.34 v1(183.89,100.96)
DDR4_DDIMM_DQ14: length 73.9
  L05_SIG2 w0.081: v1(178.79,105.57) 178.79,106.52 179.05,106.78 183.27,106.78 184.25,105.8 184.25,105.1 182.57,103.42 182.57,102.13 181.81,101.38 181.81,97.84 179.77,95.8 177.57,95.8 176.95,95.18 171.97,95.18 171.55,94.76 163.88,94.76 159.1,89.98 136.97,89.98 135.19,88.19 135.19,82.78 135.53,82.44 135.53,81.95 135.53,81.17 135.41,81.05 135.42,81.03 v1(135.45,81.01)
DDR4_DDIMM_DQ15: length 75.3
  TOP w0.149: v1(183.32,103.08) 178.23,103.08 177.94,102.79 J2.166
  L05_SIG2 w0.081: v1(135.45,79.17) 135.82,79.54 135.82,80.73 135.87,80.79 135.87,82.59 135.52,82.95 135.52,88.05 137.11,89.64 159.23,89.64 163.99,94.4 164.73,94.4 164.81,94.32 164.81,93.89 164.89,93.81 165.06,93.81 165.14,93.89 165.14,94.32 165.23,94.4 165.4,94.4 165.48,94.32 165.48,93.89 165.56,93.81 165.73,93.81 165.82,93.89 165.82,94.32 165.9,94.4 166.07,94.4 166.15,94.32 166.15,93.89 166.23,93.81 166.4,93.81 166.49,93.89 166.49,94.32 166.57,94.4 172.26,94.4 172.54,94.68 176.93,94.68 177.71,95.46 179.95,95.46 182.59,98.11 182.59,101.07 183.32,101.81 v1(183.32,103.08)
DDR4_DDIMM_DQ16: length 55.5
  L16_SIG6 w0.081: v1(173.69,105.57) 173.69,106.67 173.43,106.93 169.74,106.93 167.83,105.02 167.83,102.24 167.49,101.89 164.71,101.89 161.42,98.61 161.42,97.84 158.8,95.22 158.8,92.49 158.35,92.04 148.65,92.04 143.14,86.53 143.14,84.71 139.93,81.5 139.93,81.37 139.06,80.5 139.06,78.4 139.3,78.16 139.64,78.16 140.23,77.57 v1(140.23,77.33)
DDR4_DDIMM_DQ17: length 56.1
  L16_SIG6 w0.081: v1(172.85,102.31) 173.18,102.31 173.29,102.42 173.29,105.36 172.27,106.39 169.75,106.39 168.22,104.86 168.22,104.52 168.3,104.44 168.76,104.44 168.84,104.36 168.84,104.18 168.76,104.1 168.3,104.1 168.22,104.02 168.22,103.85 168.3,103.77 168.76,103.77 168.84,103.69 168.84,103.51 168.76,103.43 168.3,103.43 168.22,103.35 168.22,100.65 165.67,98.1 165.67,97.67 158.49,90.48 148.18,90.48 143.81,86.11 143.81,84.38 140.98,81.55 140.98,80.31 139.94,79.27 139.94,78.54 v1(140.23,78.25)
DDR4_DDIMM_DQ18: length 55.2
  L16_SIG6 w0.081: v1(139.43,76.87) 139.43,77.19 138.26,78.36 138.26,80.34 139.22,81.3 139.36,81.3 139.59,81.54 139.59,81.86 139.59,83.01 140.49,83.91 141.78,83.91 142.81,84.94 142.81,86.67 148.93,92.79 155.07,92.79 155.47,93.19 155.47,94.45 163.8,102.77 164.34,102.77 164.42,102.86 164.42,104.05 164.5,104.13 164.67,104.13 164.75,104.05 164.75,102.86 164.84,102.77 165.01,102.77 165.09,102.86 165.09,104.05 165.17,104.13 165.34,104.13 165.42,104.05 165.42,102.86 165.51,102.77 165.68,102.77 165.76,102.86 165.76,104.05 165.84,104.13 166.01,104.13 166.1,104.05 166.1,102.86 166.18,102.77 166.82,102.77 167.33,103.28 167.33,105.15 v1(167.74,105.57)
DDR4_DDIMM_DQ19: length 55.5
  L16_SIG6 w0.081: v1(166.89,100.96) 166.21,100.28 165.62,100.28 165.54,100.2 165.54,98.62 165.46,98.53 165.29,98.53 165.21,98.62 165.21,100.2 165.13,100.28 164.95,100.28 164.87,100.2 164.87,98.62 164.79,98.53 164.62,98.53 164.54,98.62 164.54,100.2 164.46,100.28 164.13,100.28 163.83,99.98 163.83,96.78 161.84,94.79 160.92,94.79 160.62,94.49 160.62,93.09 158.38,90.85 157.83,90.85 157.75,90.93 157.75,91.47 157.67,91.55 157.5,91.55 157.41,91.47 157.41,90.93 157.33,90.85 157.16,90.85 157.08,90.93 157.08,91.47 157,91.55 156.83,91.55 156.74,91.47 156.74,90.93 156.66,90.85 156.49,90.85 156.41,90.93 156.41,91.47 156.33,91.55 156.15,91.55 156.07,91.47 156.07,90.93 155.99,90.85 155.82,90.85 155.74,90.93 155.74,91.47 155.66,91.55 155.48,91.55 155.4,91.47 155.4,90.93 155.32,90.85 155.15,90.85 155.07,90.93 155.07,91.47 154.99,91.55 154.81,91.55 154.73,91.47 154.73,90.93 154.65,90.85 154.48,90.85 154.4,90.93 154.4,91.47 154.32,91.55 154.14,91.55 154.06,91.47 154.06,90.93 153.98,90.85 147.97,90.85 143.48,86.35 143.48,84.57 140.62,81.72 140.62,80.88 140.2,80.46 140.02,80.46 139.43,79.87 v1(139.43,78.71)
DDR4_DDIMM_DQ20: length 52.8
  L16_SIG6 w0.081: v1(175.39,105.57) 174.96,105.13 174.96,97.59 175.25,97.3 175.25,96.99 174.96,96.71 174.96,96.21 171.68,92.93 171.68,92.1 169.18,89.61 164.55,89.61 162.56,87.63 149.62,87.63 146.57,84.58 146.57,82.75 144.62,80.8 144.62,78.31 144.1,77.79 v1(142.62,77.79)
DDR4_DDIMM_DQ21: length 52.5
  L16_SIG6 w0.081: v1(143.41,78.25) 143.84,78.25 144.24,78.65 144.24,80.9 146.23,82.9 146.23,84.71 149.48,87.96 162.43,87.96 164.41,89.94 169.04,89.94 169.28,90.18 169.28,90.29 168.87,90.71 168.87,90.82 168.99,90.94 169.1,90.94 169.52,90.53 169.63,90.53 169.75,90.65 169.75,90.77 169.34,91.18 169.34,91.29 169.46,91.42 169.58,91.42 169.99,91 170.11,91 171.35,92.24 171.35,93.07 174.15,95.87 174.15,96.52 174.07,96.6 173.67,96.6 173.59,96.68 173.59,96.85 173.67,96.94 174.07,96.94 174.15,97.02 174.15,97.19 174.07,97.27 173.67,97.27 173.59,97.35 173.59,97.52 173.67,97.61 174.07,97.61 174.15,97.69 174.15,97.86 174.07,97.94 173.67,97.94 173.59,98.02 173.59,98.2 173.67,98.28 174.07,98.28 174.15,98.36 174.15,98.53 174.07,98.61 173.67,98.61 173.59,98.69 173.59,98.87 173.67,98.95 174.07,98.95 174.15,99.03 174.15,100.57 v1(174.54,100.96)
DDR4_DDIMM_DQ22: length 53.4
  TOP w0.149: v1(172.89,104.52) 170.14,104.52 169.44,105.21 J2.32
  L16_SIG6 w0.081: v1(142.62,78.71) 143.74,78.71 143.88,78.85 143.88,81.06 145.9,83.08 145.9,84.85 149.34,88.3 162.28,88.3 164.26,90.28 166.69,90.28 173.21,96.8 173.21,100.93 172.48,101.66 172.48,104.11 v1(172.89,104.52)
DDR4_DDIMM_DQ23: length 52.5
  TOP w0.149: J2.177 168.59,100.63 168.82,100.41 172.17,100.41 v1(172.3,100.28)
  L16_SIG6 w0.081: v1(172.3,100.28) 172.45,100.13 172.45,96.51 169,93.06 168.89,93.06 168.64,93.31 168.52,93.31 168.4,93.19 168.4,93.07 168.65,92.83 168.65,92.71 168.53,92.59 168.41,92.59 168.17,92.84 168.05,92.84 167.93,92.71 167.93,92.6 168.17,92.35 168.17,92.24 168.05,92.12 167.94,92.12 167.69,92.36 167.58,92.36 167.45,92.24 167.45,92.13 167.7,91.88 167.7,91.76 167.58,91.64 167.46,91.64 167.22,91.89 167.1,91.89 166.98,91.77 166.98,91.65 167.23,91.4 167.23,91.29 167.1,91.17 166.99,91.17 166.74,91.41 166.63,91.41 166.51,91.29 166.51,91.18 166.75,90.93 166.75,90.82 166.55,90.61 163.76,90.61 163.44,90.29 163.06,90.29 161.4,88.63 149.11,88.63 145.56,85.09 145.56,83.23 142.99,80.65 142.99,79.48 142.68,79.17 v1(141.82,79.17)
DDR4_DDIMM_DQ24: length 43.5
  TOP w0.149: U6.MH15 137.54,80.89 137.54,81.22 v2(136.99,81.77)
  L03_SIG1 w0.081: v1(164.33,106.19) 164.33,106.2 161.9,106.2 arc(160.84,105.98) 159.94,105.38 158.84,104.28 arc(158.34,103.52) 158.16,102.63 158.16,101.5 157.14,100.48 157.14,97.91 156.14,96.9 155.84,96.9 149.87,90.93 148.04,90.93 143.2,86.1 143.2,84.99 142.45,84.24 141.7,84.24 141.69,84.25 139.33,84.25 139.33,84.24 139.33,84.24 138.74,83.66 137.21,83.66 136.54,82.99 136.54,82.22 v2(136.99,81.77)
DDR4_DDIMM_DQ25: length 46.3
  TOP w0.149: J2.183 163.49,102.68 162.94,103.23 157.78,103.23 v1(157.53,103.48)
  L03_SIG1 w0.081: v1(157.53,103.48) 157.53,103.48 157.53,101.9 156.97,101.34 156.97,100.83 156.58,100.43 156.58,99.44 156.18,99.04 156.18,97.81 155.98,97.61 155.66,97.61 153.92,95.87 arc(153.7,95.73) 153.45,95.68 152.88,95.68 arc(152.84,95.67) 152.8,95.67 152.53,95.6 arc(152.49,95.59) 152.45,95.57 arc(152.31,95.47) 152.18,95.35 150.24,93.4 150.24,92.35 149.16,91.27 147.61,91.27 142.86,86.52 142.86,85.13 142.31,84.58 141.84,84.58 141.83,84.58 139.18,84.58 138.75,84.16 137.63,84.16 arc(136.96,84.03) 136.4,83.65 arc(136.02,83.06) 135.87,82.38 135.87,80.23 arc(135.88,80.19) 135.9,80.16 136.06,80 136.4,80 136.77,79.63 v2(137.84,79.63)
DDR4_DDIMM_DQ26: length 45.8
  L03_SIG1 w0.081: v1(158.39,106.96) 157.04,105.61 157.04,101.92 156.25,101.13 156.25,99.58 155.36,98.7 155.36,97.79 153.76,96.18 152.52,96.18 149.9,93.57 149.9,92.49 149.02,91.61 147.48,91.61 144.54,88.67 144.39,88.67 143.81,88.67 143.81,88.67 141.36,88.67 141.36,88.67 137.42,88.67 136.63,87.88 136.63,84.64 135.03,83.04 135.03,82.66 134.95,82.58 134.56,82.58 134.48,82.5 134.48,82.32 134.56,82.24 134.95,82.24 135.03,82.16 135.03,79.91 135.22,79.72 135.53,79.72 136.08,79.17 v2(137.04,79.17)
DDR4_DDIMM_DQ27: length 42.9
  TOP w0.149: v1(158.08,100.36) 157.74,100.36 157.54,100.56 J2.190
  L03_SIG1 w0.081: v2(137.04,81.01) 137.43,81.4 137.43,82.2 137.33,82.3 137.12,82.3 136.89,82.53 136.89,82.85 137.2,83.16 138.72,83.16 139.47,83.91 141.55,83.91 141.56,83.91 142.59,83.91 142.59,83.91 142.67,83.91 143.69,84.94 143.69,86.09 148.13,90.54 152.39,90.54 152.79,90.94 152.79,91.05 151.99,91.86 151.99,91.98 152.11,92.1 152.22,92.1 153.03,91.29 153.15,91.29 153.27,91.41 153.27,91.53 152.46,92.34 152.46,92.45 152.58,92.57 152.7,92.57 153.51,91.76 153.62,91.76 153.74,91.89 153.74,92 152.93,92.81 152.93,92.92 153.06,93.05 153.17,93.05 153.98,92.24 154.09,92.24 156.87,95.01 156.87,96.2 158.08,97.41 v1(158.08,100.36)
DDR4_DDIMM_DQ28: length 43.2
  L03_SIG1 w0.081: v1(166.04,106.96) 166.04,102.45 165.46,101.86 163.24,101.86 162.29,100.91 162.29,99.89 163.07,99.1 163.07,96.93 160.53,94.39 160.53,93.47 154.06,87 151.74,87 151.66,87.08 151.66,87.24 151.58,87.32 151.41,87.32 151.33,87.24 151.33,87.08 151.25,87 148.5,87 146.02,84.52 146.02,83.44 143.6,81.02 142.45,81.02 142.1,80.68 142.1,80.37 v2(141.82,80.09)
DDR4_DDIMM_DQ29: length 45.1
  L03_SIG1 w0.081: v2(141.02,79.63) 141.45,79.2 141.45,79.02 141.67,78.8 141.97,78.8 142.38,79.2 142.81,79.2 143.22,79.61 144.37,79.61 144.45,79.53 144.45,79.05 144.54,78.97 144.71,78.97 144.79,79.05 144.79,79.53 144.87,79.61 145.04,79.61 145.13,79.53 145.13,79.05 145.21,78.97 145.38,78.97 145.46,79.05 145.46,79.53 145.54,79.61 145.97,79.61 146.1,79.74 146.92,79.74 148.21,78.45 154.48,78.45 155.22,79.19 155.22,87.19 162.72,94.69 164.62,94.69 164.74,94.8 164.74,99.99 165.19,100.45 v1(165.19,100.96)
DDR4_DDIMM_DQ30: length 45.2
  TOP w0.149: v1(161.19,103.94) 160.09,105.04 J2.43
  L03_SIG1 w0.081: v1(161.19,103.94) 162.16,103.94 162.24,103.86 162.24,103.58 162.32,103.5 162.78,103.5 162.86,103.42 162.86,103.25 162.78,103.17 162.32,103.17 162.24,103.09 162.24,101.45 161.95,101.16 161.95,99.55 162.24,99.26 162.24,96.63 159.68,94.07 159.68,93.13 arc(159.68,93.1) 159.66,93.08 154.27,87.69 150.78,87.69 150.7,87.6 150.7,87.44 150.61,87.36 150.44,87.36 150.36,87.44 150.36,87.6 150.28,87.69 150.11,87.69 150.03,87.6 150.03,87.44 149.94,87.36 149.77,87.36 149.69,87.44 149.69,87.6 149.61,87.69 149.44,87.69 149.35,87.6 149.35,87.44 149.27,87.36 149.1,87.36 149.02,87.44 149.02,87.6 148.94,87.69 148.42,87.69 145.66,84.93 145.66,83.64 143.71,81.69 141.23,81.69 140.65,81.11 140.65,79.99 140.23,79.57 v2(140.23,79.17)
DDR4_DDIMM_DQ31: length 43.4
  TOP w0.149: v1(162.66,100.37) 159.4,100.37 159.24,100.52 J2.188
  L03_SIG1 w0.081: v2(141.02,80.55) 141.45,80.12 141.45,79.94 141.67,79.72 141.97,79.72 142.43,80.18 142.77,80.18 143.19,80.59 143.91,80.59 146.36,83.04 146.36,84.1 148.75,86.49 152.43,86.49 152.51,86.41 152.51,85.93 152.59,85.85 152.76,85.85 152.85,85.93 152.85,86.41 152.93,86.49 153.1,86.49 153.18,86.41 153.18,85.93 153.26,85.85 153.44,85.85 153.52,85.93 153.52,86.41 153.6,86.49 154.05,86.49 161.39,93.83 161.39,94.47 163.89,96.96 163.89,99.18 163.97,99.26 164.24,99.26 164.32,99.34 164.32,99.51 164.24,99.59 163.97,99.59 163.89,99.68 163.89,100.11 163.63,100.37 v1(162.66,100.37)
DDR4_DDIMM_DQ32: length 68.1
  L14_SIG5 w0.081: v1(109.09,106.96) 108.9,106.77 108.9,105.76 108.82,105.68 108.19,105.68 107.83,106.04 107.83,106.31 107.96,106.44 107.96,107.4 107.84,107.53 106.46,107.53 106.06,107.13 106.06,106.01 105.53,105.48 105.53,102.46 105.27,102.19 105.27,100.94 105.53,100.67 106.9,100.67 107.07,100.84 107.07,101.41 106.97,101.51 106.97,103.34 107.06,103.43 107.64,103.43 107.73,103.35 107.73,100.92 107.97,100.67 109.12,100.67 109.83,101.37 113.11,101.37 113.37,101.64 115.17,101.64 116.72,100.09 119.95,100.09 120.94,99.1 121.89,99.1 122.31,98.68 124.44,98.68 125.16,97.96 125.16,95.24 125.64,94.76 125.64,93.99 129.65,89.98 130.13,89.98 130.22,89.89 130.22,89.72 130.3,89.64 130.74,89.64 130.82,89.56 130.82,89.39 130.74,89.31 130.3,89.31 130.22,89.22 130.22,89.05 130.3,88.97 130.74,88.97 130.82,88.89 130.82,88.72 130.74,88.64 130.3,88.64 130.22,88.55 130.22,88.38 130.3,88.3 130.74,88.3 130.82,88.22 130.82,88.05 130.74,87.97 130.3,87.97 130.22,87.88 130.22,87.71 130.3,87.63 130.74,87.63 130.82,87.55 130.82,87.38 130.74,87.29 130.3,87.29 130.22,87.21 130.22,87.04 130.3,86.96 130.74,86.96 130.82,86.88 130.82,86.71 130.74,86.62 130.3,86.62 130.22,86.54 130.22,84.98 130.76,84.44 131.4,83.8 131.4,82.36 130.76,81.72 130.76,80.71 130.26,80.21 130.26,79.97 130.67,79.57 v1(130.67,78.25)
DDR4_DDIMM_DQ33: length 67
  L14_SIG5 w0.081: v1(130.67,77.33) 130.98,77.33 131.09,77.44 131.09,77.94 131.2,78.06 131.2,78.4 131,78.6 131,79.17 131.1,79.27 131.1,81.58 131.73,82.22 131.73,84.14 131.18,84.7 131.18,85.08 131.18,89.62 131.16,89.64 131.16,89.72 130,90.88 129.88,90.88 129.65,90.65 129.53,90.65 129.41,90.77 129.41,90.88 129.64,91.12 129.64,91.23 129.52,91.35 129.41,91.35 129.17,91.12 129.06,91.12 128.94,91.24 128.94,91.36 129.17,91.59 129.17,91.7 129.05,91.83 128.93,91.83 128.7,91.59 128.59,91.59 128.46,91.72 128.46,91.83 128.7,92.06 128.7,92.18 128.57,92.3 128.46,92.3 128.23,92.07 128.11,92.07 127.99,92.19 127.99,92.31 128.22,92.54 128.22,92.65 128.1,92.77 127.98,92.77 127.75,92.54 127.64,92.54 127.52,92.66 127.52,92.78 127.75,93.01 127.75,93.13 127.63,93.25 127.51,93.25 127.28,93.02 127.16,93.02 127.04,93.14 127.04,93.25 127.27,93.49 127.27,93.6 127.15,93.72 127.04,93.72 126.8,93.49 126.69,93.49 126.57,93.61 126.57,93.73 126.8,93.96 126.8,94.08 126.68,94.2 126.56,94.2 126.33,93.96 126.21,93.96 126.09,94.09 126.09,94.2 126.33,94.43 126.33,94.55 125.49,95.38 125.49,98.09 124.76,98.83 124.76,99.4 124.63,99.53 124.2,99.53 124.12,99.45 124.12,99.09 124.04,99.01 123.86,99.01 123.78,99.09 123.78,99.45 123.7,99.53 123.53,99.53 123.45,99.45 123.45,99.09 123.37,99.01 123.19,99.01 123.11,99.09 123.11,99.45 123.03,99.53 120.98,99.53 120.56,99.95 120.56,100.21 120.64,100.29 121.54,100.29 121.62,100.37 121.62,100.54 121.54,100.62 120.64,100.62 120.56,100.7 120.56,100.88 120.64,100.96 121.54,100.96 121.62,101.04 121.62,101.21 121.54,101.29 120.64,101.29 120.56,101.38 120.56,101.59 120.64,101.68 121.36,101.68 121.44,101.76 121.44,101.93 121.36,102.01 119.91,102.01 119.83,101.93 119.83,101.66 119.75,101.57 119.25,101.57 119.17,101.49 119.17,101.25 119.25,101.17 119.66,101.17 119.74,101.09 119.74,100.91 119.66,100.83 119.25,100.83 119.17,100.75 119.17,100.51 119.09,100.42 118.92,100.42 118.84,100.51 118.84,101.49 118.7,101.63 117.62,101.63 117.48,101.49 117.48,101.29 117.56,101.2 117.94,101.2 118.02,101.12 118.02,100.95 117.94,100.87 117.56,100.87 117.48,100.79 117.48,100.55 117.4,100.47 117.23,100.47 117.15,100.55 117.15,101.49 117.07,101.57 115.71,101.57 115.31,101.97 114.52,101.97 114.44,102.05 114.44,102.17 114.36,102.25 114.18,102.25 114.1,102.17 114.1,102.05 114.02,101.97 113.85,101.97 113.77,102.05 113.77,102.17 113.69,102.25 113.51,102.25 113.43,102.17 113.43,102.05 113.35,101.97 113.18,101.97 113.1,102.05 113.1,102.17 113.02,102.25 112.84,102.25 112.76,102.17 112.76,102.05 112.68,101.97 112.32,101.97 112.06,101.71 109.57,101.71 109.26,101.39 108.75,101.39 108.6,101.54 108.6,101.8 108.52,101.88 108.32,101.88 108.24,101.8 v1(108.24,101.06)
DDR4_DDIMM_DQ34: length 67.1
  L14_SIG5 w0.081: v1(103.14,106.96) 103.5,106.6 103.5,106.49 103.42,106.41 102.79,106.41 102.7,106.33 102.7,106.16 102.79,106.08 103.42,106.08 103.5,105.99 103.5,105.82 103.42,105.74 102.79,105.74 102.7,105.66 102.7,105.49 102.79,105.41 103.42,105.41 103.5,105.32 103.5,105.15 103.42,105.07 102.79,105.07 102.7,104.99 102.7,104.82 102.79,104.73 103.42,104.73 103.5,104.65 103.5,104.48 103.42,104.4 102.79,104.4 102.7,104.32 102.7,104.15 102.79,104.06 103.42,104.06 103.5,103.98 103.5,103.81 103.42,103.73 102.79,103.73 102.7,103.65 102.7,103.47 102.79,103.39 103.42,103.39 103.5,103.31 103.5,103.14 103.42,103.06 102.79,103.06 102.7,102.98 102.7,102.8 102.79,102.72 103.42,102.72 103.5,102.64 103.5,100.64 103.36,100.49 103.36,100.18 103.58,99.97 103.88,99.97 103.9,99.98 109.43,99.98 110.04,100.59 112.8,100.59 113.51,101.3 115.03,101.3 116.59,99.74 119.08,99.74 120.13,98.69 121.83,98.69 122.32,98.19 123.05,98.19 123.4,97.84 124.54,97.84 124.82,97.56 124.82,96.72 124.74,96.64 124.44,96.64 124.36,96.56 124.36,96.39 124.44,96.31 124.74,96.31 124.82,96.23 124.82,96.05 124.74,95.97 124.44,95.97 124.36,95.89 124.36,95.72 124.44,95.64 124.74,95.64 124.82,95.56 124.82,94.3 129.89,89.24 129.89,89.04 129.81,88.96 129.71,88.96 129.63,88.88 129.63,88.71 129.71,88.62 129.81,88.62 129.89,88.54 129.89,88.37 129.81,88.29 129.71,88.29 129.63,88.21 129.63,88.04 129.71,87.95 129.81,87.95 129.89,87.87 129.89,84.84 130.43,84.3 130.43,83.91 131.06,83.28 131.06,82.72 130.93,82.59 130.45,82.59 129.92,82.06 129.92,81.91 130,81.83 130.32,81.83 130.41,81.75 130.41,81.58 130.32,81.5 130,81.5 129.92,81.42 129.92,81.24 130,81.16 130.32,81.16 130.41,81.08 130.41,80.91 130.32,80.83 130,80.83 129.92,80.75 129.92,79.83 130.26,79.5 130.26,77.26 v1(129.87,76.87)
DDR4_DDIMM_DQ35: length 68
  L14_SIG5 w0.081: v1(129.87,78.71) 129.87,79.41 129.59,79.69 129.59,80.83 129.51,80.91 129.11,80.91 129.02,81 129.02,81.17 129.11,81.25 129.51,81.25 129.59,81.33 129.59,82.2 130.25,82.87 130.25,83.3 129.51,84.04 129.51,87.22 128.69,88.04 128.69,89.93 128.31,90.31 128.19,90.31 128.12,90.24 128.01,90.24 127.89,90.36 127.89,90.48 127.96,90.55 127.96,90.66 127.83,90.79 127.72,90.79 127.65,90.72 127.54,90.72 127.41,90.84 127.41,90.95 127.48,91.02 127.48,91.14 127.36,91.26 127.25,91.26 127.18,91.19 127.06,91.19 126.94,91.31 126.94,91.43 127.01,91.5 127.01,91.61 126.89,91.73 126.77,91.73 126.7,91.66 126.59,91.66 126.46,91.79 126.46,91.9 126.53,91.97 126.53,92.09 126.41,92.21 126.3,92.21 126.23,92.14 126.11,92.14 125.99,92.26 125.99,92.38 126.06,92.45 126.06,92.56 125.94,92.68 125.82,92.68 125.75,92.61 125.64,92.61 125.52,92.74 125.52,92.85 125.59,92.92 125.59,93.03 125.46,93.16 125.35,93.16 125.28,93.09 125.16,93.09 125.04,93.21 125.04,93.32 125.11,93.39 125.11,93.51 124.99,93.63 124.87,93.63 124.81,93.56 124.69,93.56 124.57,93.68 124.57,93.8 124.64,93.87 124.64,93.98 124.32,94.3 123.94,94.3 123.69,94.54 123.69,95.72 123.61,95.8 122.61,95.8 122.53,95.88 122.53,96.06 122.61,96.14 123.61,96.14 123.69,96.22 123.69,96.39 123.61,96.47 122.61,96.47 122.53,96.55 122.53,96.73 122.61,96.81 123.61,96.81 123.69,96.89 123.69,97.07 123.05,97.72 122.12,97.72 122.04,97.64 122.04,96.33 121.96,96.25 121.78,96.25 121.7,96.33 121.7,97.64 121.62,97.72 121.45,97.72 121.37,97.64 121.37,96.33 121.29,96.25 121.11,96.25 121.03,96.33 121.03,96.94 120.95,97.02 120.39,97.02 120.31,97.1 120.31,97.27 120.39,97.35 120.95,97.35 121.03,97.44 121.03,97.64 120.95,97.72 120.21,97.72 120.13,97.8 120.13,98.25 120.05,98.33 119.88,98.33 119.8,98.25 119.8,97.8 119.72,97.72 119.28,97.72 118.56,98.43 118.56,98.7 117.91,99.35 116.5,99.35 115.41,100.45 115.12,100.45 115.03,100.37 115.03,99.46 114.95,99.38 114.78,99.38 114.7,99.46 114.7,100.37 114.56,100.51 113.95,100.51 113.87,100.43 113.87,99.72 113.69,99.54 113.34,99.54 113.12,99.76 112.71,99.76 112.63,99.84 112.63,100.13 112.55,100.21 112.38,100.21 112.3,100.13 112.3,99.84 112.21,99.76 112.04,99.76 111.96,99.84 111.96,100.13 111.88,100.21 111.71,100.21 111.63,100.13 111.63,99.84 111.54,99.76 111.37,99.76 111.29,99.84 111.29,100.13 111.21,100.21 111.04,100.21 110.95,100.13 110.95,99.84 110.87,99.76 110.7,99.76 110.62,99.84 110.62,100.13 110.54,100.21 110.37,100.21 110.28,100.13 110.28,99.84 110.2,99.76 109.8,99.76 109.68,99.64 108.12,99.64 107.99,99.52 107.78,99.52 107.66,99.64 107.45,99.64 107.32,99.52 107.11,99.52 106.99,99.64 106.77,99.64 106.65,99.52 106.44,99.52 106.32,99.64 106.1,99.64 105.98,99.52 105.77,99.52 105.64,99.64 105.43,99.64 105.31,99.52 105.1,99.52 104.97,99.64 104.76,99.64 104.64,99.52 104.43,99.52 104.3,99.64 104.09,99.64 103.97,99.52 103.49,99.52 103.3,99.72 102.4,99.72 102.29,99.83 v1(102.29,100.96)
DDR4_DDIMM_DQ36: length 65.9
  L14_SIG5 w0.081: v1(133.05,76.87) 133.45,77.56 arc(133.52,77.79) 133.45,78.02 arc(133.39,78.25) 133.45,78.48 arc(133.62,78.64) 133.84,78.71 133.85,78.71 arc(134.08,78.77) 134.24,78.93 134.25,78.94 arc(134.31,79.17) 134.25,79.4 134.25,79.4 arc(134.19,79.63) 134.25,79.86 arc(134.31,80.09) 134.25,80.31 134.24,80.34 arc(134.19,80.56) 134.25,80.78 arc(134.31,81) 134.26,81.22 134.26,89.77 130.68,93.35 130.68,98.34 130.21,98.81 129.62,98.81 126.61,101.82 126.6,101.82 125.72,102.71 125.72,104.1 125.63,104.18 124.28,104.18 124.2,104.26 124.2,104.44 124.28,104.52 125.63,104.52 125.71,104.6 125.71,104.77 125.63,104.85 124.28,104.85 124.2,104.94 124.2,105.11 124.28,105.19 125.63,105.19 125.71,105.27 125.71,105.44 125.63,105.52 124.28,105.52 124.2,105.61 124.2,105.78 124.28,105.86 125.63,105.86 125.71,105.94 125.71,106.11 125.63,106.2 124.28,106.2 124.2,106.28 124.2,106.45 124.28,106.53 125.63,106.53 125.71,106.61 125.71,107.66 125.52,107.86 123.57,107.86 123.49,107.78 123.49,106.75 123.41,106.67 123.23,106.67 123.15,106.75 123.15,107.78 123.07,107.86 122.65,107.86 122.56,107.78 122.56,107.44 122.48,107.36 122.31,107.36 122.23,107.44 122.23,107.78 122.15,107.86 121.98,107.86 121.89,107.78 121.89,107.44 121.81,107.36 121.64,107.36 121.56,107.44 121.56,107.78 121.48,107.86 111.77,107.86 v1(110.87,106.96)
DDR4_DDIMM_DQ37: length 65.3
  L14_SIG5 w0.081: v1(133.05,78.71) 133.45,79.4 133.46,79.4 arc(133.52,79.63) 133.45,79.86 arc(133.39,80.09) 133.45,80.31 133.45,80.32 arc(133.52,80.54) 133.46,80.76 133.42,80.81 133.42,81.1 133.92,81.61 133.92,89.63 129.99,93.56 129.99,97.93 120.49,107.43 112.31,107.43 112.17,107.29 112.17,106.71 112.03,106.58 109.68,106.58 109.51,106.75 109.51,107.2 108.85,107.86 106.32,107.86 105.2,106.74 105.2,106.21 105.11,106.13 104.82,106.13 104.74,106.05 104.74,105.88 104.82,105.79 105.11,105.79 105.2,105.71 105.2,105.54 105.11,105.46 104.82,105.46 104.74,105.38 104.74,105.2 104.82,105.12 105.11,105.12 105.2,105.04 105.2,102.6 104.71,102.11 104.71,102.11 104.51,101.92 104.51,101.64 104.87,101.28 104.87,100.85 105.39,100.34 109.31,100.34 v1(109.94,100.96)
DDR4_DDIMM_DQ38: length 65.2
  L14_SIG5 w0.081: v1(104.84,106.96) 106.08,108.2 109.72,108.2 109.8,108.12 109.8,107.47 109.88,107.38 110.05,107.38 110.13,107.47 110.13,108.12 110.21,108.2 110.39,108.2 110.47,108.12 110.47,107.47 110.55,107.38 110.72,107.38 110.8,107.47 110.8,108.12 110.88,108.2 125.77,108.2 129.5,104.47 129.5,103.48 129.42,103.4 129.02,103.4 128.93,103.32 128.93,103.15 129.02,103.07 129.42,103.07 129.5,102.99 129.5,102.81 129.42,102.73 129.02,102.73 128.93,102.65 128.93,102.48 129.02,102.4 129.42,102.4 129.5,102.32 129.5,102.14 129.42,102.06 129.02,102.06 128.93,101.98 128.93,101.81 129.02,101.73 129.42,101.73 129.5,101.65 129.5,101.47 129.42,101.39 129.02,101.39 128.93,101.31 128.93,101.14 129.02,101.06 129.42,101.06 129.5,100.97 129.5,100.8 129.42,100.72 129.02,100.72 128.93,100.64 128.93,100.47 129.02,100.39 129.42,100.39 129.5,100.3 129.5,99.93 129.71,99.73 131.38,99.73 131.68,99.43 131.68,93.3 135.44,89.54 135.44,86.51 135.22,86.29 135.22,81.54 135.04,81.23 arc(134.99,81) 135.05,80.78 135.06,80.77 arc(135.11,80.54) 135.05,80.32 135.04,80.31 arc(134.99,80.09) 135.05,79.86 arc(135.11,79.63) 135.05,79.4 135.04,79.4 arc(134.99,79.17) 135.05,78.94 arc(135.11,78.71) 135.05,78.48 135.05,78.48 arc(134.89,78.31) 134.66,78.25 v1(133.85,78.25)
DDR4_DDIMM_DQ39: length 66.2
  L14_SIG5 w0.081: v1(133.85,77.33) 134.09,77.33 134.66,77.33 arc(134.88,77.39) 135.05,77.56 arc(135.22,77.73) 135.45,77.79 arc(135.67,77.85) 135.84,78.01 135.84,78.02 arc(135.91,78.25) 135.84,78.48 135.84,78.48 arc(135.78,78.71) 135.84,78.94 arc(135.91,79.17) 135.85,79.4 135.84,79.4 arc(135.78,79.63) 135.84,79.86 arc(135.91,80.09) 135.85,80.31 135.84,80.32 arc(135.78,80.55) 135.84,80.78 arc(135.89,80.89) 135.91,81.01 135.91,81.43 135.56,81.78 135.56,86.15 135.78,86.37 135.78,89.69 132.5,92.96 132.5,99.09 131.15,100.43 130.35,100.43 129.86,100.92 129.86,104.61 125.93,108.53 105.72,108.53 104.34,107.15 104.34,102.38 103.99,102.03 v1(103.99,100.96)
DDR4_DDIMM_DQ40: length 67
  L14_SIG5 w0.081: v1(99.74,106.96) 96.6,106.96 94.77,105.14 94.77,104.79 94.24,104.25 94.24,100.32 94.54,100.02 94.66,100.02 94.83,100.19 94.95,100.19 95.07,100.07 95.07,99.96 94.9,99.78 94.9,99.67 95.12,99.44 95.12,98.8 95.2,98.72 96.21,98.72 96.3,98.64 96.3,98.46 96.21,98.38 95.2,98.38 95.12,98.3 95.12,98.13 95.2,98.05 96.21,98.05 96.3,97.97 96.3,97.79 96.21,97.71 95.2,97.71 95.12,97.63 95.12,97.46 95.2,97.38 96.21,97.38 96.3,97.3 96.3,97.12 96.21,97.04 95.57,97.04 95.49,96.96 95.49,95.99 95.96,95.52 96.07,95.52 96.35,95.8 96.46,95.8 96.58,95.67 96.58,95.56 96.31,95.29 96.31,95.17 96.43,95.05 96.55,95.05 96.82,95.32 96.93,95.32 97.06,95.2 97.06,95.09 96.78,94.81 96.78,94.7 96.91,94.58 97.02,94.58 97.29,94.85 97.41,94.85 97.53,94.73 97.53,94.61 97.26,94.34 97.26,94.22 97.78,93.7 97.78,91.93 99.01,90.69 110.07,90.69 110.07,90.69 110.48,90.69 110.48,90.69 114.56,90.69 117.42,87.84 121.87,87.84 123.11,86.59 123.11,83.61 124.17,82.55 124.17,82.31 125.21,81.27 125.21,80.95 125.48,80.68 125.48,80.31 arc(125.42,80.09) 125.49,79.86 arc(125.55,79.63) 125.49,79.4 125.48,79.4 arc(125.42,79.17) 125.49,78.94 125.83,78.35 v1(125.88,78.25)
DDR4_DDIMM_DQ41: length 70.3
  L14_SIG5 w0.081: v1(98.89,100.96) 99.45,101.52 99.45,105.72 100.19,106.46 100.19,107.11 99.89,107.41 96.47,107.41 95.65,106.59 95.15,106.59 94.4,107.33 93.55,107.33 93.25,107.03 93.25,106.46 93.34,106.36 93.34,105.29 93.12,105.08 93.12,101.45 93.34,101.24 93.34,98.2 92.58,97.44 92.58,96.99 93.63,95.94 93.63,95.35 95.35,93.64 95.35,93.17 98.5,90.02 110.07,90.02 110.07,90.02 110.48,90.02 110.48,90.02 113.79,90.02 117.09,86.72 121.23,86.72 122.27,85.68 122.27,83.18 123.01,82.45 123.01,82.21 arc(123.03,82.08) 123.11,81.97 123.85,81.24 arc(123.87,81.2) 123.88,81.16 123.88,80.8 arc(123.87,80.48) 123.83,80.15 arc(123.84,80) 123.89,79.86 arc(123.95,79.63) 123.89,79.4 123.89,79.4 arc(123.83,79.17) 123.89,78.94 arc(124.05,78.78) 124.27,78.71 124.29,78.71 arc(124.48,78.67) 124.64,78.55 arc(124.66,78.53) 124.68,78.5 124.7,78.46 arc(124.87,78.31) 125.09,78.25 125.11,78.25 arc(125.33,78.18) 125.49,78.02 v1(125.88,77.33)
DDR4_DDIMM_DQ42: length 66.8
  L14_SIG5 w0.081: v1(93.79,106.96) 93.79,105.89 93.98,105.7 93.98,104.71 93.46,104.19 93.46,101.59 93.85,101.2 93.85,99.81 94.16,99.5 94.16,98.81 94.08,98.73 93.77,98.73 93.68,98.65 93.68,98.47 93.77,98.39 94.08,98.39 94.16,98.31 94.16,98.14 94.08,98.06 93.77,98.06 93.68,97.98 93.68,97.8 93.77,97.72 94.08,97.72 94.16,97.64 94.16,97.49 94.25,97.41 94.54,97.41 94.62,97.33 94.62,97.15 94.54,97.07 94.25,97.07 94.16,96.99 94.16,96.5 94.63,96.03 94.63,95.86 94.81,95.68 94.81,95.57 94.43,95.19 94.43,95.07 94.55,94.95 94.67,94.95 95.05,95.33 95.16,95.33 95.28,95.21 95.28,95.09 94.9,94.72 94.9,94.6 95.03,94.48 95.14,94.48 95.52,94.86 95.63,94.86 96.13,94.36 96.13,94.25 95.69,93.81 95.69,93.7 95.81,93.57 95.93,93.57 96.36,94.01 96.48,94.01 96.82,93.67 96.82,92.38 98.85,90.36 110.07,90.36 110.07,90.36 110.48,90.36 110.48,90.36 113.93,90.36 114.11,90.17 114.23,90.17 114.35,90.3 114.47,90.3 114.59,90.18 114.59,90.06 114.47,89.94 114.47,89.82 114.59,89.7 114.7,89.7 114.83,89.82 114.94,89.82 115.06,89.7 115.06,89.59 114.94,89.46 114.94,89.35 115.06,89.23 115.18,89.23 115.3,89.35 115.42,89.35 115.54,89.23 115.54,89.11 115.41,88.99 115.41,88.87 115.54,88.75 115.65,88.75 115.77,88.87 115.89,88.87 116.01,88.75 116.01,88.64 115.89,88.51 115.89,88.4 116.01,88.28 116.13,88.28 116.25,88.4 116.36,88.4 116.49,88.28 116.49,88.16 116.36,88.04 116.36,87.93 116.8,87.49 117.38,87.49 117.47,87.41 117.47,87.17 117.55,87.09 117.72,87.09 117.8,87.17 117.8,87.41 117.88,87.49 118.06,87.49 118.14,87.41 118.14,87.17 118.22,87.09 118.39,87.09 118.47,87.17 118.47,87.41 118.55,87.49 118.73,87.49 118.81,87.41 118.81,87.17 118.89,87.09 119.06,87.09 119.14,87.17 119.14,87.41 119.22,87.49 119.4,87.49 119.48,87.41 119.48,87.17 119.56,87.09 119.73,87.09 119.81,87.17 119.81,87.41 119.89,87.49 120.07,87.49 120.15,87.41 120.15,87.17 120.23,87.09 120.4,87.09 120.48,87.17 120.48,87.41 120.56,87.49 120.74,87.49 120.82,87.41 120.82,87.17 120.9,87.09 121.07,87.09 121.15,87.17 121.15,87.41 121.24,87.49 121.62,87.49 121.7,87.42 121.7,87.31 121.52,87.13 121.52,87.02 121.64,86.9 121.76,86.9 121.93,87.07 122.05,87.07 122.17,86.95 122.17,86.83 122,86.66 122,86.54 122.12,86.42 122.23,86.42 122.41,86.6 122.52,86.6 122.67,86.45 122.67,83.58 123.84,82.41 123.84,82.05 124.79,81.1 124.81,80.97 124.78,80.91 arc(124.73,80.85) 124.69,80.78 arc(124.63,80.56) 124.67,80.35 124.69,80.31 arc(124.75,80.09) 124.69,79.86 arc(124.63,79.63) 124.69,79.4 124.69,79.4 v1(125.09,78.71)
DDR4_DDIMM_DQ43: length 69.5
  L14_SIG5 w0.081: v1(92.94,100.96) 92.62,101.29 92.62,104.07 92.42,104.26 91.96,104.26 91.69,103.99 91.69,103.69 91.61,103.61 91.26,103.61 91.18,103.53 91.18,103.35 91.26,103.27 91.61,103.27 91.69,103.19 91.69,103.02 91.61,102.94 91.26,102.94 91.18,102.86 91.18,102.68 91.26,102.6 91.61,102.6 91.69,102.52 91.69,102.35 91.61,102.27 91.26,102.27 91.18,102.19 91.18,102.01 91.26,101.93 91.61,101.93 91.69,101.85 91.69,100.55 91.77,100.47 92.92,100.47 93,100.39 93,100.22 92.92,100.14 92.52,100.14 92.44,100.06 92.44,99.81 92.36,99.73 92.19,99.73 92.1,99.81 92.1,100.06 92.02,100.14 91.77,100.14 91.69,100.06 91.69,98.88 91.77,98.79 92.89,98.79 92.98,98.71 92.98,98.54 92.89,98.46 92.57,98.46 92.49,98.38 92.49,97.94 92.41,97.86 92.24,97.86 92.16,97.94 92.16,98.38 92.08,98.46 91.77,98.46 91.69,98.38 91.69,97.69 92.13,97.25 92.13,96.25 92.21,96.17 92.57,96.17 92.65,96.09 92.65,95.92 92.57,95.83 92.21,95.83 92.13,95.75 92.13,95.58 92.21,95.5 92.57,95.5 92.65,95.42 92.65,95.24 92.57,95.16 92.21,95.16 92.13,95.08 92.13,94.58 92.31,94.4 94.11,94.4 95.01,93.5 95.01,92.71 98.04,89.69 99.64,89.69 99.64,89.68 110.07,89.68 110.07,89.68 110.47,89.68 110.48,89.68 113.42,89.68 116,87.1 116,84.98 116.26,84.71 121.45,84.71 121.91,84.25 121.91,82.42 123.1,81.23 arc(123.16,81) 123.09,80.78 arc(123.03,80.57) 123.08,80.35 123.1,80.31 arc(123.16,80.09) 123.1,79.86 arc(123.03,79.63) 123.09,79.4 123.1,79.4 arc(123.16,79.17) 123.1,78.94 arc(123.03,78.71) 123.1,78.48 123.11,78.46 arc(123.27,78.31) 123.49,78.25 123.52,78.25 arc(123.73,78.18) 123.89,78.02 arc(124.05,77.86) 124.27,77.79 124.29,77.79 arc(124.51,77.73) 124.68,77.58 124.69,77.56 v1(125.09,76.87)
DDR4_DDIMM_DQ44: length 67.5
  L14_SIG5 w0.081: v1(101.44,106.96) 101.44,105.76 102.17,105.03 102.17,104.69 101.83,104.35 101.83,103.89 101.75,103.8 99.91,103.8 99.83,103.72 99.83,103.55 99.91,103.47 101.75,103.47 101.83,103.39 101.83,103.22 101.75,103.13 99.91,103.13 99.83,103.05 99.83,102.88 99.91,102.8 101.75,102.8 101.83,102.72 101.83,102.55 101.75,102.46 99.91,102.46 99.83,102.38 99.83,102.21 99.91,102.13 101.75,102.13 101.83,102.05 101.83,101.87 101.75,101.79 99.91,101.79 99.83,101.71 99.83,101.54 99.91,101.46 101.75,101.46 101.83,101.38 101.83,99.23 102.09,98.97 106.08,98.97 106.42,98.63 107.53,98.63 107.54,98.63 107.63,98.63 108.04,99.04 108.8,99.04 108.94,98.89 117.71,98.89 118.1,98.51 118.1,98.24 119.09,97.25 119.35,97.25 121.45,95.16 122.43,95.16 128.23,89.35 128.23,87.85 129.05,87.03 129.05,84.05 128.89,83.89 128.89,82.49 128.68,82.28 128.68,79.91 129.41,79.19 129.41,78.64 129.57,78.47 129.57,78.13 129.07,77.63 v1(129.07,77.33)
DDR4_DDIMM_DQ45: length 66.2
  L14_SIG5 w0.081: v1(129.07,78.25) 129.07,78.49 129.07,78.49 129.07,79.05 128.35,79.77 128.35,82.42 128.56,82.63 128.56,84.03 128.72,84.19 128.72,86.89 127.9,87.71 127.9,89.21 124.17,92.94 120.66,92.94 120.52,93.08 120.52,93.72 120.6,93.8 121.38,93.8 121.46,93.88 121.46,94.05 121.38,94.13 120.6,94.13 120.52,94.21 120.52,94.39 120.6,94.47 121.38,94.47 121.46,94.55 121.46,94.72 121.38,94.8 120.6,94.8 120.52,94.88 120.52,95.34 118.19,97.67 117.71,97.67 117.63,97.59 117.63,96.3 117.54,96.22 117.37,96.22 117.29,96.3 117.29,97.59 117.21,97.67 117.04,97.67 116.95,97.59 116.95,96.3 116.87,96.22 116.7,96.22 116.62,96.3 116.62,97.59 116.54,97.67 116.37,97.67 116.28,97.59 116.28,96.3 116.2,96.22 116.03,96.22 115.95,96.3 115.95,97.59 115.87,97.67 115.7,97.67 115.61,97.59 115.61,96.3 115.53,96.22 115.36,96.22 115.28,96.3 115.28,97.59 115.2,97.67 115.02,97.67 114.94,97.59 114.94,96.3 114.86,96.22 114.69,96.22 114.61,96.3 114.61,97.59 114.53,97.67 114.35,97.67 114.27,97.59 114.27,96.3 114.19,96.22 114.02,96.22 113.94,96.3 113.94,97.59 113.86,97.67 112.95,97.67 112.72,97.9 105.7,97.9 105.23,98.36 101.22,98.36 101.03,98.55 101.03,99.52 100.5,100.04 100.5,100.87 v1(100.59,100.96)
DDR4_DDIMM_DQ46: length 67.1
  L14_SIG5 w0.081: v1(95.49,106.96) 94.79,107.67 92.46,107.67 91.58,106.78 91.58,105.98 90.8,105.2 90.8,96.31 91.22,95.89 91.22,94.13 91.49,93.85 93.67,93.85 94.1,93.42 94.1,93 97.76,89.35 99.5,89.35 99.5,89.35 110.07,89.35 110.47,89.35 110.47,89.35 113.1,89.35 115.63,86.82 115.63,84.45 115.84,84.24 120.95,84.24 121.24,83.95 121.24,81.94 122.2,80.98 arc(122.25,80.86) 122.31,80.75 arc(122.36,80.53) 122.3,80.32 122.3,80.31 arc(122.24,80.09) 122.3,79.86 arc(122.36,79.63) 122.3,79.4 122.3,79.4 arc(122.24,79.17) 122.3,78.94 arc(122.36,78.71) 122.3,78.48 122.3,78.48 arc(122.24,78.25) 122.3,78.02 arc(122.46,77.86) 122.68,77.79 122.7,77.79 arc(122.92,77.73) 123.08,77.58 123.11,77.54 arc(123.27,77.39) 123.49,77.33 123.52,77.33 arc(123.73,77.26) 123.89,77.1 arc(124.05,76.94) 124.27,76.87 124.3,76.87 arc(124.52,76.81) 124.69,76.64 arc(124.85,76.47) 125.08,76.41 125.09,76.41 arc(125.31,76.47) 125.48,76.63 125.49,76.64 arc(125.65,76.81) 125.88,76.87 125.89,76.87 arc(126.12,76.81) 126.28,76.64 arc(126.45,76.47) 126.68,76.41 126.68,76.41 arc(126.91,76.47) 127.07,76.63 127.08,76.65 arc(127.25,76.81) 127.48,76.87 v1(128.27,76.87)
DDR4_DDIMM_DQ47: length 66.2
  L14_SIG5 w0.081: v1(128.27,78.71) 128.27,79.2 127.98,79.49 arc(127.94,79.57) 127.92,79.65 127.92,85 127.84,85.08 127.69,85.08 127.61,85.16 127.61,85.34 127.69,85.42 127.84,85.42 127.92,85.5 127.92,85.67 127.84,85.75 127.69,85.75 127.61,85.84 127.61,86.01 127.69,86.09 127.84,86.09 127.92,86.17 127.92,86.34 127.84,86.42 127.69,86.42 127.61,86.51 127.61,86.68 127.69,86.76 127.84,86.76 127.92,86.84 127.92,87.17 arc(127.91,87.21) 127.89,87.25 127.56,87.57 127.56,89.07 124.15,92.49 120.46,92.49 119.71,93.24 119.71,94.66 119.38,94.99 119.07,94.99 118.31,95.75 117.26,95.75 116.98,95.47 114.28,95.47 112.8,96.95 111.11,96.95 110.69,97.37 105.2,97.37 104.97,97.6 103.24,97.6 102.75,97.11 102.75,95.73 102.5,95.48 100.43,95.48 100.14,95.77 100.14,99.51 99.91,99.74 99.25,99.74 98.52,100.47 98.52,101.31 98.98,101.77 98.98,105.5 98.2,106.28 96.92,106.28 94.64,104 94.64,102.34 94.72,102.26 95.09,102.26 95.17,102.18 95.17,102.01 95.09,101.93 94.72,101.93 94.64,101.85 v1(94.64,100.96)
DDR4_DDIMM_DQ48: length 83.3
  L16_SIG6 w0.081: v1(129.87,75.95) 130.27,75.26 arc(130.33,75.03) 130.27,74.8 130.26,74.79 arc(130.2,74.56) 130.27,74.34 arc(130.43,74.17) 130.66,74.11 130.67,74.11 arc(130.9,74.17) 131.06,74.34 arc(131.23,74.51) 131.46,74.57 131.46,74.57 arc(131.69,74.63) 131.86,74.8 131.86,74.81 arc(132.03,74.97) 132.26,75.03 132.26,75.03 arc(132.49,75.09) 132.66,75.26 arc(132.82,75.43) 133.05,75.49 133.28,75.49 133.53,75.74 133.53,76.2 134.2,76.86 134.25,77.1 arc(134.31,77.33) 134.25,77.56 134.25,77.56 arc(134.19,77.79) 134.25,78.02 arc(134.31,78.25) 134.25,78.48 134.25,78.48 arc(134.19,78.71) 134.25,78.94 arc(134.31,79.17) 134.25,79.4 134.25,79.4 arc(134.19,79.63) 134.25,79.86 arc(134.31,80.09) 134.25,80.31 134.24,80.34 arc(134.19,80.56) 134.25,80.78 arc(134.31,81) 134.26,81.23 134.25,81.24 133.81,81.67 133.81,83.83 134.27,84.28 134.27,87.57 129.28,92.56 125.44,92.56 123.13,94.86 123.13,95.51 120.41,98.23 120.3,98.23 120.15,98.09 120.04,98.09 119.92,98.21 119.92,98.33 120.06,98.47 120.06,98.59 119.75,98.9 118.98,98.9 118.9,98.81 118.9,98.5 118.82,98.42 118.65,98.42 118.57,98.5 118.57,98.81 118.49,98.9 118.31,98.9 118.23,98.81 118.23,98.5 118.15,98.42 117.98,98.42 117.9,98.5 117.9,98.81 117.82,98.9 115.95,98.9 115.87,98.81 115.87,98.48 115.79,98.4 115.62,98.4 115.54,98.48 115.54,98.81 115.45,98.9 114.65,98.9 114.57,98.81 114.57,97.92 114.49,97.84 114.32,97.84 114.24,97.92 114.24,98.81 114.16,98.9 113.87,98.9 112.71,100.05 112.71,100.16 113.04,100.49 113.04,100.61 112.92,100.73 112.81,100.73 112.48,100.4 112.36,100.4 112.01,100.75 112.01,101.12 111.8,101.34 110.93,101.34 110.91,101.35 110.75,101.35 110.42,101.67 110.42,101.79 110.71,102.07 110.71,102.19 110.59,102.31 110.47,102.31 110.19,102.03 110.07,102.03 109.95,102.15 109.95,102.26 110.23,102.55 110.23,102.66 110.11,102.78 110,102.78 109.71,102.5 109.6,102.5 109.48,102.62 109.48,102.74 109.76,103.02 109.76,103.14 109.64,103.26 109.52,103.26 109.24,102.97 109.12,102.97 108.96,103.14 108.85,103.14 108.56,102.85 108.45,102.85 108.32,102.97 108.32,103.09 108.61,103.37 108.61,103.49 108.49,103.61 108.37,103.61 108.09,103.32 107.97,103.32 107.85,103.45 107.85,103.56 108.14,103.85 108.14,103.96 108.01,104.08 107.9,104.08 107.61,103.8 107.5,103.8 107.38,103.92 107.38,104.04 107.66,104.32 107.66,104.44 107.43,104.67 103.46,104.67 102.86,104.06 95.39,104.06 95.02,104.43 90.99,104.43 90.77,104.65 90.77,105.89 v1(90.39,106.26)
DDR4_DDIMM_DQ49: length 84.9
  L16_SIG6 w0.081: v1(129.07,74.57) 129.47,75.26 arc(129.53,75.48) 129.47,75.71 129.47,75.72 arc(129.41,75.95) 129.47,76.18 129.47,76.18 arc(129.64,76.35) 129.87,76.41 arc(130.09,76.47) 130.26,76.63 130.28,76.66 arc(130.33,76.88) 130.27,77.1 arc(130.2,77.33) 130.26,77.56 130.27,77.56 arc(130.33,77.79) 130.27,78.02 arc(130.2,78.25) 130.27,78.48 arc(130.33,78.71) 130.27,78.94 130.27,82.09 130.27,82.09 130.27,82.36 130.5,82.59 130.77,82.59 131.06,82.88 131.06,84.12 130.26,84.93 130.26,85.43 129.4,86.29 129.4,86.41 129.78,86.79 129.78,86.9 129.66,87.03 129.54,87.03 129.16,86.65 129.05,86.65 128.92,86.77 128.92,86.88 129.3,87.26 129.3,87.38 129.18,87.5 129.07,87.5 128.69,87.12 128.57,87.12 128.32,87.37 128.32,87.49 128.72,87.88 128.72,88 128.59,88.12 128.48,88.12 128.08,87.72 127.97,87.72 127.85,87.85 127.85,87.96 128.69,88.8 128.69,88.92 128.57,89.04 128.45,89.04 127.61,88.2 127.49,88.2 127.37,88.32 127.37,88.44 128.33,89.4 128.33,89.51 128.21,89.63 128.09,89.63 127.13,88.67 127.02,88.67 126.9,88.79 126.9,88.91 127.87,89.88 127.87,90 127.75,90.12 127.63,90.12 126.66,89.15 126.55,89.15 126.42,89.27 126.42,89.38 126.82,89.78 126.82,89.9 126.7,90.02 126.58,90.02 126.19,89.62 126.07,89.62 125.56,90.14 124.43,90.14 123.5,90.14 121.96,91.68 120.67,91.68 120.4,91.96 120.4,92.22 120.12,92.5 119.86,92.5 119.42,92.93 119.42,93.05 119.75,93.38 119.75,93.5 119.64,93.61 119.51,93.61 119.18,93.28 119.07,93.28 118.95,93.41 118.95,93.52 119.23,93.81 119.23,93.92 119.11,94.05 119,94.05 118.71,93.76 118.59,93.76 118.43,93.92 118.43,94.26 118.35,94.34 118.18,94.34 118.1,94.26 118.1,93.92 118.02,93.84 116.85,93.84 116.77,93.92 116.77,94.26 116.69,94.34 116.52,94.34 116.44,94.26 116.44,93.92 116.35,93.84 115.05,93.84 114.97,93.92 114.97,94.27 114.89,94.35 114.72,94.35 114.64,94.27 114.64,93.92 114.55,93.84 114.38,93.84 114.3,93.92 114.3,94.27 114.22,94.35 114.05,94.35 113.96,94.27 113.96,93.92 113.88,93.84 111.68,93.84 111.6,93.92 111.6,94.26 111.52,94.34 111.35,94.34 111.27,94.26 111.27,93.92 111.19,93.84 110.32,93.84 110.24,93.92 110.24,94.26 110.16,94.35 109.98,94.35 109.9,94.26 109.9,93.92 109.82,93.84 109.65,93.84 109.57,93.92 109.57,94.26 109.49,94.35 109.31,94.35 109.23,94.26 109.23,93.92 109.15,93.84 108.88,93.84 107.92,94.79 107.55,94.79 106.62,95.73 106.62,96.74 105.42,97.94 105.39,97.94 104.99,98.34 103.4,98.34 102.63,99.12 102.63,99.48 101.57,100.54 94.52,100.54 93.67,101.38 93.35,101.38 93.27,101.46 93.27,101.76 93.18,101.85 93.02,101.85 92.94,101.77 92.94,101.46 92.86,101.38 92.68,101.38 92.6,101.46 92.6,101.76 92.51,101.85 92.35,101.85 92.27,101.77 92.27,101.46 92.19,101.38 92.01,101.38 91.93,101.46 91.93,101.76 91.84,101.85 91.68,101.85 91.6,101.77 91.6,101.46 91.52,101.38 91.34,101.38 91.26,101.46 91.26,101.76 91.17,101.85 91.01,101.85 90.93,101.77 90.93,101.46 90.85,101.38 89.82,101.38 89.56,101.65 v1(89.56,101.73)
