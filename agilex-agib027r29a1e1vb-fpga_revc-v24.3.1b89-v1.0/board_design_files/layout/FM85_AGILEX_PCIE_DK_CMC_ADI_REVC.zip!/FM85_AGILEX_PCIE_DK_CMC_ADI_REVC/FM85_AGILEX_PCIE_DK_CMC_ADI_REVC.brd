# Allegro board FM85_AGILEX_PCIE_DK_CMC_ADI_REVC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_COMP_CH1_DQS_N5: length 30.9
  L03_SIG1 w0.081: v5(154.95,24.9) 154.9,24.86 154.9,24.68 155.03,24.55 155.36,24.55 155.5,24.7 155.5,25.63 155.38,25.76 155.38,29.1 154.18,30.3 147.8,30.3 143.77,34.33 143.77,34.59 144.04,34.86 144.04,34.98 143.93,35.09 143.81,35.09 143.54,34.82 143.27,34.82 143.05,35.04 143.05,35.31 143.32,35.58 143.32,35.7 143.21,35.81 143.09,35.81 142.44,35.15 142.17,35.15 141.92,35.4 141.92,35.67 142.58,36.32 142.58,36.44 142.45,36.57 142.34,36.57 142.09,36.32 141.77,36.32 141.2,36.9 141.2,38.79 141.39,38.99 141.39,39.26 141.29,39.37 141.29,39.75 141.4,39.98 141.42,40.15 141.34,40.29 141.18,40.33 141.03,40.25 141,40.11 v1(141.02,40.07)
DDR4_COMP_CH1_DQS_N6: length 47.7
  L14_SIG5 w0.081: v1(133.04,38.22) U6.D26 133.28,38.1 133.32,37.94 133.24,37.87 133.24,37.55 133.45,37.34 133.45,36.99 133.2,36.74 132.41,36.74 131.88,36.21 131.88,35.31 131.8,35.22 131.2,35.22 131.01,35.04 131.01,34.71 131.2,34.52 131.91,34.52 132.03,34.41 132.03,33.93 131.94,33.85 131.7,33.85 131.51,33.66 131.51,33.33 131.7,33.15 131.89,33.15 131.99,33.05 131.99,32.89 131.91,32.81 131.7,32.81 131.51,32.62 131.51,32.3 131.7,32.11 131.8,32.11 131.88,32.03 131.88,31.24 132.07,31.05 132.43,31.05 132.51,30.97 132.51,30.48 132.7,30.29 133.03,30.29 133.21,30.48 133.21,30.97 133.3,31.05 134.65,31.05 134.73,30.97 134.73,30.4 134.91,30.21 135.24,30.21 135.43,30.4 135.43,30.97 135.51,31.05 135.68,31.05 135.76,30.97 135.76,30.4 135.95,30.21 136.28,30.21 136.46,30.4 136.46,30.97 136.55,31.05 136.72,31.05 136.8,30.97 136.8,30.18 137.02,29.97 137.28,29.97 137.5,30.19 137.5,30.97 137.58,31.05 137.75,31.05 137.84,30.97 137.84,30.04 138.04,29.84 138.35,29.84 138.54,30.03 138.54,30.97 138.62,31.05 138.79,31.05 138.87,30.97 138.87,30.05 139.08,29.84 139.38,29.84 139.57,30.03 139.57,30.97 139.65,31.05 139.83,31.05 139.91,30.97 139.91,30.03 140.1,29.84 140.41,29.84 140.61,30.04 140.61,30.97 140.74,31.1 143.51,31.1 143.81,30.8 143.81,30.68 143.16,30.03 143.16,29.76 143.39,29.53 143.65,29.53 144.31,30.19 144.42,30.19 146.17,28.44 146.17,27.91 145.81,27.55 145.81,27.17 145.73,27.09 145.38,27.09 145.19,26.9 145.19,26.58 145.38,26.39 145.73,26.39 145.81,26.31 145.81,26.13 145.73,26.05 145.38,26.05 145.19,25.86 145.19,25.54 145.74,24.99 145.74,24.64 145.62,24.51 144.81,24.51 144.72,24.6 144.72,24.79 v1(144.79,24.86)
DDR4_COMP_CH1_DQS_N7: length 48
  TOP w0.149: U7.A7 v1(127.27,29.26)
  L16_SIG6 w0.076: v1(120.31,44.67) 120.56,44.81 arc(120.62,44.82) 120.66,44.79 120.7,44.72 arc(120.72,44.63) 120.67,44.56 arc(120.66,44.55) 120.65,44.53 arc(120.64,44.52) 120.63,44.51 arc(120.61,44.46) 120.58,44.42 arc(120.53,44.35) 120.5,44.26 arc(120.48,44.13) 120.51,44 arc(120.57,43.75) 120.61,43.51 arc(120.62,43.46) 120.61,43.41 arc(120.6,43.25) 120.63,43.1 arc(120.64,43.07) 120.65,43.04 arc(120.65,43.02) 120.65,43 120.67,42.94 arc(120.68,42.81) 120.65,42.68 120.65,42.68 arc(120.63,42.65) 120.62,42.63 arc(120.61,42.62) 120.61,42.62 120.6,42.6 arc(120.6,42.6) 120.59,42.6 120.49,42.5 arc(120.46,42.48) 120.43,42.47 120.29,42.47 arc(120.08,42.43) 119.91,42.32 119.86,42.27 arc(119.86,42.25) 119.85,42.23 arc(119.78,42.11) 119.66,42.03 arc(119.58,42) 119.49,41.99 arc(119.08,41.79) 118.97,41.34 arc(118.96,41.29) 118.96,41.23 arc(118.97,41.2) 118.99,41.16 arc(119,41.15) 119.01,41.13 arc(119.02,41.11) 119.02,41.09 arc(119.03,41.06) 119.04,41.02 arc(119.04,40.99) 119.05,40.96 arc(119.05,40.87) 119.02,40.78 arc(119.01,40.75) 118.99,40.72 arc(118.96,40.65) 118.96,40.57 arc(118.98,40.4) 119.04,40.24 arc(119.09,40.14) 119.1,40.03 arc(119.09,39.98) 119.07,39.94 arc(119.04,39.89) 119.01,39.84 arc(118.96,39.61) 119.01,39.39 arc(119.03,39.34) 119.06,39.29 arc(119.07,39.28) 119.07,39.28 arc(119.12,39.1) 119.05,38.93 arc(118.95,38.72) 119.03,38.49 arc(119.05,38.47) 119.06,38.44 arc(119.09,38.39) 119.13,38.35 arc(119.15,38.32) 119.15,38.28 arc(119.14,38.24) 119.12,38.2 arc(119.01,38.01) 118.93,37.8 118.94,37.6 118.94,37.06 118.94,37.06 118.94,37.04
  L16_SIG6 w0.081: v1(127.27,29.26) 127.55,28.98 arc(127.58,28.96) 127.61,28.95 127.64,28.95 127.86,29.04 128.09,29.27 128.11,29.41 128.11,29.51 arc(128.08,29.6) 127.99,29.63 arc(127.89,29.76) 127.99,29.88 arc(128.11,30) 127.99,30.12 arc(127.87,30.24) 127.99,30.36 128.04,30.36 arc(128.09,30.39) 128.11,30.44 128.11,31.06 128.06,31.41 arc(128.03,31.51) 127.98,31.58 arc(127.92,31.62) 127.85,31.64 126.28,31.64 arc(126.22,31.61) 126.2,31.55 126.2,31.27 126.28,31.19 127.26,31.19 127.48,30.96 127.48,30.11 127.29,29.92 125.73,29.92 125.5,30.15 125.5,33.27 125.4,33.37 125.24,33.37 125.16,33.29 125.16,30.07 124.97,29.88 124.66,29.88 124.46,30.08 124.46,31.72 124.38,31.8 124.21,31.8 124.13,31.72 124.13,30.36 123.94,30.17 123.63,30.17 123.43,30.37 123.43,31.02 123.34,31.1 121.71,31.1 121.63,31.02 121.63,28.94 121.28,28.59 120.58,28.59 120.04,29.12 120.04,30.17 120.14,30.27 120.14,31.42 120.74,32.02 120.74,34.43 119.2,35.98 119.2,36.08 118.94,36.33 118.94,37.04
DDR4_COMP_CH1_DQS_N8: length 60.7
  L14_SIG5 w0.076: v1(129.87,44.67) 130.05,44.84 arc(130.08,44.89) 130.08,44.95 130.05,45.16 arc(130.06,45.26) 130.11,45.36 130.12,45.36 arc(130.15,45.41) 130.18,45.47 130.18,45.48 arc(130.27,45.6) 130.4,45.68 130.4,45.68 arc(130.51,45.69) 130.62,45.68 arc(130.66,45.68) 130.7,45.67 arc(130.84,45.64) 130.98,45.57 arc(131.07,45.51) 131.15,45.44 arc(131.18,45.41) 131.2,45.38 arc(131.22,45.36) 131.23,45.35 arc(131.26,45.32) 131.28,45.29 arc(131.29,45.26) 131.31,45.22 arc(131.31,45.06) 131.23,44.92 arc(131.16,44.5) 131.55,44.34 arc(131.62,44.36) 131.69,44.39 arc(131.75,44.43) 131.79,44.49 arc(131.79,44.49) 131.79,44.49 arc(131.82,44.53) 131.85,44.57 131.86,44.58 arc(132.09,44.73) 132.37,44.74 arc(132.41,44.73) 132.45,44.72 arc(132.5,44.7) 132.55,44.67 132.6,44.63 arc(132.6,44.63) 132.61,44.62 arc(132.61,44.62) 132.62,44.62 arc(132.62,44.61) 132.63,44.61 arc(132.63,44.6) 132.64,44.6 arc(132.71,44.51) 132.77,44.4 arc(132.78,44.37) 132.8,44.34 arc(132.83,44.32) 132.85,44.31 133.16,44.25 arc(133.21,44.25) 133.26,44.25 arc(133.32,44.27) 133.37,44.3 arc(133.42,44.33) 133.47,44.37 133.61,44.51 133.61,44.52 133.63,44.53
  L14_SIG5 w0.081: 133.63,44.53 133.75,44.65 134.2,44.65 134.59,44.25 135.1,44.25 135.47,44.62 135.97,44.62 136.34,44.25 136.82,44.25 137.32,43.75 137.64,43.75 138.25,43.15 138.66,43.15 139.21,42.6 139.54,42.6 139.99,42.15 140.34,42.15 140.69,42.5 141.26,42.5 141.67,42.09 141.86,42.09 142.33,42.56 142.96,42.56 143.29,42.23 145.15,42.23 145.43,41.94 145.43,41.18 145.24,41 144.17,41 144.09,40.91 144.09,40.76 144.19,40.66 145.36,40.66 145.55,40.47 145.55,40.15 145.36,39.96 144.37,39.96 144.29,39.88 144.29,39.71 144.37,39.62 145.63,39.62 145.88,39.38 145.88,39.11 145.69,38.92 144.11,38.92 144.03,38.84 144.03,38.7 144.13,38.59 145.9,38.59 146.17,38.31 146.17,37.95 145.89,37.67 143.76,37.67 143.67,37.58 143.67,37.41 143.75,37.33 145.7,37.33 145.91,37.12 145.91,35.14 148.39,32.66 152.42,32.66 152.63,32.45 157.49,32.45 157.68,32.27 157.68,31.74 157.49,31.55 157.08,31.55 157,31.47 157,31.29 157.08,31.21 157.49,31.21 157.68,31.02 157.68,30.7 157.49,30.51 157.08,30.51 157,30.43 157,30.26 157.08,30.18 157.49,30.18 157.68,29.99 157.68,29.41 157.49,29.22 156.91,29.22 156.82,29.14 156.82,28.64 156.91,28.55 157.8,28.55 v1(158.15,28.9)
DDR4_COMP_CH1_DQS_P0: length 52.4
  L07_SIG3 w0.076: 144.1,40.18 144.08,40.18 144.08,40.17 143.8,40.17 arc(143.69,40.17) 143.57,40.17 arc(143.52,40.17) 143.47,40.16 arc(143.43,40.16) 143.38,40.16 arc(143.3,40.16) 143.21,40.17 arc(143.17,40.18) 143.14,40.22 arc(142.93,40.52) 142.58,40.61 arc(142.42,40.64) 142.32,40.76 arc(141.82,41.07) 141.32,40.75 arc(141.32,40.74) 141.31,40.73 141.31,40.73 arc(141.23,40.63) 141.1,40.61 arc(140.76,40.54) 140.52,40.28 arc(140.42,40.16) 140.26,40.13 arc(140.05,40.1) 139.87,39.99 arc(139.83,39.94) 139.78,39.9 139.77,39.89 arc(139.74,39.86) 139.72,39.84 arc(139.68,39.8) 139.64,39.76 arc(139.61,39.74) 139.58,39.72 139.55,39.69 arc(139.52,39.67) 139.48,39.66 arc(139.38,39.66) 139.28,39.65 arc(139.2,39.62) 139.13,39.58 arc(139.06,39.53) 138.99,39.48
  L07_SIG3 w0.089: 138.99,39.48 138.95,39.43 arc(138.83,39.15) 138.95,38.87 138.98,38.83 arc(139.04,38.69) 138.98,38.54 138.95,38.51 arc(138.83,38.23) 138.95,37.96 139.08,37.82 arc(139.12,37.74) 139.08,37.66 138.74,37.32 arc(138.59,37.26) 138.44,37.32 138.31,37.45 arc(138.26,37.52) 138.23,37.6 138.23,37.62 arc(138.23,37.7) 138.26,37.78 138.29,37.83 arc(138.33,37.88) 138.38,37.9 138.39,37.9 arc(138.53,37.89) 138.61,37.78 v1(138.62,37.74) ; 144.1,40.18 146.39,40.18 148.1,41.89 152.46,41.89 arc(152.57,41.86) 152.67,41.8 156.9,37.57 162.07,32.4 arc(162.11,32.37) 162.15,32.36 162.81,32.36 166.51,28.66 166.51,25.67 167.27,24.91 167.27,20.99 167.04,20.76 166.75,20.76 166.54,20.97 166.54,24.23 166.37,24.4 165.45,24.4 v1(165.11,24.06)
DDR4_COMP_CH1_DQS_P1: length 27.6
  L03_SIG1 w0.081: v1(129.07,37.77) 128.82,37.91 128.71,37.88 128.64,37.76 128.64,37.31 129.97,35.98 129.97,35.71 129.65,35.38 129.65,35.27 129.76,35.15 129.88,35.15 130.2,35.48 130.47,35.48 131.66,34.29 131.66,33.32 131.89,33.08 131.89,32.82 131.69,32.61 131.69,32.49 131.8,32.38 131.92,32.38 132.12,32.59 132.39,32.59 132.85,32.13 132.97,32.13 133.26,32.42 133.53,32.42 133.75,32.2 133.75,31.93 133.45,31.64 133.45,31.52 134.25,30.72 134.25,30.31 135.24,29.31 135.68,29.31 135.87,29.13 135.87,28.81 135.68,28.62 135.33,28.62 135.25,28.54 135.25,27.5 135.33,27.42 135.66,27.42 135.85,27.23 135.85,26.92 135.66,26.73 135.33,26.73 135.25,26.65 135.25,26.48 135.33,26.4 135.66,26.4 135.85,26.21 135.85,25.9 135.66,25.71 135.32,25.71 135.25,25.63 135.25,25.32 135.34,25.23 135.63,25.23 135.87,24.99 135.87,22.83 135.63,22.58 135.36,22.58 135.16,22.79 135.16,24.26 135.07,24.34 134.68,24.34 134.63,24.29 v5(134.63,24.06)
DDR4_COMP_CH1_DQS_P2: length 31
  L03_SIG1 w0.081: v5(124.47,24.06) 124.47,24.29 124.55,24.37 124.86,24.37 124.97,24.26 124.97,22.47 125.2,22.23 125.55,22.23 125.74,22.42 125.74,23.84 125.82,23.92 126.36,23.92 126.49,23.79 126.49,22.88 126.66,22.7 126.97,22.7 127.19,22.93 127.19,24.48 127.01,24.67 125.63,24.67 125.07,25.23 125.07,25.53 125.15,25.61 125.55,25.61 125.76,25.81 125.76,26.12 125.57,26.31 125.26,26.31 125.18,26.39 125.18,26.56 125.26,26.64 125.51,26.64 125.7,26.83 125.7,27.16 125.51,27.34 125.11,27.34 125.03,27.43 125.03,28.95 125.11,29.03 125.41,29.03 125.6,29.22 125.6,29.55 125.41,29.74 125.11,29.74 125.03,29.82 125.03,30.58 123.77,31.83 123.77,32.11 123.63,32.26 123.63,32.61 123.77,32.76 123.77,33.31 123.63,33.46 123.63,34.53 124.01,34.91 124.01,35.47 123.63,35.85 123.63,37.6 124.03,38.01 124.03,38.46 123.91,38.58 123.91,38.78 124.03,38.9 124.03,39.36 123.92,39.46 123.92,39.74 124.06,39.89 124.06,40.3 124.27,40.51 v1(124.27,40.54)
DDR4_COMP_CH1_DQS_P3: length 39.8
  TOP w0.149: U8.B7 v1(137.32,28.06)
  L05_SIG2 w0.076: v1(121.11,42.38) 121.08,42.42 arc(121.06,42.44) 121.02,42.46 120.81,42.49 arc(120.75,42.48) 120.7,42.44 arc(120.69,42.37) 120.71,42.3 arc(120.79,42.19) 120.84,42.06 arc(120.85,41.87) 120.8,41.68 arc(120.78,41.64) 120.76,41.59 arc(120.73,41.47) 120.75,41.34 arc(120.76,41.28) 120.78,41.21 arc(120.78,41.17) 120.79,41.13 arc(120.81,40.96) 120.77,40.79 arc(120.74,40.69) 120.73,40.59 120.73,40.47 arc(120.74,40.41) 120.76,40.36 arc(120.85,40.07) 120.76,39.77 arc(120.74,39.72) 120.73,39.67 120.73,39.55 arc(120.74,39.49) 120.76,39.44 arc(120.85,39.16) 120.78,38.87 arc(120.76,38.84) 120.74,38.81 arc(120.71,38.67) 120.76,38.53 arc(120.85,38.15) 120.65,37.8 arc(120.57,37.68) 120.56,37.54 arc(120.58,37.42) 120.62,37.3 arc(120.82,36.96) 121.15,36.74 121.2,36.72 arc(121.51,36.51) 121.73,36.2
  L05_SIG2 w0.081: v1(137.32,28.06) 137.63,28.37 137.73,28.37 137.92,28.56 137.92,29.64 137.56,30 137.43,30 136.56,30.87 135.68,30.87 135.49,30.68 135.49,29.59 135.41,29.5 135.24,29.5 135.16,29.59 135.16,30.68 134.97,30.87 132.36,30.87 132.17,30.68 132.17,29.27 132.09,29.19 131.92,29.19 131.84,29.27 131.84,30.66 131.65,30.85 131.32,30.85 131.14,30.66 131.14,29.27 131.05,29.19 130.88,29.19 130.8,29.27 130.8,30.63 130.56,30.87 130,30.87 129.92,30.95 129.92,35.33 129.55,35.7 122.65,35.7 arc(122.12,35.84) 121.73,36.2
DDR4_COMP_CH1_DQS_P4: length 52.2
  TOP w0.149: U9.B7 v1(147.48,28.06)
  L07_SIG3 w0.076: 129.12,37.18 129.11,37.18 129.06,37.24 arc(128.78,37.44) 128.44,37.54 arc(128.33,37.57) 128.21,37.6 arc(128.08,37.68) 128.02,37.83 arc(127.86,38.16) 127.52,38.31 arc(127.33,38.38) 127.19,38.53 arc(127.15,38.64) 127.16,38.76 arc(127.19,38.91) 127.22,39.05 arc(127.22,39.24) 127.16,39.43 arc(127.14,39.46) 127.13,39.49 arc(127.11,39.54) 127.09,39.58 arc(126.96,39.7) 126.79,39.71 arc(126.74,39.7) 126.7,39.69 arc(126.68,39.69) 126.66,39.69 arc(126.51,39.73) 126.39,39.83 arc(126.37,39.85) 126.36,39.88 arc(126.35,39.89) 126.35,39.91 arc(126.34,39.92) 126.33,39.94 arc(126.3,40.01) 126.24,40.08 arc(126.1,40.15) 125.94,40.16 arc(125.59,40.3) 125.55,40.68 arc(125.62,40.99) 125.55,41.29 arc(125.52,41.48) 125.58,41.65 arc(125.63,41.76) 125.65,41.87 arc(125.65,41.94) 125.63,42.01 125.49,42.35 arc(125.49,42.4) 125.5,42.44 125.52,42.49 arc(125.52,42.49) 125.52,42.49 arc(125.57,42.52) 125.63,42.51 v1(125.88,42.37)
  L07_SIG3 w0.089: 129.12,37.18 129.85,36.45 130.63,36.45 133.8,33.28 133.8,32.23 133.48,31.91 132.64,31.91 132.55,31.82 132.55,30.5 132.65,30.41 134.09,30.41 134.39,30.1 134.39,29.64 134.51,29.52 135.37,29.52 135.57,29.32 135.57,28.74 135.66,28.65 135.82,28.65 135.91,28.74 135.91,29.32 136.11,29.52 136.45,29.52 136.54,29.61 136.54,30.89 136.74,31.09 137.07,31.09 137.27,30.89 137.27,29.61 137.35,29.52 137.52,29.52 137.61,29.61 137.61,30.89 137.81,31.09 138.13,31.09 138.33,30.89 138.33,29.61 138.42,29.52 138.59,29.52 138.68,29.61 138.68,30.89 138.88,31.09 139.2,31.09 139.4,30.89 139.4,29.61 139.49,29.52 139.88,29.52 140.08,29.32 140.08,28.79 140.16,28.7 140.33,28.7 140.42,28.79 140.42,29.32 140.62,29.52 140.94,29.52 141.14,29.32 141.14,28.4 141.26,28.28 141.4,28.28 141.49,28.37 141.49,29.32 141.69,29.52 142.01,29.52 142.21,29.32 142.21,28.43 142.3,28.34 142.44,28.34 142.55,28.45 142.55,29.32 142.75,29.52 145.05,29.52 145.27,29.73 147.86,29.73 148.19,29.41 148.19,28.57 147.99,28.37 147.78,28.37 v1(147.48,28.06)
DDR4_COMP_CH1_DQS_P5: length 31
  L03_SIG1 w0.081: v5(154.95,24.1) 154.95,24.28 155.04,24.37 155.43,24.37 155.69,24.62 155.69,25.71 155.56,25.84 155.56,29.17 154.25,30.48 147.87,30.48 143.95,34.4 143.95,34.52 144.22,34.79 144.22,35.05 144,35.28 143.74,35.28 143.47,35.01 143.35,35.01 143.24,35.12 143.24,35.24 143.51,35.51 143.51,35.77 143.28,35.99 143.02,35.99 142.36,35.34 142.24,35.34 142.11,35.48 142.11,35.59 142.76,36.25 142.76,36.52 142.53,36.75 142.26,36.75 142.02,36.51 141.85,36.51 141.38,36.97 141.38,38.72 141.58,38.91 141.58,39.34 141.47,39.45 141.47,39.71 141.58,39.92 141.61,40.18 141.55,40.29 141.57,40.38 v1(141.82,40.53)
DDR4_COMP_CH1_DQS_P6: length 47.5
  L14_SIG5 w0.081: v1(133.83,37.76) 133.83,37.77 133.75,37.85 133.48,37.85 133.42,37.79 133.42,37.63 133.63,37.42 133.63,36.91 133.28,36.56 132.49,36.56 132.06,36.14 132.06,35.23 131.88,35.04 131.28,35.04 131.2,34.96 131.2,34.79 131.28,34.71 131.99,34.71 132.21,34.48 132.21,33.85 132.02,33.66 131.78,33.66 131.7,33.58 131.7,33.41 131.78,33.33 131.97,33.33 132.18,33.12 132.18,32.82 131.99,32.63 131.78,32.63 131.7,32.55 131.7,32.37 131.78,32.29 131.88,32.29 132.06,32.1 132.06,31.32 132.15,31.23 132.51,31.23 132.7,31.04 132.7,30.56 132.78,30.47 132.95,30.47 133.03,30.56 133.03,31.04 133.22,31.23 134.72,31.23 134.91,31.04 134.91,30.47 134.99,30.39 135.16,30.39 135.24,30.47 135.24,31.04 135.43,31.23 135.76,31.23 135.95,31.04 135.95,30.47 136.03,30.39 136.2,30.39 136.28,30.47 136.28,31.04 136.47,31.23 136.79,31.23 136.98,31.04 136.98,30.26 137.09,30.15 137.21,30.15 137.32,30.26 137.32,31.04 137.51,31.23 137.83,31.23 138.02,31.04 138.02,30.12 138.11,30.02 138.27,30.02 138.35,30.1 138.35,31.04 138.54,31.23 138.87,31.23 139.05,31.04 139.05,30.12 139.16,30.02 139.31,30.02 139.39,30.1 139.39,31.04 139.58,31.23 139.9,31.23 140.09,31.04 140.09,30.1 140.17,30.02 140.33,30.02 140.43,30.12 140.43,31.04 140.67,31.28 143.58,31.28 143.99,30.87 143.99,30.61 143.34,29.95 143.34,29.84 143.46,29.72 143.58,29.72 144.23,30.37 144.5,30.37 146.35,28.51 146.35,27.84 145.99,27.48 145.99,27.09 145.81,26.91 145.46,26.91 145.38,26.82 145.38,26.65 145.46,26.57 145.81,26.57 145.99,26.38 145.99,26.06 145.81,25.87 145.46,25.87 145.38,25.79 145.38,25.62 145.93,25.06 145.93,24.56 145.69,24.32 145.05,24.32 v1(144.79,24.06)
DDR4_COMP_CH1_DQS_P7: length 47.9
  TOP w0.149: U7.B7 v1(127.27,28.46)
  L16_SIG6 w0.076: 119.12,37.04 119.12,37.06 119.12,37.06 119.12,37.61 119.11,37.77 arc(119.18,37.94) 119.27,38.1 arc(119.31,38.18) 119.33,38.26 arc(119.32,38.37) 119.26,38.47 arc(119.24,38.5) 119.22,38.53 arc(119.19,38.57) 119.16,38.61 arc(119.13,38.71) 119.17,38.8 arc(119.3,39.09) 119.21,39.38 119.21,39.38 arc(119.21,39.39) 119.21,39.39 arc(119.19,39.43) 119.17,39.46 arc(119.14,39.61) 119.17,39.76 arc(119.19,39.8) 119.22,39.84 arc(119.26,39.93) 119.28,40.03 arc(119.26,40.19) 119.2,40.33 arc(119.15,40.44) 119.14,40.56 arc(119.14,40.56) 119.14,40.57 arc(119.14,40.58) 119.14,40.6 arc(119.14,40.6) 119.14,40.6 arc(119.14,40.62) 119.14,40.63 arc(119.16,40.66) 119.18,40.7 arc(119.23,40.84) 119.22,40.99 arc(119.22,41.02) 119.22,41.04 arc(119.21,41.06) 119.21,41.09 arc(119.21,41.12) 119.21,41.15 arc(119.21,41.16) 119.21,41.17 arc(119.2,41.22) 119.18,41.27 arc(119.19,41.63) 119.5,41.81 arc(119.62,41.83) 119.73,41.87 arc(119.91,41.99) 120.02,42.17 120.04,42.19 arc(120.15,42.27) 120.29,42.29 120.43,42.29 arc(120.53,42.31) 120.61,42.37 120.72,42.47 arc(120.73,42.48) 120.74,42.49 120.75,42.51 arc(120.76,42.52) 120.76,42.52 arc(120.79,42.56) 120.81,42.6 120.81,42.61 arc(120.86,42.8) 120.84,42.99 120.83,43.05 arc(120.82,43.05) 120.82,43.06 arc(120.82,43.06) 120.82,43.06 arc(120.81,43.11) 120.8,43.16 arc(120.77,43.26) 120.78,43.37 arc(120.79,43.45) 120.79,43.53 arc(120.74,43.79) 120.68,44.05 arc(120.66,44.13) 120.67,44.22 arc(120.69,44.27) 120.71,44.31 arc(120.76,44.36) 120.79,44.43 arc(120.89,44.61) 120.86,44.81 120.82,44.88 arc(120.81,44.93) 120.85,44.98 v1(121.1,45.13)
  L16_SIG6 w0.081: 119.12,37.04 119.12,36.42 119.38,36.16 119.38,36.06 120.93,34.51 120.93,31.94 120.32,31.34 120.32,30.19 120.22,30.09 120.22,29.2 120.65,28.77 121.2,28.77 121.45,29.02 121.45,31.09 121.64,31.28 123.42,31.28 123.61,31.09 123.61,30.45 123.7,30.35 123.86,30.35 123.94,30.43 123.94,31.8 124.13,31.98 124.46,31.98 124.64,31.8 124.64,30.15 124.73,30.06 124.9,30.06 124.98,30.14 124.98,33.36 125.17,33.55 125.47,33.55 125.68,33.34 125.68,30.23 125.81,30.1 127.22,30.1 127.3,30.19 127.3,30.88 127.18,31 126.2,31 126.02,31.19 126.02,31.55 arc(126.09,31.74) 126.28,31.82 127.85,31.82 arc(127.99,31.79) 128.11,31.71 arc(128.2,31.59) 128.24,31.44 128.29,31.13 arc(128.3,31.11) 128.3,31.09 128.3,29.4 128.26,29.18 127.97,28.89 127.67,28.77 127.47,28.77 arc(127.44,28.77) 127.41,28.75 127.25,28.59 127.25,28.48 v1(127.27,28.46)
DDR4_COMP_CH1_DQS_P8: length 60.8
  L14_SIG5 w0.076: v1(130.66,45.13) 130.5,45.03 arc(130.42,45.01) 130.34,45.02 130.31,45.03 arc(130.28,45.05) 130.27,45.07 130.25,45.11 arc(130.25,45.12) 130.24,45.12 arc(130.24,45.15) 130.23,45.18 arc(130.23,45.21) 130.25,45.24 130.25,45.25 arc(130.31,45.32) 130.35,45.41 130.35,45.42 arc(130.39,45.47) 130.45,45.51 arc(130.52,45.52) 130.59,45.51 arc(130.64,45.5) 130.69,45.49 arc(130.78,45.47) 130.87,45.43 arc(130.87,45.43) 130.88,45.43 arc(130.96,45.37) 131.03,45.3 arc(131.05,45.29) 131.06,45.27 arc(131.09,45.25) 131.11,45.22 arc(131.12,45.21) 131.12,45.2 arc(131.13,45.19) 131.14,45.17 arc(131.14,45.1) 131.11,45.05 arc(131.01,44.41) 131.6,44.16 arc(131.69,44.2) 131.78,44.24 arc(131.87,44.31) 131.94,44.4 arc(131.96,44.42) 131.98,44.45 131.99,44.46 arc(132.15,44.56) 132.33,44.57 132.41,44.55 arc(132.42,44.54) 132.44,44.53 132.49,44.49 arc(132.49,44.49) 132.5,44.49 arc(132.5,44.49) 132.5,44.48 arc(132.51,44.48) 132.51,44.48 arc(132.51,44.47) 132.52,44.47 arc(132.57,44.41) 132.6,44.34 arc(132.63,44.28) 132.66,44.23 arc(132.73,44.17) 132.82,44.13 133.13,44.07 arc(133.22,44.07) 133.31,44.08 arc(133.38,44.11) 133.45,44.14 arc(133.53,44.19) 133.6,44.25 133.74,44.39 133.74,44.39 133.76,44.4
  L14_SIG5 w0.081: 133.76,44.4 133.82,44.47 134.12,44.47 134.52,44.07 135.17,44.07 135.55,44.44 135.9,44.44 136.27,44.07 136.75,44.07 137.25,43.57 137.57,43.57 138.17,42.97 138.58,42.97 139.14,42.42 139.47,42.42 139.91,41.97 140.42,41.97 140.76,42.31 141.19,42.31 141.6,41.9 141.93,41.9 142.4,42.37 142.88,42.37 143.21,42.04 145.07,42.04 145.25,41.86 145.25,41.26 145.17,41.18 144.09,41.18 143.91,40.99 143.91,40.68 144.11,40.48 145.28,40.48 145.37,40.4 145.37,40.23 145.28,40.14 144.3,40.14 144.11,39.95 144.11,39.63 144.3,39.44 145.55,39.44 145.69,39.3 145.69,39.19 145.61,39.11 144.03,39.11 143.84,38.92 143.84,38.62 144.06,38.4 145.82,38.4 145.99,38.23 145.99,38.02 145.82,37.85 143.68,37.85 143.48,37.65 143.48,37.34 143.67,37.15 145.62,37.15 145.72,37.05 145.72,35.07 148.32,32.47 152.35,32.47 152.55,32.27 157.42,32.27 157.5,32.19 157.5,31.81 157.42,31.73 157,31.73 156.82,31.54 156.82,31.22 157,31.03 157.42,31.03 157.5,30.95 157.5,30.78 157.42,30.69 157,30.69 156.82,30.51 156.82,30.18 157,29.99 157.42,29.99 157.5,29.91 157.5,29.48 157.42,29.4 156.83,29.4 156.64,29.21 156.64,28.56 156.83,28.37 157.13,28.37 157.21,28.29 157.21,28.15 157.3,28.06 157.45,28.06 157.55,28.16 157.55,28.31 157.61,28.37 157.88,28.37 v1(158.15,28.1)
DDR4_COMP_CH1_ODT: length 84.1
  TOP w0.149: U8.K3 v1(135.13,21.66) ; U11.K3 v1(165.74,21.66) ; U10.K3 v1(155.45,21.7) ; U9.K3 v1(145.29,21.66) ; v1(124.9,22) 124.79,22 U7.K3
  L07_SIG3 w0.089: v1(165.74,21.66) 165.32,22.08 155.83,22.08 v1(155.45,21.7) 155.09,22.07 154.31,22.07 154.3,22.08 153.99,22.08 153.99,22.07 145.7,22.07 v1(145.29,21.66) 144.9,22.05 135.52,22.05 v1(135.13,21.66) 134.2,22.6 134.2,22.62 133.77,23.05 127.23,23.05 126.21,22.03 124.93,22.03 v1(124.9,22)
  L16_SIG6 w0.081: v1(125.88,45.13) 125.88,45.49 125.79,45.58 125.61,45.58 125.24,45.22 124.9,45.22 124.49,44.8 arc(124.44,44.77) 124.38,44.76 124.26,44.76 arc(124.22,44.75) 124.19,44.73 123.95,44.49 arc(123.92,44.43) 123.9,44.37 123.9,40.7 123.9,40.7 123.9,40.39 123.9,40.39 123.9,38.66 arc(123.97,38.46) 124.13,38.32 124.31,38.22 arc(124.47,38.11) 124.6,37.95 124.6,37.95 124.62,37.93 124.68,37.74 arc(124.69,37.7) 124.7,37.66 arc(124.79,37.33) 124.96,37.04 arc(125.02,36.97) 125.08,36.9 125.17,36.81 arc(125.26,36.75) 125.35,36.73 arc(125.39,36.72) 125.43,36.71 125.64,36.61 arc(125.72,36.54) 125.77,36.44 125.84,36.22 arc(125.84,36.18) 125.85,36.14 125.86,35.94 arc(125.9,35.84) 125.98,35.78 126.17,35.71 arc(126.18,35.71) 126.19,35.71 126.84,35.68 arc(127.38,35.57) 127.83,35.27 129.01,34.09 arc(129.95,32.68) 130.28,31.02 130.28,29.55 130.52,29.31 130.52,28.22 130.53,28.22 130.53,27.74 arc(130.52,27.62) 130.49,27.5 arc(130.47,27.39) 130.48,27.28 arc(130.48,27.14) 130.45,27.01 130.02,26 arc(129.89,25.74) 129.71,25.52 129.42,25.23 129.15,25.23 arc(129.12,25.23) 129.09,25.21 128.9,25.02 128.9,24.74 128.59,24.43 128.31,24.43 128.1,24.22 128.1,23.94 127.36,23.21 127.24,23.21 127.01,23.45 127.01,23.56 127.18,23.73 127.18,23.84 127.05,23.97 126.94,23.97 126.77,23.8 126.65,23.8 126.4,24.05 126.29,24.05 126.16,23.93 126.16,23.81 127.01,22.97 127.01,22.86 126.19,22.03 125.77,22.03 125.69,22.12 125.69,23.82 125.6,23.91 125.44,23.91 125.36,23.83 125.36,22.12 125.28,22.03 124.93,22.03 v1(124.9,22)
DDR4_COMP_CH1_PAR: length 82.7
  TOP w0.149: U9.T3 v1(145.29,16.86) ; U8.T3 v1(135.13,16.86) ; U7.T3 v1(124.47,16.4) ; U10.T3 v1(155.45,16.9) ; U11.T3 v1(165.74,16.86)
  L03_SIG1 w0.081: v1(145.29,16.86) 144.9,16.47 139.42,16.47 arc(139.29,16.49) 139.18,16.56 arc(138.96,16.69) 138.7,16.74 138.53,16.74 arc(138.34,16.71) 138.17,16.62 arc(138.01,16.52) 137.82,16.49 135.51,16.49 v1(135.13,16.86) 134.75,16.48 128.87,16.48 128.61,16.74 128.32,16.74 127.98,16.4 v1(124.47,16.4)
  L07_SIG3 w0.089: v1(155.45,16.9) 155.07,17.28 152.91,17.28 152.75,17.44 152.6,17.44 152.41,17.25 152.25,17.25 152.07,17.44 151.91,17.44 151.73,17.25 145.68,17.25 v1(145.29,16.86)
  L12_SIG4 w0.089: v1(124.47,16.4) 124.46,16.4 124.01,16.4 arc(123.96,16.4) 123.92,16.4 123.53,16.47 arc(123.49,16.49) 123.45,16.51 123.09,16.79 arc(122.95,16.9) 122.82,17.02 arc(122.79,17.05) 122.76,17.09 122.41,17.61 arc(122.05,18.21) 121.74,18.84 arc(121.65,19.11) 121.62,19.38 121.62,27.94 121.71,28.03 122.32,28.03 122.4,28.11 122.4,28.28 122.32,28.37 121.59,28.37 121.49,28.47 121.49,28.62 121.58,28.71 122.4,28.71 122.49,28.8 122.49,28.97 122.4,29.05 121.71,29.05 121.62,29.14 121.62,32.85 arc(121.63,33.28) 121.67,33.72 121.75,34.51 arc(121.96,35.99) 122.3,37.45 arc(122.32,37.51) 122.32,37.57 122.32,37.84 122.32,41.46 arc(122.42,41.71) 122.67,41.82 arc(122.8,41.85) 122.91,41.93 123.33,42.35 arc(123.43,42.42) 123.54,42.46 arc(123.77,42.57) 123.87,42.81 arc(123.88,42.88) 123.9,42.95 arc(123.93,43.07) 123.93,43.2 arc(123.95,43.45) 124.13,43.63 arc(124.17,43.65) 124.21,43.67 124.51,43.89 arc(124.67,44.05) 124.76,44.24 124.77,44.24 arc(124.78,44.38) 124.75,44.51 arc(124.72,44.74) 124.83,44.94 arc(124.95,45.05) 125.06,45.17 arc(125.11,45.2) 125.16,45.22 arc(125.43,45.32) 125.66,45.49 125.75,45.57 arc(125.84,45.64) 125.95,45.68 arc(126.15,45.78) 126.25,45.98 arc(126.29,46.09) 126.36,46.18 v1(126.68,46.51)
  L16_SIG6 w0.081: v1(165.74,16.86) 165.33,17.27 157.99,17.27 157.97,17.25 157.52,17.25 157.5,17.27 155.83,17.27 v1(155.45,16.9)
DDR4_COMP_CH1_RESET_N: length 85
  L07_SIG3 w0.089: v1(143.19,18.46) 140.26,18.46 139.89,18.09 133.4,18.09 v1(133.03,18.46) 132.7,18.14 131.61,18.14 131.52,18.23 131.52,18.45 131.43,18.54 131.27,18.54 131.18,18.45 131.18,18.23 131.09,18.14 130,18.14 129.9,18.04 123.53,18.04 123.1,18.46 v1(122.87,18.46)
  L12_SIG4 w0.089: v1(163.51,18.46) 160.66,18.46 160.28,18.09 153.72,18.09 v1(153.35,18.46)
  L14_SIG5 w0.081: v1(122.87,18.46) 123.3,18.03 123.76,18.03 124.1,18.37 124.1,18.54 124.18,18.62 124.53,18.62 124.61,18.71 124.61,18.88 124.53,18.96 124.18,18.96 124.1,19.04 124.1,19.21 124.18,19.29 124.53,19.29 124.61,19.38 124.61,19.55 124.53,19.63 124.18,19.63 124.1,19.71 124.1,19.88 124.18,19.97 124.53,19.97 124.61,20.05 124.61,20.22 124.53,20.3 124.18,20.3 124.1,20.38 124.1,21.36 124.18,21.44 124.46,21.44 124.54,21.52 124.54,21.69 124.46,21.78 124.18,21.78 124.1,21.86 124.1,22.61 124.21,22.73 124.59,22.73 124.68,22.81 124.68,22.95 124.57,23.06 124.21,23.06 124.13,23.14 124.13,23.52 124.35,23.74 124.49,23.74 125.29,22.93 125.41,22.93 125.53,23.05 125.53,23.17 124.73,23.97 124.73,24.12 125.37,24.77 125.37,24.98 125.46,25.06 125.64,25.06 125.72,25.14 125.72,25.32 125.64,25.4 125.46,25.4 125.37,25.48 125.37,25.65 125.46,25.73 125.64,25.73 125.72,25.81 125.72,25.99 125.64,26.07 125.46,26.07 125.37,26.15 125.37,26.32 125.46,26.4 125.64,26.4 125.72,26.48 125.72,26.66 125.64,26.74 125.39,26.74 125.28,26.85 125.28,27.41 125.42,27.55 125.77,27.55 126.27,28.05 arc(126.29,28.08) 126.3,28.12 126.3,29.71 arc(126.3,29.72) 126.3,29.73 126.3,33.09 126.58,33.37 127.15,33.37 127.35,33.58 127.35,34.99 126.74,35.6 126.74,36.41 127.11,36.79 127.11,37.61 127.11,37.61 127.11,37.92 127.11,37.93 127.11,38.14 arc(127.08,38.31) 126.98,38.45 126.89,38.54 arc(126.86,38.57) 126.83,38.59 arc(126.73,38.63) 126.63,38.67 arc(126.54,38.72) 126.46,38.78 arc(126.31,39.01) 126.25,39.28 126.25,39.68 arc(126.24,39.75) 126.19,39.82 126.13,39.89 arc(126.07,39.93) 126,39.96 arc(125.96,39.98) 125.92,40 125.49,40.28 arc(125.36,40.36) 125.22,40.42 arc(125.19,40.44) 125.15,40.45 125.07,40.49 arc(124.72,40.67) 124.42,40.92 124.38,40.96 arc(124.35,40.99) 124.31,41.01 124.17,41.07 arc(124.13,41.09) 124.1,41.11 124.02,41.19 arc(123.94,41.3) 123.92,41.43 123.92,44.24 v1(123.49,44.67)
  L16_SIG6 w0.081: v1(143.19,18.46) 143.58,18.06 150.23,18.06 150.63,18.46 v1(153.35,18.46)
  BOTTOM w0.149: v1(163.51,18.46) 163.48,18.46 162.89,17.87 162.69,17.87 162.47,17.65 R67.2 R68.2
DDR4_COMP_CH1_RZQ: length 11
  BOTTOM w0.149: v1(129.07,44.21) 129.45,43.83 129.45,43.48 129.48,43.45 129.48,43.12 129.45,43.09 129.45,42.58 129.53,42.49 129.53,42.18 129.46,42.11 129.46,40.82 129.48,40.81 129.48,38.52 129.24,38.28 129.03,38.28 127.77,37.02 127.77,35.89 127.61,35.73 127.38,35.73 126.89,35.24 v1(126.89,34.8)
DDR4_COMP_CH1_TEN: length 47.3
  TOP w0.149: U10.N9 v1(160.25,19.3) ; U11.N9 170.52,19.26 v1(170.54,19.24) ; U9.N9 v1(150.09,19.26) ; U8.N9 v1(139.93,19.26) ; U7.N9 v1(129.77,19.26)
  L14_SIG5 w0.081: v1(129.77,19.26) 130.42,19.26 130.79,19.63 139.56,19.63 v1(139.93,19.26) 140.35,19.68 149.68,19.68 v1(150.09,19.26) 150.51,19.68 159.87,19.68 v1(160.25,19.3) 160.59,19.63 170.15,19.63 v1(170.54,19.24)
  BOTTOM w0.149: R71.1 R69.2 171.6,18.87 170.91,18.87 v1(170.54,19.24)
DDR4_DDIMM2_A0: length 79.7
  TOP w0.149: v1(124.39,97.03) 124.39,97.03 J1.79
  L12_SIG4 w0.089: v1(124.39,97.03) 124.19,97.23 124.16,97.23 123.83,97.56 123.17,97.56 123,97.73 120,97.73 119.65,97.39 119.32,97.39 117.93,96 117.93,95.19 117.71,94.97 116.9,94.97 116.76,94.83 116.76,94.07 116.2,93.51 116.2,92.48 116.38,92.3 116.38,91.93 116.43,91.88 116.43,91.63 115.87,91.07 115,91.07 114.53,90.6 114.17,90.6 111.32,87.75 111.32,86.81 112.35,85.78 112.35,85.26 112.51,85.1 112.51,82.84 112.34,82.67 112.34,81.36 112.73,80.76 112.73,78.07 arc(112.72,77.97) 112.69,77.88 arc(112.68,77.83) 112.67,77.78 arc(112.6,77.58) 112.43,77.46 arc(112.35,77.43) 112.28,77.38 111.79,76.89 arc(111.67,76.81) 111.53,76.78 arc(111.31,76.7) 111.18,76.5 arc(111.13,76.41) 111.04,76.36 arc(110.89,76.33) 110.74,76.32 arc(110.68,76.32) 110.62,76.3 arc(110.56,76.29) 110.5,76.28 arc(110.35,76.25) 110.23,76.16 arc(109.95,76.03) 109.68,76.15 arc(109.37,76.33) 109.01,76.3 arc(108.97,76.29) 108.93,76.28 108.91,76.28 arc(108.76,76.25) 108.63,76.16 arc(108.35,76.03) 108.08,76.16 arc(107.95,76.25) 107.8,76.28 arc(107.74,76.29) 107.68,76.3 arc(107.55,76.32) 107.42,76.3 arc(107.38,76.29) 107.33,76.28 107.32,76.28 arc(107.16,76.25) 107.04,76.16 arc(106.74,76.04) 106.46,76.19 arc(106.37,76.28) 106.25,76.33 arc(105.84,76.49) 105.49,76.75 arc(105.46,76.79) 105.42,76.83 arc(105.3,76.92) 105.16,76.96 arc(104.84,77.15) 104.85,77.52 arc(104.9,77.66) 104.89,77.81 arc(104.86,77.92) 104.84,78.03 arc(104.83,78.07) 104.82,78.11 arc(104.79,78.24) 104.82,78.37 arc(104.87,78.59) 104.9,78.81 arc(104.89,78.86) 104.88,78.9 arc(104.77,79.06) 104.62,79.16 arc(104.58,79.18) 104.53,79.18 104.34,79.18 arc(104.08,79.07) 103.97,78.81 103.97,76.19 arc(103.95,75.96) 103.91,75.73 arc(103.89,75.65) 103.9,75.56 arc(103.87,75.33) 103.69,75.17 arc(103.61,75.13) 103.55,75.08 arc(103.51,75.04) 103.48,75 arc(103.37,74.92) 103.25,74.88 arc(103.14,74.84) 103.05,74.77 arc(102.78,74.65) 102.51,74.76 arc(102.4,74.84) 102.28,74.87 arc(102.21,74.88) 102.14,74.91 arc(101.98,74.94) 101.82,74.91 arc(101.75,74.88) 101.68,74.87 arc(101.56,74.84) 101.45,74.76 arc(101.18,74.65) 100.92,74.76 arc(100.81,74.84) 100.68,74.87 arc(100.61,74.88) 100.55,74.91 arc(100.38,74.94) 100.21,74.9 arc(100.2,74.9) 100.2,74.9 arc(100.03,74.46) 100.43,74.2 arc(100.48,74.19) 100.51,74.15 arc(100.58,74.08) 100.67,74.06 arc(100.77,74.03) 100.84,73.95 arc(101.15,73.74) 101.49,73.9 arc(101.62,74.01) 101.8,74.06 102.16,74.06 arc(102.33,74.01) 102.47,73.9 102.63,73.66 arc(102.72,73.57) 102.84,73.52 arc(103,73.44) 103.09,73.29 arc(103.14,73.22) 103.21,73.18 arc(103.34,73.15) 103.47,73.14 arc(103.81,73.1) 104.12,72.95 arc(104.14,72.94) 104.16,72.93 arc(104.18,72.91) 104.2,72.9 arc(104.26,72.85) 104.32,72.79 104.44,72.67 arc(104.48,72.64) 104.54,72.6 arc(104.63,72.53) 104.7,72.44 arc(104.73,72.38) 104.77,72.34 104.93,72.18 arc(105.01,72.14) 105.09,72.14 arc(105.23,72.14) 105.36,72.09 arc(105.45,72.04) 105.54,72.03 arc(105.65,72.01) 105.74,71.97 arc(105.96,71.89) 106.18,71.96 arc(106.28,72.01) 106.38,72.03 arc(106.48,72.04) 106.57,72.09 arc(106.92,72.18) 107.24,72.02 arc(107.28,71.99) 107.33,71.97 arc(107.34,71.96) 107.36,71.95 arc(107.51,71.9) 107.67,71.91 arc(107.77,71.94) 107.88,71.95 arc(108.01,71.97) 108.11,72.05 arc(108.35,72.15) 108.59,72.05 arc(108.7,71.97) 108.83,71.95 arc(108.93,71.94) 109.03,71.91 arc(109.15,71.89) 109.27,71.91 arc(109.37,71.94) 109.47,71.95 arc(109.6,71.97) 109.71,72.05 arc(109.95,72.15) 110.19,72.05 arc(110.3,71.97) 110.43,71.95 110.5,71.95 arc(110.55,71.94) 110.59,71.93 arc(110.64,71.91) 110.69,71.9 arc(110.89,71.87) 111.09,71.86 arc(111.18,71.89) 111.24,71.96 arc(111.54,72.15) 111.84,71.96 arc(111.9,71.89) 111.99,71.86 112.59,71.86 arc(112.74,71.9) 112.86,72.01 arc(113.16,72.14) 113.44,71.96 arc(113.5,71.89) 113.59,71.86 arc(113.67,71.87) 113.76,71.89 arc(113.82,71.9) 113.89,71.9 arc(114.16,71.97) 114.3,72.2 arc(114.36,72.32) 114.48,72.36 114.61,72.36 arc(114.65,72.36) 114.7,72.36 arc(114.74,72.35) 114.79,72.36 114.95,72.36 115.08,72.23 arc(115.14,72.15) 115.16,72.05 arc(115.2,71.91) 115.27,71.79 arc(115.35,71.73) 115.46,71.72 arc(115.63,71.71) 115.79,71.62 arc(115.91,71.54) 116.05,71.51 116.1,71.51 arc(116.15,71.51) 116.21,71.49 arc(116.26,71.48) 116.3,71.47 116.42,71.47 arc(116.51,71.46) 116.6,71.44 arc(116.7,71.39) 116.75,71.29 arc(116.97,71.01) 117.33,71.04 117.61,71.23 arc(117.75,71.3) 117.9,71.34 arc(118.22,71.5) 118.35,71.84 arc(118.33,71.94) 118.27,72.02 118.06,72.24 arc(118.02,72.26) 117.97,72.27 arc(117.8,72.22) 117.66,72.12 117.54,72 arc(117.33,71.88) 117.09,71.89 arc(117.07,71.9) 117.05,71.9 arc(116.9,71.96) 116.8,72.07 arc(116.73,72.17) 116.66,72.25 arc(116.52,72.34) 116.36,72.36 arc(116.07,72.45) 115.95,72.73 115.95,73.03 arc(115.96,73.08) 116,73.11 116.92,73.47 116.93,73.47 116.98,73.53 117.13,73.53 117.3,73.53 arc(117.32,73.53) 117.34,73.53 117.63,73.53 arc(117.79,73.56) v1(117.91,73.65)
DDR4_DDIMM2_A1: length 78.5
  TOP w0.149: v1(135.43,96.15) 135.44,96.16 J1.72
  L07_SIG3 w0.089: v1(135.43,96.15) 136.1,96.15 136.19,96.24 136.19,96.53 136.28,96.62 136.44,96.62 136.53,96.53 136.53,96.24 136.62,96.15 136.79,96.15 136.88,96.24 136.88,96.53 136.96,96.62 137.13,96.62 137.22,96.53 137.22,96.24 137.31,96.15 137.47,96.15 137.56,96.24 137.56,96.53 137.65,96.62 137.81,96.62 137.9,96.53 137.9,96.24 137.99,96.15 138.16,96.15 138.25,96.24 138.25,96.53 138.34,96.62 138.5,96.62 138.59,96.53 138.59,96.24 138.68,96.15 139.08,96.15 139.17,96.24 139.17,96.84 139.26,96.93 139.42,96.93 139.51,96.84 139.51,96.24 139.6,96.15 139.77,96.15 139.85,96.24 139.85,96.84 139.94,96.93 140.11,96.93 140.2,96.84 140.2,96.24 140.29,96.15 140.45,96.15 140.54,96.24 140.54,96.84 140.63,96.93 140.79,96.93 140.88,96.84 140.88,96.24 140.97,96.15 141.14,96.15 141.23,96.24 141.23,96.84 141.32,96.93 141.48,96.93 141.57,96.84 141.57,96.24 141.66,96.15 141.82,96.15 141.91,96.24 141.91,96.84 142,96.93 142.17,96.93 142.25,96.84 142.25,96.24 142.34,96.15 142.64,96.15 142.78,96.29 142.78,97.2 142.62,97.36 139.13,97.36 138.73,96.97 135.81,96.97 135.47,96.63 133.49,96.63 133.4,96.55 133.4,96.42 134.1,95.72 134.1,95.59 133.99,95.48 133.86,95.48 133.15,96.19 132.95,96.19 132.86,96.09 132.86,95.97 133.48,95.34 133.48,95.22 133.37,95.1 133.24,95.1 132.63,95.71 132.47,95.71 132.35,95.59 132.35,95.47 132.69,95.13 132.69,95 132.57,94.89 132.44,94.89 132.11,95.22 131.98,95.22 131.86,95.09 130.14,95.09 129.83,94.78 129.83,94.65 130.09,94.39 130.09,94.26 129.97,94.14 129.85,94.14 129.58,94.41 129.46,94.41 128.95,93.9 128.95,93.77 129.2,93.52 129.2,93.39 129.09,93.28 128.96,93.28 128.71,93.53 128.58,93.53 128.46,93.41 128.46,93.29 128.72,93.03 128.72,92.91 128.6,92.79 128.48,92.79 128.22,93.05 128.1,93.05 127.98,92.93 127.98,92.8 128.23,92.55 128.23,92.42 128.12,92.31 127.99,92.31 127.74,92.56 127.61,92.56 127.49,92.44 127.49,92.32 127.75,92.06 127.75,91.94 127.63,91.82 127.51,91.82 127.25,92.08 127.13,92.08 127.01,91.96 127.01,91.83 127.26,91.58 127.26,91.45 127.15,91.34 127.02,91.34 126.77,91.59 126.64,91.59 126.52,91.47 126.52,91.35 126.78,91.09 126.78,90.97 126.66,90.85 126.54,90.85 126.28,91.11 126.16,91.11 126.04,90.99 126.04,90.86 126.29,90.61 126.29,90.48 126.18,90.37 126.05,90.37 125.8,90.62 125.67,90.62 125.55,90.5 125.55,90.38 125.81,90.12 125.81,90 125.69,89.88 125.57,89.88 125.31,90.14 125.19,90.14 124.47,89.42 124.47,89.3 124.7,89.07 124.7,88.94 124.59,88.83 124.46,88.83 124.23,89.06 124.11,89.06 123.99,88.94 123.99,88.81 124.22,88.58 124.22,88.46 124.1,88.34 123.98,88.34 123.75,88.57 123.62,88.57 123.5,88.45 123.5,88.33 123.73,88.1 123.73,87.97 123.62,87.86 123.49,87.86 123.26,88.09 123.14,88.09 123.02,87.97 123.02,87.84 123.25,87.61 123.25,87.49 123.13,87.37 123.01,87.37 122.78,87.6 122.65,87.6 122.53,87.48 122.53,87.36 122.76,87.13 122.76,87 122.65,86.89 122.52,86.89 122.29,87.12 122.17,87.12 122.05,87 122.05,86.87 122.28,86.64 122.28,86.52 122.16,86.4 122.04,86.4 121.81,86.63 121.68,86.63 121.54,86.49 121.54,85.89 121.36,85.72 121.03,85.72 120.69,85.37 120.69,83.77 121.01,83.44 121.01,81.77 120.63,81.38 120.63,80.96 120.73,80.85 120.73,76.76 120.42,76.45 120.08,76.45 119.66,76.03 119.58,76.03 119.13,75.58 119.13,74.91 118.87,74.65 118.74,74.65 118.71,74.63 v1(118.71,74.11)
DDR4_DDIMM2_A2: length 81.1
  TOP w0.149: J1.216 135.44,92.78 v1(135.52,92.7)
  L07_SIG3 w0.089: v1(117.92,72.73) 118.31,73.42 arc(118.48,73.59) 118.71,73.65 118.72,73.65 arc(118.94,73.59) 119.11,73.42 arc(119.28,73.25) 119.5,73.19 119.51,73.19 arc(119.73,73.13) 119.9,72.97 119.92,72.94 arc(120.08,72.79) 120.31,72.73 120.32,72.73 arc(120.54,72.66) 120.7,72.5 arc(120.87,72.33) 121.09,72.27 121.28,72.27 121.77,72.76 122.02,72.76 122.31,73.05 122.7,73.19 arc(122.92,73.25) 123.09,73.42 123.27,73.59 123.59,73.59 123.96,73.22 124.44,73.22 124.7,73.48 124.7,85.09 125.65,86.03 125.77,86.03 126.48,85.32 126.61,85.32 126.73,85.44 126.73,85.56 126.01,86.27 126.01,86.4 126.13,86.52 126.26,86.52 126.97,85.81 127.09,85.81 127.21,85.92 127.21,86.05 126.5,86.76 126.5,86.89 126.62,87 126.74,87 127.45,86.29 127.58,86.29 127.7,86.41 127.7,86.53 126.98,87.24 126.98,87.37 127.1,87.49 127.23,87.49 127.94,86.78 128.06,86.78 128.18,86.89 128.18,87.02 127.47,87.73 127.47,87.86 127.59,87.97 127.71,87.97 128.42,87.26 128.55,87.26 128.67,87.38 128.67,87.5 127.95,88.21 127.95,88.34 129.11,89.5 129.24,89.5 129.92,88.81 130.05,88.81 130.16,88.93 130.16,89.05 129.48,89.74 129.48,89.86 129.6,89.98 129.72,89.98 130.4,89.3 130.53,89.3 130.65,89.41 130.65,89.54 129.96,90.22 129.96,90.35 130.08,90.47 130.21,90.47 130.89,89.78 131.02,89.78 131.13,89.9 131.13,90.02 130.45,90.71 130.45,90.83 130.57,90.95 130.69,90.95 131.37,90.27 131.5,90.27 131.62,90.38 131.62,90.51 130.93,91.19 130.93,91.32 131.21,91.59 148.63,91.59 148.72,91.68 148.72,91.88 148.62,91.98 137.14,91.98 136.42,92.7 v1(135.52,92.7)
DDR4_DDIMM2_A3: length 80.1
  L05_SIG2 w0.081: v1(136.28,98.1) 136.28,96.77 136.54,96.51 139.21,96.51 139.29,96.59 139.29,97.81 139.37,97.89 139.55,97.89 139.63,97.81 139.63,96.59 139.71,96.51 139.88,96.51 139.96,96.59 139.96,97.81 140.04,97.89 140.22,97.89 140.3,97.81 140.3,96.59 140.38,96.51 140.55,96.51 140.63,96.59 140.63,97.81 140.71,97.89 140.89,97.89 140.97,97.81 140.97,96.59 141.05,96.51 141.22,96.51 141.3,96.59 141.3,97.81 141.39,97.89 141.56,97.89 141.64,97.81 141.64,96.59 141.72,96.51 141.89,96.51 141.97,96.59 141.97,97.81 142.06,97.89 142.23,97.89 142.31,97.81 142.31,96.59 142.39,96.51 143.3,96.51 143.44,96.37 143.44,96.13 143.29,95.97 142.47,95.97 142.39,95.89 142.39,95.41 142.31,95.33 142.14,95.33 142.06,95.41 142.06,95.89 141.98,95.97 141.8,95.97 141.72,95.89 141.72,95.41 141.64,95.33 141.47,95.33 141.39,95.41 141.39,95.89 141.3,95.97 141.13,95.97 141.05,95.89 141.05,95.41 140.97,95.33 140.8,95.33 140.72,95.41 140.72,95.89 140.63,95.97 140.46,95.97 140.38,95.89 140.38,95.41 140.3,95.33 140.13,95.33 140.04,95.41 140.04,95.89 139.96,95.97 139.79,95.97 139.71,95.89 139.71,95.41 139.63,95.33 139.46,95.33 139.37,95.41 139.37,95.89 139.29,95.97 138.05,95.97 137.97,95.89 137.97,95.41 137.89,95.33 137.71,95.33 137.63,95.41 137.63,95.89 137.55,95.97 137.38,95.97 137.3,95.89 137.3,95.41 137.22,95.33 137.04,95.33 136.96,95.41 136.96,95.89 136.88,95.97 136.07,95.97 134.92,94.82 134.43,94.82 134.2,94.59 134.2,94.1 133.31,93.21 133.31,92.81 130.57,90.08 130.57,86.8 130.16,86.4 130.16,84.83 131.07,83.93 131.07,79.7 131.86,78.91 131.86,78.48 131.86,78.48 arc(131.8,78.25) 131.86,78.02 arc(131.92,77.79) 131.86,77.56 131.86,77.56 arc(131.8,77.33) 131.86,77.1 arc(131.92,76.88) 131.87,76.66 131.86,76.63 arc(131.8,76.41) 131.86,76.18 arc(131.92,75.95) 131.86,75.72 131.86,75.72 arc(131.8,75.49) 131.86,75.26 131.86,75.26 arc(131.92,75.03) 131.86,74.8 131.86,74.79 arc(131.8,74.57) 131.86,74.34 arc(131.92,74.11) 131.86,73.88 131.86,73.88 arc(131.8,73.65) 131.86,73.42 arc(131.92,73.19) 131.86,72.96 131.86,72.95 arc(131.8,72.73) 131.86,72.5 arc(131.92,72.27) 131.86,72.04 131.86,72.04 arc(131.69,71.87) 131.46,71.81 131.46,71.81 arc(131.23,71.75) 131.06,71.58 arc(130.9,71.41) 130.67,71.35 130.66,71.35 arc(130.44,71.29) 130.27,71.12 130.27,71.12 arc(130.1,70.95) 129.88,70.89 129.87,70.89 arc(129.64,70.83) 129.47,70.66 129.47,70.65 arc(129.3,70.49) 129.07,70.43 129.06,70.43 arc(128.84,70.36) 128.67,70.2 arc(128.51,70.03) 128.28,69.97 128.27,69.97 arc(128.05,69.91) 127.88,69.75 127.87,69.73 arc(127.7,69.57) 127.48,69.51 127.47,69.51 arc(127.24,69.57) 127.08,69.74 arc(127.05,69.79) 127.01,69.83 126.75,69.83 126.12,70.46 124.07,70.46 123.96,70.56 arc(123.92,70.61) 123.89,70.66 arc(123.72,70.83) 123.49,70.89 123.49,70.89 arc(123.27,70.83) 123.1,70.67 123.09,70.65 arc(122.92,70.49) 122.7,70.43 122.68,70.43 arc(122.46,70.49) 122.3,70.66 arc(122.13,70.83) 121.9,70.89 arc(121.68,70.95) 121.51,71.11 121.5,71.12 arc(121.33,71.29) 121.1,71.35 121.09,71.35 arc(120.87,71.41) 120.7,71.58 arc(120.54,71.74) 120.32,71.81 120.31,71.81 arc(120.08,71.87) 119.92,72.02 119.9,72.05 arc(119.73,72.21) 119.51,72.27 v1(118.71,72.27)
DDR4_DDIMM2_A4: length 82.2
  BOTTOM w0.149: v1(117.12,74.11) 117.92,74.11 arc(118.14,74.17) 118.3,74.32 118.32,74.35 arc(118.49,74.51) 118.71,74.57 arc(118.94,74.63) 119.11,74.8 119.11,74.81 arc(119.28,74.97) 119.51,75.03 119.52,75.03 arc(119.74,75.09) 119.91,75.26 arc(119.97,75.48) 119.92,75.7 119.91,75.72 arc(119.85,75.95) 119.91,76.18 119.92,76.19 arc(119.97,76.42) 119.91,76.64 arc(119.85,76.86) 119.9,77.08 119.91,77.1 arc(119.97,77.33) 119.91,77.56 119.91,77.56 arc(119.85,77.79) 119.91,78.02 arc(119.97,78.25) 119.91,78.48 119.91,78.48 arc(119.85,78.71) 119.91,78.94 arc(119.97,79.17) 119.91,79.4 119.91,79.4 arc(119.85,79.63) 119.91,79.86 arc(119.97,80.09) 119.91,80.31 119.89,80.35 arc(119.85,80.57) 119.91,80.78 arc(119.96,80.92) 119.97,81.06 120.47,81.57 121.22,81.57 121.36,81.72 121.36,83.05 121.51,83.2 121.81,83.2 121.96,83.05 121.96,81.72 122.11,81.57 122.67,81.57 123.02,81.92 123.02,83.26 122.82,83.46 122.82,83.68 122.67,83.83 121.91,83.83 121.76,83.98 121.76,84.27 121.91,84.42 122.67,84.42 122.82,84.57 122.82,84.87 122.67,85.02 121.91,85.02 121.76,85.17 121.76,85.46 121.91,85.61 122.67,85.61 122.82,85.76 122.82,86.06 122.67,86.21 121.91,86.21 121.76,86.35 121.76,86.65 121.91,86.8 123.24,86.8 124.43,87.98 124.43,89.75 124.75,90.07 125.44,90.07 125.59,89.92 125.59,86.43 125.74,86.28 126.03,86.28 126.18,86.43 126.18,89.92 126.33,90.07 126.63,90.07 126.78,89.92 126.78,86.43 126.93,86.28 127.22,86.28 127.37,86.43 127.37,89.92 127.52,90.07 127.82,90.07 127.97,89.92 127.97,85.58 128.11,85.43 128.41,85.43 128.56,85.58 128.56,89.92 128.71,90.07 135.26,90.07 135.44,90.25 143.67,90.25 143.82,90.4 143.82,91.56 143.51,91.87 137.29,91.87 137.14,92.02 v1(137.14,93.34)
DDR4_DDIMM2_A5: length 82.1
  BOTTOM w0.149: v1(137.99,93.34) 137.59,93.75 136.98,93.75 136.41,93.18 136.41,91.7 136.64,91.47 142.89,91.47 143.07,91.29 143.07,90.9 142.92,90.75 137.56,90.75 137.38,90.93 137.16,90.93 136.98,90.75 135.52,90.75 135.35,90.58 135.1,90.58 134.95,90.73 134.95,91.1 134.81,91.25 134.51,91.25 134.36,91.1 134.36,90.57 134.21,90.42 124.43,90.42 123.54,89.53 123.19,89.53 122.49,90.23 122.28,90.23 122.07,90.02 122.07,89.81 122.49,89.4 122.49,89.19 122.17,88.87 122.17,88.66 122.38,88.45 122.69,88.45 123.1,88.87 123.7,88.87 123.93,88.64 123.93,88.12 123.11,87.31 122.74,87.31 122.19,87.86 121.98,87.86 121.45,87.33 121.24,87.33 121.03,87.54 121.03,87.75 121.56,88.28 121.56,88.49 121.21,88.84 121.21,89.27 121.52,89.58 121.52,89.79 121.31,90 121.1,90 120.79,89.69 120.58,89.69 120.23,90.05 120.02,90.05 119.81,89.84 119.81,89.63 120.63,88.8 120.63,88.59 120.47,88.42 120.47,87.95 120.32,87.8 119.62,87.8 119.47,87.95 119.47,88.96 119.32,89.11 119.02,89.11 118.87,88.96 118.87,87.95 118.73,87.8 118.04,87.8 117.89,87.66 117.89,87.36 118.04,87.21 118.35,87.21 118.5,87.06 118.5,86.8 118.64,86.65 118.94,86.65 119.09,86.8 119.09,87.06 119.24,87.21 120.32,87.21 120.55,86.98 120.55,86.65 120.32,86.43 119.81,86.43 119.66,86.28 119.66,85.98 119.81,85.83 120.32,85.83 120.47,85.68 120.47,85.39 120.32,85.24 119.81,85.24 119.66,85.09 119.66,84.79 119.81,84.64 120.82,84.64 121.02,84.45 121.02,84.14 120.87,83.99 120.36,83.99 120.14,83.77 120.14,83.26 120,83.13 119.52,83.13 119.32,83.33 119.32,84.31 119.12,84.51 118.82,84.51 118.67,84.36 118.67,82.68 118.82,82.53 119.73,82.53 119.88,82.38 119.88,82.18 119.16,81.46 119.16,81.36 arc(119.15,81.31) 119.13,81.27 119.11,81.23 arc(119.05,81) 119.11,80.78 119.13,80.75 arc(119.17,80.53) 119.11,80.32 119.11,80.31 arc(119.05,80.09) 119.11,79.86 arc(119.17,79.63) 119.11,79.4 119.11,79.4 arc(119.05,79.17) 119.11,78.94 arc(119.17,78.71) 119.11,78.48 119.11,78.48 arc(119.05,78.25) 119.11,78.02 arc(119.17,77.79) 119.11,77.56 119.11,77.56 arc(119.05,77.33) 119.11,77.1 arc(119.17,76.88) 119.12,76.66 119.1,76.62 arc(119.05,76.4) 119.11,76.18 arc(119.17,75.95) 119.11,75.72 119.11,75.72 arc(118.95,75.56) 118.73,75.49 118.71,75.49 arc(118.48,75.43) 118.31,75.26 arc(118.15,75.09) 117.92,75.03 117.92,75.03 arc(117.69,74.97) 117.52,74.81 117.52,74.8 arc(117.35,74.63) 117.12,74.57 arc(116.9,74.51) 116.73,74.36 v1(116.32,73.65)
DDR4_DDIMM2_A6: length 81
  L07_SIG3 w0.089: v1(117.12,72.27) 117.12,72.59 117.51,72.98 117.51,81.21 118.34,82.04 118.34,82.26 118.25,82.35 117.77,82.35 117.68,82.44 117.68,82.6 117.77,82.69 118.25,82.69 118.34,82.78 118.34,83.81 118.2,83.95 117.72,83.95 117.63,84.04 117.63,84.2 117.72,84.29 118.25,84.29 118.34,84.38 118.34,86.69 118.43,86.78 118.95,86.78 119.04,86.86 119.04,87.03 118.95,87.12 118.43,87.12 118.34,87.21 118.34,87.37 118.43,87.46 118.95,87.46 119.04,87.55 119.04,87.71 118.95,87.8 118.43,87.8 118.34,87.89 118.34,88.11 118.59,88.37 119.41,88.37 119.87,88.83 119.87,91.61 119.55,91.93 119.55,92.17 118.8,92.93 118.33,92.93 118.07,93.19 118.07,93.96 118.16,94.05 118.4,94.05 118.49,94.14 118.49,94.3 118.4,94.39 118.16,94.39 118.07,94.48 118.07,94.64 118.16,94.73 118.4,94.73 118.49,94.82 118.49,94.99 118.4,95.08 118.16,95.08 118.07,95.16 118.07,95.41 118.16,95.49 118.73,95.49 118.88,95.35 118.88,95 119,94.87 119.82,94.87 119.91,94.96 119.91,95.39 120,95.48 120.16,95.48 120.25,95.39 120.25,94.96 120.34,94.87 120.5,94.87 120.59,94.96 120.59,95.39 120.68,95.48 120.85,95.48 120.94,95.39 120.94,94.96 121.03,94.87 121.32,94.87 121.41,94.78 121.41,94.21 121.32,94.13 121.07,94.13 120.98,94.04 120.98,93.69 120.9,93.6 120.73,93.6 120.64,93.69 120.64,94.04 120.55,94.13 119.9,94.13 119.67,93.89 119.67,93.03 119.93,92.77 122.09,92.77 122.5,92.36 123.41,92.36 124.84,93.79 124.84,95.08 124.93,95.17 125.53,95.17 125.62,95.25 125.62,95.42 125.53,95.51 124.93,95.51 124.84,95.6 124.84,95.76 124.93,95.85 125.53,95.85 125.62,95.94 125.62,96.11 125.53,96.19 124.93,96.19 124.84,96.28 124.84,96.45 124.93,96.54 125.53,96.54 125.62,96.63 125.62,96.79 125.53,96.88 124.93,96.88 124.84,96.97 124.84,97.13 124.93,97.22 125.53,97.22 125.62,97.31 125.62,97.48 125.53,97.57 124.93,97.57 124.84,97.66 124.84,97.82 124.93,97.91 125.53,97.91 125.62,98 125.62,98.16 125.53,98.25 124.93,98.25 124.84,98.34 124.84,98.81 125.08,99.05 126.16,99.05 126.25,98.96 126.25,98.31 126.34,98.22 126.5,98.22 126.59,98.31 126.59,98.96 126.68,99.05 126.85,99.05 126.94,98.96 126.94,98.31 127.02,98.22 127.19,98.22 127.28,98.31 127.28,98.96 127.37,99.05 127.53,99.05 127.62,98.96 127.62,98.31 127.71,98.22 127.87,98.22 127.96,98.31 127.96,98.96 128.05,99.05 128.22,99.05 128.31,98.96 128.31,98.31 128.4,98.22 128.56,98.22 128.65,98.31 128.65,98.96 128.74,99.05 128.9,99.05 128.99,98.96 128.99,98.31 129.08,98.22 129.25,98.22 129.34,98.31 129.34,98.96 129.42,99.05 129.86,99.05 130.26,98.64 131.23,98.64 131.77,98.11 134.85,98.11 136.09,99.34 v1(137.99,99.34)
DDR4_DDIMM2_A7: length 82.2
  L07_SIG3 w0.089: v1(139.79,93.34) 139.79,92.61 140.14,92.27 148.01,92.27 148.59,92.84 148.59,94.96 148.88,95.25 149.35,95.25 149.44,95.16 149.44,94.27 149.53,94.18 149.7,94.18 149.78,94.27 149.78,95.16 149.87,95.25 150.04,95.25 150.13,95.16 150.13,94.27 150.22,94.18 150.38,94.18 150.47,94.27 150.47,95.16 150.56,95.25 150.9,95.25 151.15,95 151.15,94.13 151.27,94.01 151.27,93.72 151.18,93.63 149.55,93.63 149.46,93.54 149.46,93.38 149.55,93.29 151.18,93.29 151.27,93.2 151.27,93.03 151.18,92.94 149.55,92.94 149.46,92.85 149.46,92.69 149.55,92.6 151.18,92.6 151.27,92.51 151.27,91.99 151.07,91.78 151.07,91.78 150.83,91.55 150.83,91.55 150.61,91.33 133.14,91.33 126.19,84.38 126.07,84.38 125.74,84.7 125.61,84.7 125.5,84.59 125.5,84.46 125.82,84.14 125.82,84.01 125.71,83.89 125.58,83.89 125.26,84.22 125.13,84.22 125.01,84.1 125.01,83.98 125.34,83.65 125.34,83.53 125.2,83.39 125.2,83 125.2,81.72 125.47,81.45 125.47,73.07 125.21,72.82 125.06,72.82 124.59,72.35 124.01,72.35 123.62,72.75 arc(123.56,72.73) 123.51,72.73 123.49,72.73 arc(123.27,72.67) 123.1,72.51 123.09,72.49 arc(122.92,72.33) 122.7,72.27 122.68,72.27 arc(122.46,72.2) 122.3,72.04 arc(122.13,71.87) 121.91,71.81 121.9,71.81 arc(121.68,71.75) 121.51,71.59 121.5,71.58 arc(121.33,71.41) 121.1,71.35 121.09,71.35 arc(120.87,71.41) 120.7,71.58 arc(120.54,71.74) 120.32,71.81 120.31,71.81 arc(120.08,71.87) 119.92,72.02 119.9,72.05 arc(119.73,72.21) 119.51,72.27 119.49,72.27 arc(119.27,72.34) 119.11,72.5 arc(118.95,72.66) 118.73,72.73 118.71,72.73 arc(118.49,72.67) 118.32,72.51 118.3,72.48 arc(118.14,72.33) 117.92,72.27 117.9,72.27 117.46,71.84 116.97,71.84 116.32,72.48 v1(116.32,72.73)
