# Allegro board FM85_AGILEX_PCIE_DK_CMC_ADI_REVC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N31415897: length 1.8
  TOP w0.254: Q13.4 R483.1
N31415950: length 3.5
  TOP w0.254: R483.2 C581.1 215.84,87.26 215.36,87.75 U48.1
N31416024: length 8.4
  TOP w0.381: v1(212.22,89.74) 212.22,88.6 211.03,87.41 211.03,86.27 211.41,85.89 212.15,85.89 212.56,85.48 v1(212.61,85.48) 213.41,84.68 U48.5
  BOTTOM w0.381: R485.2 v1(212.61,85.48)
N31416063: length 1.5
  TOP w0.381: v1(214,85.36) 214,85.23 214.06,85.17 U48.6
N31416065: length 2.7
  BOTTOM w0.149: R487.2 R488.1 C587.1 R489.2
N31416086: length 2.5
  BOTTOM w0.149: R489.1 215.65,91.26 214.83,90.44 Q14.1
N31558092:
  vias: v1(95.74,25.74)
N31558448:
  vias: v1(116.06,25.74)
N31558945:
  vias: v1(85.58,25.74)
N31559300:
  vias: v1(105.9,25.74)
N31559457:
  vias: v1(169.91,25.66)
N32052935: length 3.1
  TOP w0.254: EU1.2 70.71,80.99 70.13,81.57 C563.1 69.06,81.57 R454.1
N32053041: length 2.9
  TOP w0.254: EU1.3 70.14,80.49 C563.2 68.93,80.69 R455.1
N32230321: length 18.5
  TOP w0.381: v1(231.2,86.21) 231.2,85.7 U45.4
  BOTTOM w0.254: 240.56,77.92 U47.5
  BOTTOM w0.381: v1(231.2,86.21) 232.19,87.2 233.94,87.2 235.08,86.06 236.74,86.06 238.01,84.79 238.01,83.26 238.77,82.5 238.77,79.2 239.21,78.76 R480.1 240.42,78.06 240.56,77.92
N32230341: length 2.8
  BOTTOM w0.254: U47.3 241.06,74.38 240.74,74.06 R479.2 R484.2
N32230392: length 2.7
  BOTTOM w0.254: R484.1 R486.1 241.56,73.43 U47.2
N32230759: length 2.5
  TOP w0.254: U44.4 227.98,92.02 227.59,92.41 226.93,92.41 226.8,92.27 U46.3
N32232827: length 0.8
  BOTTOM w0.254: v1(211.47,72.89) 211.47,72.89 211.31,72.72 U51.3
N32233406: length 4
  BOTTOM w0.254: U52.5 R493.1 211.48,79.13 v1(211.47,79.11)
N32233436: length 2.3
  BOTTOM w0.254: R492.2 R496.2 214.32,83.45 214.12,83.65 U52.3
N32233467: length 3.4
  BOTTOM w0.254: U52.8 211.27,84.65 210.76,85.16 R491.2 R495.1
N32233496: length 2.4
  BOTTOM w0.254: U52.2 214.12,84.15 214.32,84.34 R496.1 214.76,85.23 R497.1
N32233958: length 3.3
  BOTTOM w0.254: R501.1 244.74,78.3 SW6.4
N32406903: length 3.8
  BOTTOM w0.254: SW6.6 245.04,70.5 R503.1
N32408103: length 2.7
  BOTTOM w0.254: R482.1 R478.2 242.2,77.55 242.06,77.41 U47.8
N32408438: length 3.2
  TOP w0.254: R500.2 240.61,79.07 R502.2 240.61,77.1 240.86,76.85 U53.3
N32408441: length 2.7
  TOP w0.254: R505.1 239.72,79.07 R502.1 239.72,77.1 239.46,76.85 U53.4
N33771526: length 5.2
  BOTTOM w0.149: v1(251.7,45.82) 250.92,45.04 R358.2 250.26,44.72 250.07,44.53 247.61,44.53 Q8.3
N33771550:
  vias: v1(250.27,45.93)
N34054433:
  vias: v1(250.26,44.02)
N34315909: length 1
  BOTTOM w0.149: R368.2 246.96,66.25 C491.2
N34315982: length 1
  BOTTOM w0.149: C492.2 246.83,62.18 R369.2
N34474357: length 1.3
  BOTTOM w0.149: U27.2 18.11,105.25 v1(17.62,105.74)
N34474360: length 1.3
  BOTTOM w0.149: v1(18.49,105.92) 18.51,105.89 U27.3
N36112579: length 5.6
  BOTTOM w0.149: R207.2 13.22,88.41 13.22,85.55 12.96,85.3 SW2.6
N36112582: length 6
  BOTTOM w0.149: SW2.7 13.22,84.03 13.6,84.41 13.6,87.77 R206.2
N36112585: length 6.2
  BOTTOM w0.149: SW2.8 13.22,82.76 13.95,83.49 13.95,87.11 R204.2
N36226098: length 1
  BOTTOM w0.149: R370.2 246.01,58.05 C493.2
N36270051: length 1.1
  TOP w0.149: U28.13 29.88,93.07 v1(29.85,93.04)
N36270054: length 1.2
  TOP w0.149: U28.12 29.23,93.31 v1(28.96,93.04)
N36270340: length 2.3
  BOTTOM w0.149: SW4.8 3.37,61.8 R320.2
N36315991: length 2
  TOP w0.149: U84.9 v1(45.83,27.63)
  L05_SIG2 w0.081: v1(47.22,28.04) 47.18,28.04 46.77,27.63 v1(45.83,27.63)
N36316045: length 4.8
  TOP w0.149: v1(46.45,25.83) 46.45,25.83 R816.2 45.89,26.63 U84.7
  BOTTOM w0.149: R817.1 47.72,25.5 46.78,25.5 v1(46.45,25.83)
N36316148: length 4.4
  TOP w0.191: U84.1 v1(42.31,28.58)
  BOTTOM w0.381: v1(42.31,28.58) 41.63,28.58 41.23,28.97 R819.1 40.48,29.15 C985.1 40.2,29.7 R820.1
N36316409: length 2.6
  TOP w0.254: U85.9 25.2,107.92 24.24,108.88 R821.2
N36316465: length 3.6
  TOP w0.254: R824.2 26.82,109.54 R822.2 R823.1 26.2,108.58 U85.7
N36316589: length 8.3
  TOP w0.191: U85.1 v1(24.25,104.18)
  TOP w0.508: v1(22.56,107.44) C998.1 v1(20.75,107.44)
  BOTTOM w0.381: v1(24.25,104.18) 23.72,104.18 23.34,104.56 23.34,106.66 v1(22.56,107.44) v1(20.75,107.44)
N36344563: length 1.6
  BOTTOM w0.149: SW3.5 13.84,79.25 R284.2
N36344586: length 1.6
  BOTTOM w0.149: SW3.6 13.86,77.98 R285.2
N36344607: length 1.6
  BOTTOM w0.149: SW3.7 13.86,76.71 R286.2
N36348634: length 4
  BOTTOM w0.254: U88.5 34.04,83.03 34.34,83.33 R837.1 35.5,83.33 36.08,82.76 36.46,82.76 36.75,82.46 U87.4
N36348657: length 1.7
  BOTTOM w0.254: R836.2 34.36,85.36 34.02,85.02 U88.4
N36348739: length 3
  BOTTOM w0.254: R840.2 R839.1 R838.1 32.02,81.94 U88.8
N36541668: length 0.4
  BOTTOM w0.149: R338.1 v1(2.45,69.5)
N36541743: length 1.9
  BOTTOM w0.149: v1(6.87,67.91) 6.97,67.81 R342.1
N36541790: length 1.9
  BOTTOM w0.149: R343.1 6.08,67.87 v1(6.04,67.91)
N36541991: length 2.7
  BOTTOM w0.149: v1(10.45,69.5) 10.58,69.63 R350.1
N36542034: length 2.3
  BOTTOM w0.149: v1(14.87,67.91) 15.96,66.82 R354.1
N36542055: length 2.3
  BOTTOM w0.149: R355.1 15.07,66.87 v1(14.04,67.91)
N36542312: length 19.1
  L07_SIG3 w0.089: v1(2.45,67.8) 3.44,68.78 3.44,70.69 7.37,74.63 16.86,74.63 v1(17.41,75.18)
N36542538: length 20
  L07_SIG3 w0.089: v1(6.87,69.39) 5.47,70.8 5.47,71.83 6.67,73.04 11.69,73.04 12.52,73.87 19.78,73.87 v1(21.09,75.18)
N36542543: length 22.8
  L07_SIG3 w0.089: v1(6.04,69.39) 7.15,68.28 10.04,68.28 11.06,69.29 11.06,70.56 13.47,72.98 22.57,72.98 v1(24.77,75.18)
N36542635: length 20.4
  L07_SIG3 w0.089: v1(23.81,69.5) 23.1,68.79 18.68,68.79 18.3,68.4 13.6,68.4 12.99,67.8 v1(10.45,67.8)
  BOTTOM w0.149: Q4.3 29.47,70.49 29.15,70.17 24.48,70.17 v1(23.81,69.5)
N36542846: length 16
  L07_SIG3 w0.089: v1(28.46,75.18) 26.34,75.18 21.93,70.77 17.74,70.77 16.36,69.39 v1(14.87,69.39)
N36542851: length 21.1
  L07_SIG3 w0.089: v1(14.04,69.39) 14.63,68.8 16.79,68.8 18.17,70.18 26.3,70.18 31.29,75.18 v1(32.27,75.18)
N37651435: length 1
  TOP w0.149: R159.2 C319.2
N37651438: length 0.9
  BOTTOM w0.17: C321.2 R160.2
N37651441: length 0.9
  TOP w0.17: C323.2 R161.2
N37651444: length 1
  BOTTOM w0.17: C324.2 R162.2
N37651447: length 0.9
  BOTTOM w0.17: R163.2 C325.2
N37651450: length 0.9
  TOP w0.149: C327.2 R164.2
N37651453: length 1
  BOTTOM w0.17: C329.2 R165.2
N37651456: length 1
  TOP w0.17: C330.2 R166.2
N37651459: length 1
  TOP w0.17: R167.2 C331.2
N37651462: length 1
  TOP w0.17: C333.2 R168.2
N37651465: length 0.8
  TOP w0.149: R169.2 C335.2
N37925832: length 1
  BOTTOM w0.381: C579.2 R480.2
N37926031: length 1.1
  BOTTOM w0.254: C589.2 212.37,79.54 R493.2
N39073276: length 0.6
  BOTTOM w0.381: v1(129.27,24.86) 129.36,24.77 R39.1
N39073371: length 0.6
  BOTTOM w0.381: R40.1 139.52,24.77 v1(139.43,24.86)
N39073461:
  vias: v1(129.27,25.66)
N39073464:
  vias: v1(139.43,25.66)
N39075525: length 0.6
  BOTTOM w0.381: v1(149.59,24.86) 149.68,24.77 R45.1
N39075684:
  vias: v1(159.75,24.9)
N39075769:
  vias: v1(149.59,25.66)
N39075772:
  vias: v1(159.75,25.7)
N39077807: length 1.8
  BOTTOM w0.149: C98.1 72.02,23.5 R35.1 R36.1
N39077887:
  vias: v1(75.39,24.93)
N39077990:
  vias: v1(70.59,28.93)
N39077991:
  vias: v1(74.59,28.13)
N39077992:
  vias: v1(70.59,27.33)
N39077993: length 0.6
  BOTTOM w0.149: v1(73.79,27.33) 73.79,27.33 R16.2
N39077994: length 2
  BOTTOM w0.149: R17.2 68.71,26.93 69.2,26.93 69.39,27.13 v1(69.79,27.33)
N39077995:
  vias: v1(74.59,27.33)
N39077996:
  vias: v1(70.59,26.53)
N39077997: length 0.6
  BOTTOM w0.149: v1(73.79,26.53) 73.77,26.51 R20.2
N39078014:
  vias: v1(69.79,25.73)
N39078018: length 0.6
  BOTTOM w0.149: R22.2 73.27,28.13 73.79,28.13 v1(73.79,28.13)
N39078019: length 0.6
  BOTTOM w0.149: v1(73.79,28.93) 73.74,28.98 R23.2
N39078023:
  vias: v1(75.39,25.73)
N40033287: length 5.5
  BOTTOM w0.149: R210.2 98.84,81.48 98.84,77.59 v1(99.29,77.14)
N40033916: length 12.4
  BOTTOM w0.203: R213.1 100.41,81.75 100.41,81.18 100.59,81.01 100.59,75.93 100.82,75.69 100.82,75.29 100.64,75.11 100.64,74.83 v1(100.39,74.57)
  BOTTOM w0.254: U21.1 101.74,84.98 101.04,84.27 R209.2 C392.1 R213.1
N40168095:
  vias: v1(133.05,57.55)
N40168098:
  vias: v1(132.26,58.01)
N40226134:
  vias: v1(97.56,67.14)
N40226137:
  vias: v1(96.69,67.64)
N40226161:
  vias: v1(96.69,56.64)
N40226164:
  vias: v1(97.56,56.14)
N40287496: length 5
  TOP w0.149: Y2.3 40.96,39.9 41.54,39.32 43.25,39.32 C455.1 43.64,39.31 U23.3
N40287524: length 3.5
  TOP w0.149: Y2.1 42.21,38.5 C464.1 43.75,38.81 U23.4
N40288703: length 3.2
  TOP w0.149: R258.2 45.18,35.16 46.03,35.16 46.64,35.76 U23.10
N40288707: length 3.7
  TOP w0.149: R261.2 44.7,35.69 45.98,35.69 46.14,35.84 U23.9
N40297214:
  vias: v1(100.39,55.25)
N40297218:
  vias: v1(99.59,54.79)
N40355462: length 4.9
  BOTTOM w0.149: SW2.5 12.33,88.53 R208.2
N40362320:
  vias: v1(51.78,13.16)
N40362341:
  vias: v1(51.78,14.46)
N40362434:
  vias: v1(47.25,13.46)
N40362458:
  vias: v1(48.55,13.46)
N40423539: length 1
  BOTTOM w0.149: v1(56.69,14.64) 57.49,14.64 R184.1
N40460971:
  vias: v1(132.26,63.53)
N40460975:
  vias: v1(133.05,63.07)
N40489939: length 2
  BOTTOM w0.149: U40.10 42.05,60.6 R444.2
N40492779: length 1.9
  BOTTOM w0.149: R457.2 251.85,54.84 U42.10
N40558736:
  vias: v1(48.34,18.81) v1(49.18,18.81)
N40558738: length 4.2
  TOP w0.149: R176.2 48.09,17.24 47.74,17.58 47.74,20.39 R172.1
  vias: v1(48.73,17.22)
N40558740: length 0.8
  TOP w0.149: R177.2 v1(48.78,16.02)
N40558777: length 5.3
  BOTTOM w0.149: U16.7 54.46,17.27 55.66,17.27 56.22,16.72 R174.2 56.71,17.11 56.95,17.35 58.11,17.35 R173.1
N40559506: length 3.4
  BOTTOM w0.149: R462.1 R467.2 30.49,53.8 31,54.31 31,55.03
N40559508: length 3.3
  BOTTOM w0.149: R463.1 R468.2 32.52,53.57 32.27,53.83 U43.2
N40559510: length 3.2
  BOTTOM w0.149: R464.1 R469.2 U43.1
N40559585: length 2.1
  BOTTOM w0.149: U43.7 R466.1
N40562266: length 1.6
  BOTTOM w0.254: 19.11,87.33 U14.32
  BOTTOM w0.356: C305.2 19.11,88.21 19.11,87.33
N40564050: length 12.8
  TOP w0.149: v1(49.66,82.12) 49.34,82.44 J3.8
  L07_SIG3 w0.089: v1(49.66,82.12) 48.94,82.84 48.93,82.84 48.7,83.08 48.7,83.09 48.56,83.23 44.54,83.23 43.63,84.14 v1(43.63,87.71)
  BOTTOM w0.149: R121.1 v1(43.63,87.71)
N40564634: length 8.9
  L03_SIG1 w0.081: v2(47.89,57.65) 48.26,57.28 48.26,56.05 48.01,55.81 48.01,55.09 46.6,53.68 46.6,53.07 46.19,52.66 45.05,52.66 v1(44.52,52.12)
  BOTTOM w0.149: R126.1 v1(44.52,52.12)
N40632752: length 1.3
  BOTTOM w0.149: R145.1 103.13,69.51 R146.1
  vias: v1(104.37,69.51)
N40710074: length 2
  TOP w0.254: U69.25 208.86,35.01 C821.1
N40710102: length 3.2
  TOP w0.254: U69.24 208.53,34.51 C822.2 209.82,34.17 R669.2
N40710172: length 2.1
  TOP w0.254: U69.27 207.89,36.01 208.99,37.1 R670.1
N40710190: length 4.8
  TOP w0.254: U69.23 207.63,34.01 207.91,33.73 207.91,32.08 208.07,31.92 R675.2 208.07,30.66 R674.2 C824.1
N40710194: length 116.8
  TOP w0.203: C824.2 v1(207.21,30.64)
  TOP w0.254: v1(101.96,35.96) 101.76,35.75 101.76,35.33 102.05,35.04 103.91,35.04 104.49,35.63 107,35.63 107.74,34.9 124.78,34.9 125.54,34.14 127.38,34.14 128.01,34.77 132.21,34.77 134.64,32.35 145.17,32.35 146.82,30.71 174.55,30.71 v1(174.63,30.79)
  L14_SIG5 w0.203: v1(207.21,30.64) 207.51,30.94 207.94,30.94 208.33,31.34 208.33,33.34 207.94,33.74 198.21,33.74 197.6,33.12 192.8,33.12 191,31.32 186.76,31.32 185.27,29.83 176.14,29.83 175.35,30.62 174.79,30.62 v1(174.63,30.79)
N40710315: length 117.5
  TOP w0.254: v1(101.12,36.01) 101.38,35.75 101.38,35.18 101.89,34.66 104.06,34.66 104.65,35.25 106.84,35.25 107.58,34.52 124.62,34.52 125.38,33.76 127.54,33.76 128.17,34.39 132.06,34.39 134.48,31.97 145.02,31.97 146.66,30.33 174.3,30.33 v1(174.51,30.11) ; v1(207.18,31.57) 207.18,32.3 206.61,32.87 U69.22
  L14_SIG5 w0.203: v1(207.18,31.57) 207.21,31.57 207.51,31.27 207.8,31.27 208,31.47 208,33.2 207.8,33.41 198.35,33.41 197.73,32.79 192.94,32.79 191.14,30.99 186.89,30.99 185.4,29.5 176,29.5 175.22,30.29 174.69,30.29 v1(174.51,30.11)
N40710340: length 8.9
  TOP w0.254: U69.1 206.61,37.52 206.76,37.67 207.78,37.67 208.21,38.1 208.21,39.22 208.52,39.53 211.18,39.53 212.25,40.59 TP15.1
N40803427:
  vias: v1(114.19,93.44)
N40814737:
  vias: v1(196.31,104.6) v1(196.31,104.09) v1(196.31,103.58) v1(196.31,103.07)
N40815384:
  vias: v1(114.19,100.92)
N40816526:
  vias: v1(69.14,100.96)
N41064371: length 1.7
  TOP w0.254: U68.25 39.27,105.24 C804.1
N41064404: length 5.3
  TOP w0.254: R657.2 42.77,105.37 C805.2 41.82,105.57 41.82,105.36 41.03,104.57 39.97,104.57 39.77,104.37 U68.24
N41064465: length 1.7
  TOP w0.254: R658.1 38.27,105.26 U68.27
N41064483: length 5.7
  TOP w0.254: C807.1 44.28,103.93 44.28,104.24 44.04,104.49 R659.2 R661.2 41.52,104.49 41.21,104.17 40.53,104.17 40.27,103.91 U68.23
N41064487: length 70.4
  TOP w0.254: v1(43.72,103.6) 43.72,103.53 44.23,103.03 44.23,102.64 44.42,102.45 C807.2
  L14_SIG5 w0.203: v1(75.56,88.86) 75.45,88.98 75.45,89.43 74.85,90.03 74.65,90.03 73.5,91.17 69.93,91.17 68.19,92.91 62.53,92.91 58.01,97.44 52.31,97.44 51.16,98.58 42.45,98.58 41.31,99.73 41.31,102.89 41.69,103.28 42.07,103.28 42.22,103.12 43.25,103.12 v1(43.72,103.6)
  BOTTOM w0.229: v1(75.56,88.86) 76.01,88.86 76.42,88.45 87.15,88.45 91.59,84 95.4,84 95.94,83.46 95.94,83.02 R666.2
N41064609: length 70.4
  TOP w0.254: v1(42.7,103.6) 42.58,103.47 41.62,103.47 41.15,103 U68.22
  L14_SIG5 w0.203: v1(42.7,103.6) 42.21,103.6 42.2,103.61 41.55,103.61 40.98,103.03 40.98,99.59 42.31,98.25 51.02,98.25 52.17,97.1 57.87,97.1 62.4,92.58 68.06,92.58 69.8,90.84 73.37,90.84 74.51,89.7 74.71,89.7 75.06,89.35 75.06,88.72 75.56,88.21 v1(75.56,87.72)
  BOTTOM w0.229: v1(75.56,87.72) 76.01,87.72 76.38,88.09 87,88.09 91.45,83.64 95.26,83.64 95.59,83.31 95.59,83.02 R665.2
N41064634: length 3.6
  TOP w0.254: TP14.1 34.84,104.72 36.06,104.72 36.38,104.4 36.38,103.33 36.71,103 U68.1
N41103719: length 1.6
  BOTTOM w0.149: R287.2 13.86,75.44 SW3.8
N41105372: length 2.9
  TOP w0.254: R456.1 68.93,79.67 C564.1 70.27,79.99 EU1.4
N41105376: length 3.1
  TOP w0.254: EU1.5 70.84,79.49 70.13,78.78 C564.2 68.93,78.78 R458.1
N41105458: length 1.7
  TOP w0.254: EU1.6 71.92,78.99 72.68,78.24 C566.1
  vias: v1(72.69,77.89)
N41105462: length 1.7
  TOP w0.254: EU1.7 74.36,78.99 73.57,78.2 v1(73.57,77.89)
N41106635: length 4.5
  TOP w0.149: EU1.10 75.75,80.49 76.12,80.86 v1(76.12,81.09)
  BOTTOM w0.149: v1(76.12,81.09) 76.23,80.98 76.23,79.91 76.61,79.53 R460.1
N41107356: length 2.6
  BOTTOM w0.149: EU2.3 167.61,91.14 C568.2 167.35,90.88 R471.1
N41107358: length 2.8
  BOTTOM w0.149: R470.1 166.66,90.06 C568.1 167.52,90.06 168.11,90.64 EU2.2
N41107415: length 3
  BOTTOM w0.149: EU2.5 168.47,92.14 167.76,92.85 C569.2 167.15,92.85 166.88,92.58 166.67,92.58 R473.1
N41107417: length 2.8
  BOTTOM w0.149: EU2.4 168.24,91.64 167.91,91.96 C569.1 167.13,91.96 167.01,92.08 166.75,92.08 R472.1
N41107474: length 2.8
  BOTTOM w0.149: R475.1 170.97,94.07 C571.2 171.96,93.09 EU2.7
N41107476: length 3.1
  BOTTOM w0.149: R474.1 170.17,94.8 C571.1 169.59,93.4 169.38,93.4 168.97,92.99 EU2.6
N41107506: length 1.7
  BOTTOM w0.149: R476.1 173.45,91.14 EU2.10
N41802473: length 3.9
  BOTTOM w0.203: J9.3 246.64,31.07 R414.1
N42584695: length 1
  BOTTOM w0.149: R854.2 C1286.2
N42710822: length 1.5
  BOTTOM w0.149: v1(45.55,31.54) 45.5,31.49 U30.13
N42710832: length 1.5
  BOTTOM w0.149: U30.12 44.85,31.45 v1(44.76,31.54)
N42980348: length 22
  L12_SIG4 w0.089: v1(86.89,74.27) 87.87,74.27 87.87,74.26 88.18,74.26 88.19,74.27 88.26,74.27 88.47,74.48 89.26,74.48 89.43,74.3 89.96,74.3 90.24,74.58 90.67,74.58 91.27,73.98 91.63,73.98 92.13,73.48 92.67,73.48 92.91,73.23 93.3,73.23 93.86,73.8 94.23,73.8 94.72,74.3 95.31,74.3 95.55,74.53 95.9,74.53 96.46,73.98 96.83,73.98 97.29,73.51 97.86,73.51 98.19,73.18 98.76,73.18 99.28,73.7 99.68,73.7 100.2,73.18 100.62,73.18 100.98,72.81 101.36,72.81 101.74,73.19 101.92,73.19 102.11,73.19 102.57,72.73 102.97,72.73 103.42,72.28 103.78,72.28 104.26,71.8 104.5,71.8 104.83,71.47 104.83,71.23 v1(105.17,70.89)
N42980629:
  vias: v1(103.57,67.21)
N44631565: length 1.9
  BOTTOM w0.149: U19.1 142.02,33.96 141.5,34.49 R927.1
N45051576: length 1.7
  TOP w0.254: U71.25 53.34,105.29 C1327.1
N45051609: length 5.3
  TOP w0.203: R943.1 56.84,105.43 C1328.2
  TOP w0.254: C1328.2 55.89,105.62 55.89,105.41 55.07,104.6 54.05,104.6 53.84,104.4 U71.24
N45051685: length 1.7
  TOP w0.254: U71.27 52.34,105.31 R944.1
N45051689: length 4.9
  TOP w0.149: U71.23 54.34,104.07 54.49,104.22 55.58,104.22 55.9,104.54 R947.1 R945.2 C1330.1
N45051693: length 67
  TOP w0.149: R945.1 C1330.2 v1(58.86,103.65)
  L16_SIG6 w0.081: v1(112.07,84.58) 112.07,85.35 110.58,86.84 105.8,86.84 105.04,87.59 104.48,87.89 104.24,88.07 104.01,88.26 100.17,92.1 100.09,92.22 99.19,92.22 98.39,93.02 98.39,93.93 97.26,95.06 97.26,95.64 v1(97.3,95.68) ; v1(58.86,103.65) 60.88,103.65 67.01,97.51 69.3,97.51 70.62,96.19 77.1,96.19 v1(77.15,96.14)
  BOTTOM w0.149: v1(97.3,95.68) 97.3,95.25 95.69,93.63 94.93,93.63 94.74,93.82 91.6,93.82 90.65,94.77 80.88,94.77 80.67,94.56 77.17,94.56 76.61,95.13 76.61,95.6 v1(77.15,96.14)
N45051842: length 5
  TOP w0.254: TP18.1 48.01,105.74 49.16,105.74 50.45,104.45 50.45,103.38 50.78,103.05 U71.1
N45051844: length 67.2
  TOP w0.149: U71.22 55.33,103.05 55.93,103.65 v1(56.78,103.65)
  L16_SIG6 w0.081: v1(77.17,95.41) 76.36,95.41 76.28,95.33 71.1,95.33 69.16,97.27 66.92,97.27 61.04,103.15 57.27,103.15 v1(56.78,103.65) ; v1(96.81,96.13) 96.81,95.19 98.16,93.84 98.16,92.91 99.08,91.98 99.97,91.98 99.99,91.95 103.86,88.08 104.1,87.89 104.36,87.7 104.46,87.64 104.88,87.42 105.69,86.61 110.19,86.61 111.06,85.74 111.06,84.68 v1(111.08,84.65)
  BOTTOM w0.149: v1(77.17,95.41) 77.49,95.09 90.76,95.09 91.21,94.63 95.62,94.63 96.81,95.82 v1(96.81,96.13)
N45054348: length 2.9
  BOTTOM w0.127: C1345.1 204.87,51.41 204.43,51.41 204.3,51.29 203.52,51.29 v1(202.99,51.82)
N45054411: length 12.1
  L05_SIG2 w0.127: v1(207,56.31) 201.13,56.31 200.99,56.17 200.99,54.05 200.76,53.82 200.37,53.82 200.19,53.64 200.19,53.08 200.59,52.69 v1(200.59,52.62)
  BOTTOM w0.127: v1(200.59,52.62) 200.2,53.01 199.33,53.01 R955.1
N45054431:
  vias: v1(203.79,51.82)
N45054433: length 1.7
  TOP w0.254: TP19.1 200.59,57.51 v1(200.59,55.82)
N45054462:
  vias: v1(199.79,55.02)
N45054466: length 3.3
  BOTTOM w0.254: v1(202.19,51.02) 202.19,50.4 202.45,50.14 R958.2 C1347.1 R959.2
N45054537: length 3
  TOP w0.203: v1(204.59,54.22) 204.88,54.51 205.25,54.51 205.69,54.96 205.79,54.96 R960.2
  TOP w0.254: R957.1 206.13,56.08 R960.2
N45054575: length 3.4
  BOTTOM w0.127: v1(202.99,51.02) 203.17,50.84 204.07,50.84 204.72,50.18 R978.1
N45054598: length 0.9
  TOP w0.254: U66.F1 203.9,50.85 v1(203.78,50.36)
  BOTTOM w0.254: R958.1 v1(203.78,50.36)
N45054604: length 0.9
  BOTTOM w0.149: R959.1 C1348.1
N45054651: length 4.9
  BOTTOM w0.127: v1(202.19,51.82) 202.58,52.21 202.58,53.57 202.84,53.83 205.01,53.83 R980.1
N45054838: length 1.7
  TOP w0.254: U66.C1 v1(201.4,50.14)
  BOTTOM w0.254: R964.2 v1(201.4,50.14)
N45056577: length 2.9
  BOTTOM w0.127: C1366.1 207.12,43.83 206.33,43.83 206.1,43.6 206.1,43.29 205.86,43.04 205.29,43.04 v1(204.9,43.44)
N45056642: length 13.5
  TOP w0.127: v1(207.16,49.65) 207.16,49.23 R967.2
  BOTTOM w0.127: v1(207.16,49.65) 207.16,49.26 206.46,48.55 204.44,48.55 203.7,47.82 203.7,46.23 R965.1 203.16,46.07 203.16,46.16 202.95,46.37 202.16,46.37 202.03,46.23 201.55,46.23 200.86,45.55 200.86,45.06 201.06,44.87 201.87,44.87 v1(202.5,44.24)
N45056662: length 8.7
  TOP w0.254: v1(211.48,44.23) 211.48,44.13 TP21.1
  BOTTOM w0.127: v1(205.7,43.44) 205.3,43.84 205.3,44.4 205.53,44.63 206.92,44.63 207.52,45.23 209.84,45.23 210.84,44.23 v1(211.48,44.23)
N45056664: length 4
  TOP w0.203: TP22.1 199.4,47.7 199.6,47.91 202.29,47.91 202.5,47.7 v1(202.5,47.44)
N45056693: length 1.4
  TOP w0.381: R966.1 200.32,46.64 v1(201.7,46.64)
N45056697: length 3.4
  BOTTOM w0.254: v1(203.78,40.72) 203.83,40.67 C1368.1
  BOTTOM w0.305: R969.2 C1368.1
  BOTTOM w0.508: R969.2 204.6,41.61 204.1,42.12 v1(204.1,42.64)
N45056768: length 2.6
  TOP w0.149: v1(206.5,45.84) 206.86,45.84 R972.2 R967.1
N45056806: length 1.9
  BOTTOM w0.254: R970.1 206.31,42.18 205.35,42.18 v1(204.9,42.64)
N45056829: length 1
  TOP w0.254: U67.F1 205.7,41.62 v1(205.68,41.61)
N45056835: length 1
  BOTTOM w0.254: C1369.1 R971.1
N45056882:
  vias: v1(204.1,43.44)
N45057066: length 4.1
  BOTTOM w0.254: v1(203.3,42.64) 203.14,42.64 202.99,42.48 202.99,42.48 202.91,42.41 202.91,42.41 202.69,42.18 202.68,42.18 202.51,42.01 200.2,42.01 199.94,42.26 v1(199.94,42.6)
N45214136: length 2.2
  BOTTOM w0.149: U42.14 249.9,47.87 250.26,47.51 R982.2
N45280572: length 4.8
  TOP w0.149: v2(55.02,34.29) 55.03,34.31 55.03,34.34 55.06,34.37 R985.2 ; R986.2 57.92,34.26 v2(57.92,33.42)
  L03_SIG1 w0.081: v2(57.92,33.42) 57.57,33.76 55.17,33.76 55.02,33.91 v2(55.02,34.29)
N45280837: length 4
  TOP w0.149: R988.2 61.73,34.05 C1394.2 ; R987.2 v1(58.74,34.26)
  BOTTOM w0.149: v1(58.74,34.26) 58.92,34.09 61.12,34.09 61.33,34.3 arc(61.35,34.31) v1(61.36,34.33)
N45286790: length 4.8
  L07_SIG3 w0.089: v1(213.37,56.34) v1(214.64,56.34)
  BOTTOM w0.149: C1399.2 R993.2 215.29,56.98 215.29,56.71 214.92,56.34 v1(214.64,56.34) ; v1(213.37,56.34) 213.1,56.34 212.73,56.71 212.73,56.99 R996.2
N45286851: length 5.1
  TOP w0.149: v1(209.3,57.99) 209.3,58.46 C1400.2 211.34,58.63 211.53,58.44 v1(211.53,58)
  BOTTOM w0.149: v1(211.53,58) R997.2 ; R998.2 208.73,57.9 208.82,57.99 v1(209.3,57.99)
N45349000: length 3.4
  TOP w0.149: v1(59.48,12.96) 59.48,12.99 59.33,13.14 U17.1
  BOTTOM w0.149: R1000.2 58.92,12.4 v1(59.48,12.96) R1001.1
N46887455: length 0.7
  BOTTOM w0.15: U103.D3 v1(12.35,19.21)
N46887476: length 0.7
  BOTTOM w0.15: U103.D2 v1(12.35,17.21)
N46887502: length 0.7
  BOTTOM w0.15: U103.C4 v1(14.35,20.21)
N46887527: length 0.7
  BOTTOM w0.15: U103.D4 v1(12.35,20.21)
N46887553: length 0.7
  BOTTOM w0.15: U103.D5 v1(12.35,21.21)
N46887581: length 0.7
  BOTTOM w0.15: U103.E3 v1(11.35,18.21)
N46887604: length 0.7
  BOTTOM w0.15: U103.E2 v1(11.35,17.21)
N46887630: length 0.7
  BOTTOM w0.15: U103.E1 v1(11.35,16.21)
N46986379: length 1.2
  TOP w0.381: R371.2 v1(242.01,106.86)
  vias: v1(252.77,101.43) v1(252.77,98.43) v1(252.77,95.43) v1(252.77,92.43) v1(252.77,89.43) v1(252.77,86.43) v1(252.77,83.43) v1(252.77,80.43) v1(252.77,77.43) v1(252.77,74.43) v1(252.77,71.43) v1(252.77,68.43) v1(252.77,59.43) v1(252.77,56.43) v1(252.77,47.43) v1(252.77,44.43) v1(252.77,41.43) v1(252.77,38.43) v1(252.77,35.43) v1(252.77,32.43) v1(252.77,29.43) v1(252.77,26.43) v1(252.77,23.43) v1(252.77,20.43)
N46987350: length 2.1
  TOP w0.149: R2715.2 199.87,21.32 200.02,21.47 v1(200.02,21.71)
  BOTTOM w0.149: v1(200.02,21.71) 200.02,21.47 199.87,21.32 U107.18
N46987353: length 0.9
  BOTTOM w0.254: U107.23 200.31,18.67 v1(200.6,18.38)
N46993584: length 8
  BOTTOM w0.149: J10.8 233.03,100.68 233.03,98.34 233.49,97.88 233.49,97.17 232.88,96.56 R2734.1
N46996106: length 3.6
  BOTTOM w0.149: R6183.1 224.24,102.02 J10.2
N46996953: length 3.8
  BOTTOM w0.149: J10.7 231.78,97.27 231.12,96.61 R2735.2
N47009841: length 4.8
  BOTTOM w0.149: TP951.1 123.51,37.1 R2738.2 v1(125.41,37.1) 125.41,37.98 125.49,38.06 125.49,38.39 125.41,38.48 125.41,38.9 125.49,38.98 125.49,39.21 v1(125.88,39.61)
N47015448: length 2.4
  TOP w0.149: Q15.3 14.79,105.78 14.21,106.36 14.21,107.2 D14.C
N47015450: length 0.4
  BOTTOM w0.149: R2741.1 v1(15.92,107.21)
N47031477: length 2.5
  TOP w0.149: R384.1 39.66,16.97 38.71,16.02 Y4.1
N47031519: length 1.3
  TOP w0.149: Y4.3 R385.2
N47056010: length 1.6
  BOTTOM w0.149: R2779.2 185.54,91.82 185.75,91.82 186.19,92.26 186.66,92.26 U108.9
N47056063: length 4.8
  BOTTOM w0.149: R2781.1 R2782.2 R2780.2 184.52,91.66 185.09,91.09 185.94,91.09 186.15,91.3 U108.7
N47056195: length 3.9
  BOTTOM w0.149: U108.1 189.75,93.04 189.44,93.35 189.44,93.83 189.68,94.07 189.68,94.07 189.73,94.12 C7434.1 R2784.1 189.57,95.65 R2783.1
N47788591: length 2.3
  TOP w0.149: U119.31 185.2,58.94 C1714.1
N47788598: length 2.4
  TOP w0.149: C1716.1 184.16,58.54 U119.30
N47788631: length 4.4
  TOP w0.149: C1715.1 184.51,54.92 184.21,55.22 184.21,57.48 184.12,57.56 184.12,57.56 183.94,57.74 U119.28
N47788711: length 1.4
  TOP w0.149: v1(181.09,55.94) U119.22
  BOTTOM w0.149: R6026.2 181.08,55.95 v1(181.09,55.94)
N47788713: length 1.2
  TOP w0.149: R5870.2 181.64,55.86 181.49,56.01 U119.23
N47788715: length 1.4
  TOP w0.149: U119.24 181.89,56.03 R5871.2
N47788717: length 1.8
  TOP w0.149: U119.25 182.29,56.15 182.46,55.98 182.77,55.98 R5873.2
N47790152: length 14.9
  TOP w0.149: v1(175.62,63.21) 175.66,63.25 R5883.1 R5881.1 175.35,65.21 v1(175.07,65.21)
  BOTTOM w0.149: R5882.1 C7670.2 182.58,64.86 R6194.1 182.31,65.48 182.16,65.63 181.04,65.63 180.8,65.38 180.8,64.65 C7672.2 179.92,64.25 179.84,64.18 179.74,64.18 R6035.1 178.54,64 177.8,64.73 v1(177.8,65.87) 177.43,65.87 176.76,65.21 v1(175.07,65.21)
N47791843: length 0.8
  TOP w0.203: U120.35 173.38,87.2 173.96,87.2 v1(174.09,87.07)
N47793696: length 1.8
  TOP w0.203: U121.35 174.24,73.16 174.7,73.62 R5886.2
N47795663: length 1.1
  TOP w0.203: R5891.2 174.29,59.16 U125.35
N47798128: length 2.2
  TOP w0.149: U126.35 173.59,44.35 173.67,44.44 173.81,44.44 173.98,44.61 173.98,44.62 174.09,44.73 174.38,44.73 175.08,44.03 R5894.2
N47813492: length 7.4
  L16_SIG6 w0.081: v1(15.78,55.36) 15.93,55.5 18.52,55.5 19.51,56.5 v1(19.51,58.37)
  BOTTOM w0.149: R6008.2 15.63,56.06 15.78,55.91 v1(15.78,55.36)
N47813514: length 3.2
  BOTTOM w0.149: C7522.2 17.64,58.77 17.79,58.91 17.79,59.18 v1(19.51,60.91)
N47814553: length 3
  BOTTOM w0.254: U132.6 71.62,48.32 72.14,48.85 R925.2 R923.1
N47814610: length 2.9
  BOTTOM w0.254: U132.7 71.9,47.82 72.14,47.58 C1313.1 R921.2
N47814650: length 2.2
  BOTTOM w0.254: U132.5 67.65,48.32 R917.1
N47815277: length 0.3
  BOTTOM w0.149: R6002.2 69.46,87.99 v1(69.45,88)
N47815307: length 3
  BOTTOM w0.149: v1(69.45,86.73) 69.45,87.07 69.16,87.37 R6003.2 R6005.2 68.48,88.21 R6004.1
N47815315: length 2
  BOTTOM w0.149: v1(69.45,85.46) 68.64,85.46 68.49,85.61 C7518.2
N47816801:
  vias: v1(203.44,20.75)
N47816829: length 2.5
  BOTTOM w0.203: R6173.2 203.8,19.85 v1(203.44,19.48) 203.41,19.51 R6171.2 R6172.1
N47816837: length 1
  BOTTOM w0.203: C7439.2 204.04,18.82 v1(203.44,18.21)
N47816940: length 3.4
  TOP w0.254: v1(204.71,16.94) 204.71,15.45 205.21,14.94 R2785.2
  BOTTOM w0.203: v1(204.71,16.94) 204.62,16.86 C7725.1
N47819054: length 7.3
  TOP w0.149: TP1001.1 175.82,34.04 176.21,33.66 177.05,33.66 178.11,34.72 178.11,36.55 v1(178.77,37.21)
N47819056: length 12.6
  L14_SIG5 w0.081: v4(176.14,37.55) 175.51,36.92 175.51,35.87 176.11,35.27 181.37,35.27 182.21,36.1 182.21,37.37 183.33,38.48 v1(183.85,38.48)
N47819060: length 3.6
  TOP w0.149: R5952.1 195.21,44.07 C7464.2 194.45,44.2 193.82,44.83 U135.K1
N47819062: length 6.4
  TOP w0.149: v1(192.74,43.56) 192.18,44.13 192.18,45.2 192.38,45.41 194.76,45.41 C7464.1 195.18,45.09 195.49,44.78 195.49,44.65 195.94,44.2 R5953.1
N47819276: length 0.9
  BOTTOM w0.149: v1(178.77,39.75) 178.6,39.58 R5949.2
N47819301: length 2.7
  TOP w0.149: R5955.2 193.17,36.78 v1(192.74,37.21)
N47819873: length 4.1
  L07_SIG3 w0.089: v1(183.85,43.56) 183.45,43.17 180.44,43.17 v1(180.04,43.56)
N47819899: length 9.2
  L14_SIG5 w0.081: v1(183.85,37.21) 184.25,37.61 184.25,42.46 184.02,42.69 183.98,42.69 182.64,44.03 181.78,44.03 v1(181.31,43.56)
N47819921: length 2.2
  TOP w0.254: U135.E11 v1(178.77,38.48)
  BOTTOM w0.149: v1(178.77,38.48) 178.58,38.67 R768.1
N47819951: length 6.1
  BOTTOM w0.149: v1(178.77,35.94) 178.77,36.5 178.41,36.87 R5950.2 177.92,37.4 178.18,37.66 179.07,37.66 180.04,38.63 181.17,38.63 v1(181.31,38.48)
N47819992: length 4.5
  BOTTOM w0.149: R6284.2 178.45,41.35 v1(178.77,41.02) v1(180.04,39.75) ; R6284.2 R6283.1 ; R6284.2 R6165.1
N47820049: length 0.8
  BOTTOM w0.149: R6169.2 183.51,39.41 v1(183.85,39.75)
N47820094: length 1.2
  BOTTOM w0.149: R6170.2 181.95,38.81 182.28,38.48 v1(182.58,38.48)
N47820137: length 9
  L14_SIG5 w0.081: v1(182.58,43.56) 182.12,43.1 182.12,42.2 182.42,41.9 182.65,41.9 183.22,41.33 183.22,39.56 182.77,39.11 182.26,39.11 181.74,38.59 181.74,37.65 v1(181.31,37.21)
  BOTTOM w0.203: v1(182.58,43.56) 182.26,43.56 C7461.1
N47820145: length 3.1
  BOTTOM w0.149: R5956.2 178.17,42.95 178.44,42.95 179.41,41.98 179.41,41.66 v1(180.04,41.02)
N47820149: length 8.4
  L14_SIG5 w0.081: v1(182.58,42.29) 183.41,41.47 183.41,39.34 182.94,38.88 182.42,38.88 182.14,38.6 182.14,37.63 181.98,37.46 181.98,36.61 v1(181.31,35.94)
  BOTTOM w0.203: v1(182.58,42.29) 182.9,42.29 C7462.1
N47820157: length 2.4
  TOP w0.203: U135.H12 178.72,42.24 R5957.2
N47820167: length 0.8
  BOTTOM w0.149: v1(180.03,37.32) 179.78,37.07 R5958.2
N47820169: length 1.2
  BOTTOM w0.149: v1(178.77,44.83) 178.72,44.88 178.72,45.09 178.09,45.72 R5959.2
N47820215: length 2.5
  BOTTOM w0.149: v1(180.04,35.94) 179.59,35.49 178.39,35.49 R5948.1
N47824485: length 1.3
  L07_SIG3 w0.089: v1(186.92,76.29) v1(186.92,77.56)
N47824624: length 0.9
  TOP w0.254: U118.J6 190.73,77.45 v1(190.15,76.87)
N47824941: length 1.3
  BOTTOM w0.149: v1(192,81.37) 192.02,81.35 R5837.1 192.02,80.12 v1(192,80.1)
N47824971: length 1.3
  BOTTOM w0.149: R5838.2 194.51,81.34 v1(194.54,81.37) 194.43,81.47 R6054.2
N47825075: length 0.7
  BOTTOM w0.149: R5839.1 189.22,82.87 v1(189.46,82.64)
N47825077:
  vias: v1(189.46,78.83)
N47825108: length 1.9
  BOTTOM w0.149: R5845.1 186.99,83.22 187.55,83.78 R5847.1
  BOTTOM w0.254: R5845.1 v1(186.99,82.65)
N47825137: length 3.2
  BOTTOM w0.254: D17.2 183.65,82.63 184.12,83.1 184.81,83.1 R6146.1 185.38,82.91 v1(185.65,82.64)
N47825141: length 1.3
  L07_SIG3 w0.089: v1(186.92,83.91) v1(186.92,85.18)
N47825168:
  vias: v1(188.19,76.29)
N47825183: length 7.4
  L07_SIG3 w0.089: v1(188.11,81.32) 186.96,81.32 v1(186.92,81.37) 186.92,82.12 186.27,82.77 R5841.1 185.74,84.53 v1(184.87,84.53)
  BOTTOM w0.149: v1(184.87,84.53) 185.59,84.53 185.95,84.18 186.09,84.18 R5841.1
N47825220: length 7
  L07_SIG3 w0.089: v1(187.15,71) 187.15,72.83 187.66,73.34 187.66,77.04 v1(188.19,77.56)
N47825281:
  vias: v1(185.65,80.1)
N47825319:
  vias: v1(185.65,78.83)
N47825365: length 1.7
  L07_SIG3 w0.089: v1(186.92,80.1) v1(188.19,80.1)
  BOTTOM w0.149: R5853.2 v1(188.19,80.1)
N47825375: length 2.2
  L07_SIG3 w0.089: v1(188.19,78.83) v1(186.92,78.83)
  BOTTOM w0.149: R5854.2 188.8,79.44 v1(188.19,78.83)
N47828123: length 1.3
  L07_SIG3 w0.203: v1(73.84,68.09) v1(75.11,68.09)
N47828262:
  vias: v1(73.84,71.9)
N47828572: length 1.9
  TOP w0.149: v1(70.03,73.17) v1(71.3,73.17)
  BOTTOM w0.149: v1(71.3,73.17) 71.93,73.17 R5927.1
N47828706: length 1.4
  BOTTOM w0.149: R5929.1 67.66,70.12 68.16,70.63 v1(68.76,70.63)
N47828708: length 1.3
  BOTTOM w0.149: R5930.1 72.8,70.01 72.57,70.23 v1(72.57,70.63)
N47828718: length 4.2
  L07_SIG3 w0.203: v1(70.03,69.36) v1(70.03,68.09)
  BOTTOM w0.149: R6147.1 69.5,70.58 69.63,70.45 69.63,70.43 69.66,70.4 69.66,70.4 69.7,70.36 69.7,70.36 69.87,70.2 69.88,70.2 70.03,70.05 v1(70.03,69.36) 70.25,69.14 R5941.2 ; R5940.1 70.17,67.95 v1(70.03,68.09)
N47828739: length 1.8
  BOTTOM w0.149: R5937.1 68.13,68.76 68.76,68.13 v1(68.76,68.09) 69.3,68.09 R5934.1
N47828768: length 5.9
  L07_SIG3 w0.089: v1(68.76,66.82) 68.27,66.32 66.04,66.32 65.72,66.64 v1(65.72,67.41)
  BOTTOM w0.149: v1(65.72,67.41) 65.46,67.41 D18.2 ; v1(68.76,66.82) 68.12,67.47 R5936.1
N47828772: length 1.5
  L14_SIG5 w0.081: v1(67.49,68.09) 67.22,68.36 66.5,68.36 v1(66.22,68.09)
N47828796: length 1.3
  TOP w0.149: U136.K4 75.11,68.96 74.85,68.69 v1(74.28,68.69)
N47828848: length 2
  BOTTOM w0.149: TP1007.1 74.92,69.36 v1(73.84,69.36)
N47828909: length 0.7
  BOTTOM w0.149: R5944.2 71.71,66.82 v1(71.3,66.82)
N47828945: length 0.9
  BOTTOM w0.149: R5945.1 73.15,67.39 v1(72.57,66.82)
N47828991: length 2.1
  L07_SIG3 w0.203: v1(71.3,69.36) v1(71.3,68.09)
  BOTTOM w0.149: R5946.2 71.13,69.36 v1(71.3,69.36)
N47829001: length 2.1
  L07_SIG3 w0.203: v1(72.57,69.36) v1(72.57,68.09)
  BOTTOM w0.149: v1(72.57,69.36) 72.35,69.36 R5947.2
N47866759: length 1.5
  TOP w0.254: U131.7 200.58,68.32 C7563.1
N47871117: length 2.5
  TOP w0.149: U129.B1 183.14,66.67 183.6,66.21 v1(183.6,65.96)
  BOTTOM w0.149: C7718.1 183.2,66.58 183.6,66.19 v1(183.6,65.96)
N47871122: length 0.5
  BOTTOM w0.149: v1(184.44,66.03) 184.47,66 C7569.1
N47871485: length 12.3
  TOP w0.149: v1(177.81,69.9) C7566.2 R6049.2 ; v1(184.28,67.41) 184.19,67.32 U129.C1
  L03_SIG1 w0.081: v1(184.28,67.41) 184.67,67.8 184.67,69.28 183.36,70.6 178.5,70.6 v1(177.81,69.9)
N47872099: length 4.5
  TOP w0.203: R6050.1 179.84,65.89 179.63,66.09 179.63,66.8 180.15,67.32 L26.1 181.83,67.32 182.33,67.82 U129.A2
N47874483: length 1.3
  TOP w0.149: C7567.1 184.91,67.82 U129.C2
N47990323: length 2.7
  BOTTOM w0.149: v1(65.48,37.92) R6168.1 65.95,36.86 66.31,36.49 R6166.1
  vias: v1(70.48,37.86) v1(70.48,36.26) v1(72.08,37.86) v1(72.08,36.26)
N48002409: length 0.7
  BOTTOM w0.149: v1(70.03,75.71) 70.07,75.67 R6056.2
N48253770: length 20.2
  L16_SIG6 w0.081: v1(192.44,71.21) 191.22,72.43 184.1,72.43 183.75,72.78 183.75,77.51 184.24,78 189.02,78 v1(189.46,77.56)
N48264639: length 3.5
  L07_SIG3 w0.089: v1(188.75,25.1) 189.13,24.72 190.89,24.72 v1(191.29,25.12)
  BOTTOM w0.381: v1(191.29,25.12) 191.29,25.13 R6082.2
  vias: v1(179.18,15.15) v1(181.13,25.1) v1(184.94,25.1)
N48264690: length 9
  L07_SIG3 w0.089: v1(182.4,25.1) 184.38,25.1 184.78,25.5 185.82,25.5 v1(186.21,25.1) 186.24,25.1 186.67,25.53 189.59,25.53 v1(190.02,25.1)
  BOTTOM w0.381: C7721.1 v1(190.02,25.1)
  vias: v1(193.83,25.1)
N48264694: length 3.1
  BOTTOM w0.149: v1(182.4,23.83) 183.08,23.15 183.08,21.88 v1(183.67,21.29)
N48264698: length 0.4
  BOTTOM w0.149: C1967.2 v1(181.13,23.83)
  vias: v1(184.94,23.83) v1(188.75,23.83) v1(192.56,23.83)
N48264773: length 3.1
  BOTTOM w0.149: v1(187.48,21.29) 186.98,21.79 186.98,23.06 v1(186.21,23.83)
N48264853: length 3.1
  BOTTOM w0.149: v1(191.29,21.29) 190.7,21.88 190.7,23.26 190.13,23.83 v1(190.02,23.83)
N48264943: length 1.8
  BOTTOM w0.149: v1(192.56,22.56) v1(193.83,23.83)
N48264979: length 0.8
  BOTTOM w0.149: R6082.1 R6043.1
N48265099: length 0.7
  BOTTOM w0.149: R6044.1 v1(187.48,20.02)
N48270066: length 2
  TOP w0.203: v1(206.51,96.76) 206.51,95.85 C7716.2 207.5,95.74 R6087.2
  vias: v1(210.32,96.76) v1(214.13,96.76) v1(216.67,96.76)
N48270081:
  vias: v1(207.78,96.76) v1(211.59,96.76) v1(215.4,96.76) v1(219.21,96.76)
N48270093: length 3.1
  BOTTOM w0.203: v1(209.05,100.57) 208.47,100 208.47,98.73 v1(207.78,98.03)
N48270097: length 0.3
  TOP w0.203: v1(214.13,98.03) 214.33,98.23 C7615.2
  vias: v1(206.51,98.03) v1(210.32,98.03) v1(217.94,98.03)
N48270166: length 3.1
  BOTTOM w0.203: U139.E6 212.28,98.73 212.28,100 U139.F4
N48270246: length 3.1
  BOTTOM w0.203: v1(216.67,100.57) 216.09,100 216.09,98.73 v1(215.4,98.03)
N48270336: length 1.8
  BOTTOM w0.254: v1(217.94,99.3) v1(219.21,98.03)
N48270376: length 0.9
  TOP w0.203: R6087.1 R6088.1
N48273834: length 18.4
  L07_SIG3 w0.203: v1(74.54,60.77) 73.87,60.1 72.67,60.1 v1(72,60.77) 71.26,60.02 68.94,60.02 v1(68.19,60.77)
  L14_SIG5 w0.203: v1(68.19,60.77) 67.75,60.33 64.82,60.33 v1(64.38,60.77)
  BOTTOM w0.381: C7717.2 63.28,59.66 v1(64.38,60.77) ; v1(74.54,60.77) 74.82,60.49 R6013.1
N48273885: length 14.2
  L14_SIG5 w0.203: v1(77.08,60.77) 76.57,60.25 73.79,60.25 v1(73.27,60.77) 72.76,60.25 69.98,60.25 v1(69.46,60.77) 69.01,60.77 68.33,61.45 66.01,61.45 65.65,61.08 v1(65.65,60.77)
  BOTTOM w0.149: C7720.1 65.39,60.09 65.65,60.35 v1(65.65,60.77)
N48273889: length 3.6
  L16_SIG6 w0.081: v1(66.92,56.96) 66.76,57.12 66.76,57.83 66.76,57.84 66.53,58.07 66.53,58.39 66.76,58.62 66.76,58.62 66.76,59.01 66.28,59.49 65.66,59.49
  L16_SIG6 w0.203: 65.66,59.49 v1(65.65,59.5)
N48273893: length 13.1
  L07_SIG3 w0.203: v1(64.38,59.5) 64.83,59.94 67.75,59.94 v1(68.19,59.5) 68.71,58.99 71.49,58.99 v1(72,59.5) 72.57,58.94 75.25,58.94 v1(75.81,59.5)
  BOTTOM w0.381: C7625.2 v1(64.38,59.5)
N48273968: length 3.1
  BOTTOM w0.149: v1(69.46,59.5) 70.09,58.88 70.09,58.19 70.73,57.54 v1(70.73,56.96)
N48274048: length 3.3
  L16_SIG6 w0.081: v1(74.54,56.96) 74.54,58.63 73.68,59.5 v1(73.27,59.5)
N48274138: length 1.8
  L07_SIG3 w0.089: v1(75.81,58.23) v1(77.08,59.5)
N48274174: length 0.8
  BOTTOM w0.381: R6013.2 R6095.1
N48274294: length 0.9
  BOTTOM w0.149: v1(70.73,55.69) 70.12,56.3 R6096.1
N48280620:
  vias: v1(30.33,37.92)
N48280647: length 0.6
  BOTTOM w0.203: v1(32.87,37.92) C7627.2
N48285679:
  vias: v1(17.18,40.36)
N48285771: length 0.9
  BOTTOM w0.149: R6101.2 18.45,37.82 v1(18.45,37.82)
N48285810: length 1.3
  BOTTOM w0.149: C7631.2 21.18,36.97 20.99,37.16 v1(20.99,37.82)
N48285872:
  vias: v1(19.72,37.82)
N48285918: length 2
  BOTTOM w0.149: v1(22.26,39.09) 22.26,38.81 22.45,38.62 C7698.1 R6103.2
N48287444:
  vias: v1(7.2,37.65)
N48287466:
  vias: v1(9.74,37.65)
N48350242: length 34.9
  TOP w0.149: R6061.1 38.19,45.36 38.19,45.37 38.32,45.5 38.33,45.5 38.74,45.92 40.54,45.92 40.94,45.52 41.55,45.52 v1(42.48,44.6)
  L07_SIG3 w0.089: v1(42.48,44.6) 41.48,44.6 40.49,43.6 40.49,41.51 42,40 42,34.81 41.68,34.49 41.68,33.64 42.88,32.45 42.88,28.58 42.78,28.49 42.78,26.12 43.11,25.79 43.73,25.79 46.48,23.04 46.48,22.42 44.96,20.89 v1(44.96,20.44)
N48490558:
  vias: v1(192.34,68.29)
N48495332: length 9.8
  BOTTOM w0.149: v1(71.28,36.26) 72.18,35.36 72.18,31.85 71.78,31.45 R6077.2 70.05,31.07 69.9,30.92 68.34,30.92 68.23,31.04 R6078.2
N48553342: length 7.2
  TOP w0.381: TP1004.1 201.66,60.56 200.9,59.79 199.53,59.79 v1(198.99,60.33) 198.37,60.96 198.37,61.62 198.44,61.7 R6076.1 198.44,62.33 v1(198.99,62.87)
N48553533: length 2.9
  TOP w0.203: v1(196.45,60.33) 196.88,60.77 196.88,61.78 196.45,62.21 v1(196.45,62.87)
N48553549: length 5.6
  L12_SIG4 w0.089: v1(200.26,64.14) 200.9,63.51 200.9,59.7 v1(200.26,59.06)
N48553573:
  vias: v1(200.26,61.6)
N48553577: length 7.7
  BOTTOM w0.203: v1(197.72,64.14) 198.37,63.49 199.25,63.49 199.61,63.13 199.61,60.08 199.25,59.72 198.37,59.72 U116.A3
N48553581: length 7.7
  TOP w0.149: R6053.1 199.68,64.79 199.68,64.31 199.53,64.16 v1(198.99,64.16)
  L12_SIG4 w0.089: v1(198.99,59.06) 199.6,59.67 199.6,63.53 198.99,64.14 v1(198.99,64.16)
N48553597:
  vias: v1(198.99,61.6)
N48746840: length 1.1
  BOTTOM w0.149: v1(18.45,40.36) 18.45,40.27 R6109.2
N48746952: length 1.1
  BOTTOM w0.149: v1(20.99,39.09) 20.99,39.45 20.82,39.61 R6110.2
N48746955: length 7.2
  BOTTOM w0.149: R6111.1 17.81,38.99 18.32,38.48 18.92,38.48 R6109.1 19.17,38.66 20.29,38.66 R6110.1 20.39,38.69 21.59,38.69 R6112.2
N48747048: length 1.7
  BOTTOM w0.149: C7642.1 22.54,37.54 v1(22.26,37.82) 22.24,37.84 R6112.1
N48779487: length 1.8
  BOTTOM w0.149: C7643.1 34.4,37.67 v1(34.14,37.92)
  BOTTOM w0.203: R6116.1 34.03,38.04 v1(34.14,37.92)
N48779506: length 6.8
  BOTTOM w0.149: R6115.1 29.75,39.07 30.13,38.69 30.93,38.69 R6118.1
  BOTTOM w0.203: R6116.2 32.51,38.56 R6117.1 32.2,38.69 31.11,38.69 R6118.1
N48779510: length 1
  BOTTOM w0.203: R6117.2 32.79,39.66 32.87,39.58 v1(32.87,39.19)
N48779522: length 1.3
  BOTTOM w0.203: R6118.2 30.63,39.66 30.33,39.96 v1(30.33,40.46)
N48779884:
  vias: v1(29.06,40.46)
N48784258: length 5.1
  BOTTOM w0.149: v1(22.05,57.1) 22.67,57.72 26.25,57.72 R6121.2
N48784266: length 11
  L16_SIG6 w0.081: v1(15.79,58.47) 15.32,58 14.89,58 14.56,57.67 14.56,57.08 14.35,56.87 14.35,56.08 v1(14.79,55.64)
  BOTTOM w0.149: v1(14.79,55.64) 14.79,55.25 15.25,54.79 16.3,54.79 16.43,54.92 R6125.1 ; R6123.2 R6122.1 15.96,59.64 15.79,59.47 v1(15.79,58.47) 15.79,58.13 15.99,57.93 R6124.1
N48784300: length 5.2
  BOTTOM w0.149: v1(19.51,62.18) 18.96,62.18 18.55,61.78 18.55,60.94 18.16,60.54 R6123.1 17.32,61.33 17,61.65 C7644.1
N48784323: length 5.1
  BOTTOM w0.149: R6124.2 17.75,57.93 18.17,58.35 18.17,59.06 19.48,60.37 20.24,60.37 v1(20.78,60.91)
N48784335: length 6.3
  BOTTOM w0.149: R6125.2 20.9,56.12 21.44,56.67 21.44,57.76 v1(22.05,58.37)
N48786358: length 0.5
  TOP w0.149: v1(6.38,40.26) 6.31,40.19 U142.C5
N48786366: length 5.6
  BOTTOM w0.203: R6130.1 9.28,38.14 10.07,38.14 10.22,37.99 10.22,37.95 10.25,37.92 10.25,36.96 10.44,36.77 R6129.2 10.78,36.2 10.54,35.96 R6128.2
  BOTTOM w0.254: R6130.1 8.04,38.33 R6131.1
N48786400: length 1.1
  BOTTOM w0.203: v1(11.01,37.65) 11.46,37.65 C7645.1
N48786423:
  vias: v1(9.74,38.92)
N48786435: length 1.2
  BOTTOM w0.254: R6131.2 7.45,39.42 7.2,39.68 v1(7.2,40.19)
N48792622:
  vias: v1(31.6,37.92)
N48792865: length 3.8
  BOTTOM w0.149: R6133.1 17.83,57.01 18.55,57.74 18.55,58.68 v1(19.51,59.64)
N48792977:
  vias: v1(8.47,37.65)
N48794434: length 3.9
  BOTTOM w0.149: R6136.1 73.35,87.18 72.69,87.18 R6139.1 72.54,87.2 71.57,87.2 R6138.1 71.14,87.2 70.33,87.2 R6137.2
N48794462: length 3.1
  BOTTOM w0.149: C7651.1 68.6,84.19 v1(69.45,84.19) 70.09,84.82 R6137.1
N48794485: length 1.2
  BOTTOM w0.149: R6138.2 70.89,86.1 70.72,85.93 v1(70.72,85.46)
N48794497: length 0.6
  BOTTOM w0.149: R6139.2 72.62,88 v1(71.99,88)
N48795285: length 1.1
  BOTTOM w0.149: C7652.1 202.63,16.94 v1(203.44,16.94)
N48795308: length 0.7
  BOTTOM w0.203: v1(204.71,18.21) 204.71,18.11 205,17.82 R6143.2
N48795320: length 0.7
  BOTTOM w0.254: v1(205.98,20.75) 205.94,20.79 R6144.2
N48795608: length 9.2
  L12_SIG4 w0.089: v1(206.83,21.39) 206.83,18.47 206.01,17.66 v1(204.11,17.66)
  BOTTOM w0.203: v1(204.11,17.66) 204.11,16.36 203.73,15.98 R6142.2
  BOTTOM w0.254: v1(206.83,21.39) 206.95,21.26 207.38,21.26 207.73,21.61 R6141.1
N48797650: length 1.9
  BOTTOM w0.149: C7702.1 R6100.2
  BOTTOM w0.203: C7702.1 34.69,38.85 34.35,39.19 v1(34.14,39.19)
N48797862: length 2
  BOTTOM w0.254: v1(11.01,38.92) 11.01,38.62 11.26,38.37 C7706.1 R6106.2
N48798047: length 5.7
  L03_SIG1 w0.081: v1(17.46,62.04) 17.71,61.79 20.39,61.79 v1(20.78,62.18)
  BOTTOM w0.149: v1(20.78,62.18) 20.78,63.71 C7707.1
N48798268: length 1.5
  BOTTOM w0.149: v1(70.72,84.19) 70.56,84.02 C7711.1 R6006.2
N48809318:
  vias: v1(185.65,81.37)
N48810027: length 0.7
  BOTTOM w0.381: v1(70.03,66.82) 69.77,66.55 R5931.1
N48818747: length 0.8
  BOTTOM w0.254: R6156.2 191.2,78.55 C2004.1
N48818862: length 3.6
  BOTTOM w0.149: R6154.2 72.16,72.6 73.88,72.6 74.67,71.82 C7660.1
N48819944:
  vias: v1(67.49,71.9)
N48819947: length 1.1
  BOTTOM w0.381: v1(68.76,71.9) 69.41,72.55 R6158.2
N48820208:
  vias: v1(190.73,83.91)
N48820211: length 0.7
  BOTTOM w0.149: v1(190.73,82.64) 190.6,82.51 R6159.2
N49230432: length 1.8
  TOP w0.149: R373.2 5.14,27.65 J8.4
N49230501: length 0.9
  BOTTOM w0.149: U33.3 38.09,34.88 v1(37.68,34.88)
N49230785: length 2.4
  TOP w0.149: U143.13 17.11,23.76 17.23,23.63 R378.2
N49281976: length 1.8
  BOTTOM w0.149: R2707.2 137.23,31.02 U105.10
N49282986: length 13.4
  L16_SIG6 w0.081: v1(28.54,49.74) 28.15,49.34 17.97,49.34 v1(16.08,51.23)
N49300504: length 6.9
  TOP w0.149: v1(29.6,34.18) 30.37,33.41 30.7,33.41 31,33.11 31,32.69 30.7,32.4 30.29,32.4 30.03,32.15 30.03,29.36 U34.E8
N49304849: length 9.9
  TOP w0.149: v1(30.51,34.2) 30.1,34.61 29.45,34.61 29.19,34.35 29.19,33.67 28.97,33.44 28.97,28.77 29.31,28.42 29.97,28.42 U34.F8
  BOTTOM w0.149: R6188.1 30.54,34.17 v1(30.51,34.2)
N49308651: length 1.4
  BOTTOM w0.149: R2714.2 46.03,14.97 46.18,15.12 U106.10
N49328720: length 7.7
  TOP w0.149: v1(28.76,34.18) 27.99,33.41 27.99,28.63 28.22,28.4 28.74,28.4 29.24,27.9 U34.F7
N49421487: length 1.2
  TOP w0.149: U119.21 180.69,56.16 180.69,56.15 180.69,56.05 180.55,55.9 R6196.2
N49460376: length 1.6
  TOP w0.203: v1(174.22,73.86) 174.01,73.66 U121.36
  BOTTOM w0.203: C7681.1 174.03,73.68 v1(174.22,73.86)
N49467702: length 1.1
  TOP w0.149: U120.36 174.45,87.7 C7682.1
N49512760: length 2
  TOP w0.149: C7691.1 174.81,45.12 173.81,45.12 173.54,44.85 U126.36
N49513184: length 1.1
  TOP w0.203: C7692.1 174.27,59.66 U125.36
N49539229: length 0.8
  BOTTOM w0.149: R6201.2 192.33,82.97 v1(192,82.64)
N49540456: length 0.7
  BOTTOM w0.149: v1(73.84,70.63) 73.53,70.94 TP29.1
N49541279: length 0.6
  BOTTOM w0.149: R6202.2 v1(68.76,73.17)
N49586047:
  vias: v1(212.86,101.84)
N49664632: length 2
  BOTTOM w0.149: R2794.1 67.93,37.48 C7723.1 68.45,38.29 v1(68.88,37.86)
N49665924: length 7
  L03_SIG1 w0.203: v1(20.99,40.36) 20.37,40.98 20.37,43.26 18.53,45.1 17.89,45.1 v1(17.43,44.64)
N49666814: length 6.5
  TOP w0.149: U124.C2 32.96,40.46 33.69,39.74 35.91,39.74 36.51,40.33 v1(36.51,42.61)
N49667985: length 8.5
  L05_SIG2 w0.381: v1(8.86,33.85) 9.98,33.85 10.33,34.2 10.33,39.59 v1(9.74,40.19)
  BOTTOM w0.381: v1(8.86,33.85) 9.48,33.85 R6221.2
N49668581: length 5.3
  BOTTOM w0.149: v1(22.05,60.91) 21.42,61.55 20.65,61.55 20.23,61.97 20.23,63.67 19.76,64.14 R6222.2
N49934644: length 50.3
  TOP w0.149: U120.34 173.84,86.7 173.92,86.62 174.55,86.62 v1(174.67,86.73)
  L07_SIG3 w0.089: v1(174.67,86.73) 174.67,86.62 173.73,85.68 173.34,85.68 173.21,85.81 173.21,86.2 172.05,87.36 170.93,87.36 169.94,86.37 169.93,86.37 169.67,86.11 169.67,86.1 165.03,81.46 165.03,70.97 168.85,67.14 176.27,67.14 176.94,66.47 176.94,65.28 176.88,65.22 176.88,64.89 178.44,63.32 178.44,56.92 v1(177.93,56.41)
  BOTTOM w0.149: v1(177.93,56.41) 177.9,56.41 177.9,56.45 177.9,56.46 R6255.2
N49934684: length 45.4
  TOP w0.149: v1(176.02,51.72) 176.01,51.72 176.01,52.55 175.61,52.95 175.61,53.74 175.34,54.01 R6256.2
  TOP w0.203: U121.34 174.6,72.66 v1(174.64,72.62)
  L07_SIG3 w0.089: v1(174.64,72.62) 174.28,72.98 168.97,72.98 167.34,71.35 167.34,69 168.95,67.39 176.44,67.39 177.4,66.43 177.4,65.71 177.81,65.3 177.81,64.42 178.9,63.33 178.9,57.56 179.74,56.72 179.74,55.41 180,55.15 180,54.3 180.29,54.01 180.29,52.51 180.12,52.34 176.63,52.34 176.02,51.73 v1(176.02,51.72)
N49934953: length 8.2
  TOP w0.149: v1(174.52,58.33) 174.46,58.33 174.33,58.46 174.07,58.46 173.87,58.66 U125.34 ; R6257.2 176.08,54.3 176.08,53.27 176.08,53.27 v1(176.08,53.2)
  BOTTOM w0.149: v1(174.52,58.33) 174.52,58.06 174.86,57.72 174.86,56.95 174.99,56.82 174.99,56.57 175.5,56.07 175.54,55.97 175.54,55.17 175.67,55.04 175.67,53.8 176.08,53.38 v1(176.08,53.2)
N49934989: length 14.4
  TOP w0.149: U126.34 173.36,43.87 173.79,43.87 174.13,44.21 v1(174.18,44.21)
  BOTTOM w0.149: R6258.2 176.11,54.5 176.11,53.86 176.56,53.41 176.56,53.15 v1(176.79,52.92) 176.75,52.92 176.62,52.79 175.54,52.79 174.69,51.93 174.69,50.03 175.79,48.93 175.79,45.6 174.4,44.21 v1(174.18,44.21)
N49972833: length 3.4
  L03_SIG1 w0.081: v1(183.14,67.82) 183.92,67.04 184.44,67.04 184.65,67.26 184.65,67.26 184.73,67.34 184.76,67.37 185.22,67.37 185.64,66.94 v1(185.86,66.94)
N50006329: length 1.7
  TOP w0.149: C7761.1 233.18,39.11 U137.25
N50006362: length 2.9
  TOP w0.149: U137.24 232.68,40.15 232.06,39.53 C7781.1 R6262.1
N50006438: length 2.3
  TOP w0.149: R6263.1 235.16,39.55 234.96,39.75 234.5,39.75 234.18,40.07 U137.27
N50006442: length 4.5
  TOP w0.149: R6264.2 230.27,39.62 231.48,39.62 232.18,40.33 U137.23
  TOP w0.254: R6264.2 R6266.2 C7764.1
N50006446: length 1.7
  TOP w0.254: R6266.1 C7764.2 R6271.2
N50006595: length 12.5
  TOP w0.149: v1(236.8,39.66) 236.56,39.66 235.95,40.28 235.95,41.33 235.8,41.48 U137.1 ; TP1005.1 234.18,34.31 v1(234.14,34.34)
  BOTTOM w0.254: v1(236.8,39.66) 236.8,38.52 236.63,38.36 236.63,37.98 236.79,37.82 236.79,34.95 236.18,34.34 v1(234.14,34.34)
N50006597: length 2.3
  TOP w0.149: R6270.2 229.89,40.88 230.2,41.18 R6288.1 230.4,41.48 U137.22
N50006631: length 1.2
  TOP w0.254: U137.3 236.48,42.48 v1(236.6,42.37)
N50087078: length 1.5
  TOP w0.203: U120.32 173.81,85.7 174.03,85.92 174.41,85.92 R6273.2
N50087130: length 1.5
  TOP w0.203: U121.32 173.54,71.61 174.85,71.61 R6274.2
N50087259: length 2.2
  TOP w0.149: U125.32 173.87,57.66 174.08,57.87 174.89,57.87 175.32,57.44 R6275.2
N50087315: length 2.7
  TOP w0.149: v1(174.31,42.74) 174.26,42.79 174.01,42.79 173.95,42.85 U126.32
  BOTTOM w0.203: R6276.2 174.56,43 v1(174.31,42.74)
N50532265: length 0.7
  TOP w0.149: R6262.2 C7780.1
N51024969: length 0.9
  BOTTOM w0.149: R2794.2 67.02,36.87 R6287.2
N51025331: length 1.8
  TOP w0.149: R6264.1 229.29,39.54 229.29,41.26 R6288.2
N51307354: length 2
  TOP w0.149: U119.27 183.51,57.03 v1(183.14,56.66)
  BOTTOM w0.149: R6195.1 182.05,56.59 183.06,56.59 v1(183.14,56.66)
N51308385: length 3.9
  TOP w0.149: v1(177.91,54.62) 177.91,54.62 177.81,54.71 177.81,55.68 178.11,55.98 179.74,55.98 179.89,56.13 U119.19
N51791916: length 2.9
  TOP w0.149: U119.13 177.86,58.94 177.66,58.74 177.62,58.74 177.06,58.17 v1(177.06,58.14)
  BOTTOM w0.149: R6279.2 177.1,57.7 177.06,57.73 v1(177.06,58.14)
N51798670: length 8.8
  TOP w0.149: U119.35 183.94,60.54 184.26,60.86 184.26,61.53 v1(184.42,61.68)
  L14_SIG5 w0.081: v1(184.42,61.68) 185.08,62.35 190.59,62.35 v1(191.04,62.79)
N51913133: length 3.4
  BOTTOM w0.149: R196.1 138.36,32.39 138.81,31.94 U19.4 140.03,31.45 140.02,31.45 R6299.2
N51915113: length 76.7
  TOP w0.149: R6305.1 198.75,90.16 v1(198.41,90.5)
  L16_SIG6 w0.081: v1(133.07,70.46) 133.46,70.46 arc(133.5,70.47) 133.53,70.49 133.76,70.72 arc(133.79,70.74) 133.83,70.75 134.5,70.75 arc(134.54,70.75) 134.58,70.78 135.2,71.4 arc(135.23,71.42) 135.27,71.43 135.92,71.43 arc(135.96,71.44) 135.99,71.46 136.94,72.41 arc(136.98,72.44) 137.02,72.44 137.92,72.44 arc(137.96,72.44) 137.99,72.41 138.15,72.26 arc(138.18,72.24) 138.22,72.23 138.44,72.23 arc(138.48,72.24) 138.52,72.26 138.99,72.74 arc(139.03,72.76) 139.07,72.77 139.33,72.77 arc(139.37,72.77) 139.4,72.8 139.8,73.2 arc(139.83,73.22) 139.87,73.23 140.18,73.23 arc(140.22,73.24) 140.25,73.26 140.41,73.42 arc(140.43,73.45) 140.44,73.49 140.44,74.09 arc(140.44,74.13) 140.47,74.16 141.21,74.9 arc(141.24,74.92) 141.28,74.93 141.8,74.93 arc(141.84,74.94) 141.87,74.96 142.45,75.55 arc(142.49,75.57) 142.53,75.58 142.99,75.58 arc(143.03,75.58) 143.06,75.61 143.43,75.97 arc(143.46,75.99) 143.5,76 145.91,76 arc(145.95,76.01) 145.98,76.03 148.15,78.2 arc(148.19,78.22) 148.23,78.23 152.93,78.23 arc(152.96,78.24) 153,78.26 156.08,81.34 arc(156.11,81.36) 156.15,81.37 183.86,81.37 arc(183.9,81.36) 183.93,81.34 184.21,81.07 arc(184.24,81.05) 184.28,81.04 184.75,81.04 arc(184.79,81.05) 184.82,81.07 185.46,81.71 arc(185.5,81.73) 185.54,81.74 185.76,81.74 arc(185.8,81.73) 185.83,81.71 185.94,81.6 arc(185.98,81.58) 186.01,81.57 186.55,81.57 arc(186.59,81.58) 186.62,81.6 186.73,81.71 arc(186.77,81.73) 186.81,81.74 187.87,81.74 arc(187.91,81.75) 187.95,81.77 189.24,83.07 arc(189.28,83.09) 189.32,83.1 193.04,83.1 arc(193.08,83.11) 193.12,83.13 195.04,85.05 195.04,85.05 195.41,85.43 arc(195.45,85.45) 195.49,85.46 195.57,85.46 arc(195.6,85.46) 195.62,85.48 195.9,85.76 arc(195.92,85.79) 195.93,85.83 195.93,85.99 arc(195.94,86.03) 195.96,86.06 196.27,86.37 arc(196.31,86.39) 196.35,86.4 196.45,86.4 arc(196.49,86.41) 196.53,86.43 197.44,87.34 arc(197.46,87.38) 197.47,87.42 197.47,89.66 arc(197.48,89.7) 197.5,89.73 198.01,90.24 arc(198.04,90.26) 198.08,90.27 198.15,90.27 arc(198.18,90.28) 198.21,90.29 v1(198.41,90.5)
