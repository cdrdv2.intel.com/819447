# Allegro board FM85_AGILEX_PCIE_DK_CMC_ADI_REVC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CXL_TX_P12: length 80.8
  L03_SIG1 w0.085: v2(135.73,56.1) 135.46,55.94 arc(135.4,55.93) 135.35,55.97 135.29,56.07 arc(135.27,56.16) 135.29,56.26 135.32,56.31 arc(135.51,56.49) 135.76,56.56 135.78,56.56 arc(135.99,56.6) 136.16,56.72 136.35,56.9 arc(136.42,56.95) 136.51,56.97 136.65,56.97 arc(136.75,56.95) 136.82,56.88 136.83,56.87 arc(136.83,56.87) 136.83,56.87 arc(136.83,56.87) 136.84,56.86 136.93,56.7 arc(137.12,56.5) 137.39,56.43 137.48,56.43 arc(137.64,56.39) 137.75,56.27 137.81,56.18 arc(137.99,56) 138.23,55.93 138.44,55.93 arc(138.68,56) 138.85,56.17 138.92,56.28 arc(139.07,56.44) 139.27,56.5 arc(139.42,56.53) 139.55,56.62 139.77,56.84 arc(139.87,56.91) 139.99,56.93 140.14,56.93 arc(140.4,57) 140.59,57.19 140.63,57.26 arc(140.76,57.39) 140.94,57.43 141.07,57.43 arc(141.28,57.49) 141.44,57.65 141.53,57.81 arc(141.63,57.91) 141.77,57.95 141.89,57.95 arc(141.99,57.93) 142.08,57.87 142.25,57.7 arc(142.4,57.6) 142.58,57.56 142.68,57.56 arc(142.9,57.5) 143.05,57.34 143.07,57.32 arc(143.26,57.13) 143.53,57.06 143.67,57.06 arc(143.78,57.03) 143.86,56.95 143.97,56.76 arc(144.16,56.57) 144.43,56.5 144.89,56.5 145.05,56.34 145.23,56.34 145.39,56.5 145.98,56.5 arc(146.02,56.5) 146.06,56.53 146.3,56.77 146.53,56.77 146.65,56.89 146.65,57.13 146.78,57.25 147.01,57.25 147.13,57.37 147.13,57.61 147.48,57.96 arc(147.79,58.16) 148.15,58.23 152.24,58.23 arc(153.05,58.39) 153.74,58.85 arc(154.1,59.09) 154.53,59.18 168.71,59.18 arc(168.89,59.22) 169.05,59.32 arc(169.1,59.36) 169.17,59.37 173.88,59.37 arc(174.12,59.42) 174.32,59.55 174.36,59.59 arc(175.01,59.85) 175.65,59.59 175.89,59.35 arc(176.04,59.25) 176.22,59.21 176.4,59.21 arc(176.56,59.24) 176.69,59.33 arc(176.72,59.35) 176.75,59.35 177.21,59.35 arc(177.25,59.35) 177.29,59.33 177.7,59 arc(178.39,58.63) 179.17,58.5 arc(179.22,58.49) 179.28,58.49 182.6,58.49 arc(182.8,58.45) 182.96,58.34 183.09,58.22 arc(183.9,57.68) 184.85,57.49 196.28,57.49 arc(196.56,57.51) 196.84,57.57 arc(196.87,57.58) 196.9,57.59 197.3,57.74 arc(197.39,57.77) 197.47,57.81 arc(197.69,57.88) 197.92,57.91 207.24,57.91 arc(207.85,57.79) 208.37,57.44 arc(208.98,57.03) 209.71,56.89 210.11,56.89 arc(210.24,56.89) 210.36,56.88 210.38,56.88 v2(210.61,56.66)
CXL_TX_P13: length 80.4
  L03_SIG1 w0.085: v2(138.33,56.6) 138.12,56.78 arc(138.06,56.85) 138.07,56.94 138.11,57 arc(138.11,57.01) 138.12,57.02 arc(138.15,57.04) 138.19,57.05 138.44,57.05 arc(138.6,57.08) 138.73,57.17 138.99,57.43 arc(139.06,57.48) 139.14,57.5 139.21,57.5 arc(139.44,57.56) 139.6,57.72 139.68,57.86 arc(139.83,58) 140.03,58.06 140.09,58.06 arc(140.34,58.12) 140.52,58.3 arc(140.7,58.49) 140.96,58.56 140.98,58.56 arc(141.15,58.59) 141.28,58.68 141.5,58.9 arc(141.59,58.96) 141.69,58.98 141.78,58.98 arc(141.94,58.94) 142.06,58.82 142.14,58.67 arc(142.32,58.5) 142.55,58.43 142.66,58.43 arc(142.83,58.39) 142.95,58.27 142.96,58.25 arc(143.19,58.02) 143.52,57.93 143.61,57.93 arc(143.72,57.91) 143.81,57.85 144.02,57.64 arc(144.18,57.53) 144.37,57.5 144.69,57.5 144.8,57.38 145.08,57.38 145.2,57.5 145.48,57.5 145.68,57.69 145.84,57.69 146.04,57.89 146.04,58.05 146.81,58.83 147.39,59.21 148.81,59.8 152.71,59.8 arc(153.07,59.87) 153.37,60.07 153.57,60.27 arc(153.66,60.33) 153.77,60.36 171.29,60.36 arc(172.27,60.55) 173.11,61.11 arc(173.56,61.41) 174.11,61.52 175.08,61.52 arc(175.3,61.48) 175.49,61.35 176.12,60.72 arc(176.67,60.35) 177.31,60.23 177.92,60.23 arc(178.39,60.13) 178.79,59.87 arc(179.09,59.67) 179.44,59.6 182.17,59.6 arc(182.69,59.49) 183.14,59.19 183.25,59.08 arc(184.07,58.54) 185.03,58.35 189.64,58.35 arc(190.67,58.5) 191.61,58.94 arc(191.66,58.98) 191.71,59.02 192.91,60.22 arc(193.43,60.62) 194.03,60.86 arc(194.07,60.87) 194.11,60.87 204.69,60.87 arc(204.73,60.87) 204.78,60.86 arc(205.12,60.7) 205.43,60.46 arc(205.69,60.28) 206.01,60.22 208.25,60.22 arc(208.77,60.11) 209.22,59.82 210.26,58.77 arc(210.36,58.71) 210.48,58.68 212.32,58.68 arc(212.36,58.68) 212.4,58.65 v2(212.59,58.46)
CXL_TX_P14: length 81.4
  L03_SIG1 w0.085: v2(210.61,63.86) 210.38,64.08 209.55,64.08 arc(209.49,64.09) 209.42,64.1 209.42,64.11 209.39,64.12 arc(209.38,64.12) 209.36,64.12 208.74,64.12 arc(208.67,64.11) 208.59,64.09 207.2,63.4 arc(206.55,63.14) 205.87,62.99 arc(205.85,62.99) 205.83,62.99 202.23,62.99 arc(201.7,62.88) 201.24,62.58 200.95,62.29 arc(200.8,62.19) 200.63,62.15 195.46,62.15 arc(195.33,62.13) 195.2,62.08 arc(195.07,62.03) 194.94,62.01 194.16,62.01 arc(194.04,62.02) 193.93,62.05 193.72,62.14 arc(193.68,62.15) 193.64,62.15 184.25,62.15 arc(184.24,62.15) 184.23,62.15 arc(183.94,62.06) 183.67,61.92 arc(183.1,61.66) 182.49,61.58 179.61,61.58 arc(179.16,61.67) 178.79,61.92 177.89,62.82 arc(177.71,62.93) 177.51,62.97 176.73,62.97 arc(176.61,62.99) 176.5,63.02 arc(176.43,63.06) 176.37,63.11 175.53,63.95 arc(174.73,64.49) 173.77,64.68 172.21,64.68 arc(171.42,64.52) 170.76,64.08 169.13,62.45 arc(168.32,61.91) 167.36,61.72 149.76,61.72 148.06,61.38 arc(148.05,61.38) 148.05,61.38 147.2,61.03 arc(147.12,61) 147.04,61 146.95,61 arc(146.91,60.99) 146.87,60.96 146.78,60.87 146.5,60.87 146.37,61 146.09,61 145.96,60.87 145.68,60.87 145.56,61 145.28,61 145.15,60.87 144.87,60.87 144.74,61 144.47,61 144.34,60.87 144.06,60.87 143.93,61 143.45,61 arc(143.32,60.96) 143.22,60.86 143.1,60.66 arc(142.94,60.49) 142.71,60.43 142.59,60.43 arc(142.5,60.41) 142.42,60.36 142.18,60.13 arc(142.04,60.03) 141.88,60 141.76,60 arc(141.66,59.97) 141.58,59.89 141.48,59.71 arc(141.27,59.51) 140.99,59.43 140.91,59.43 arc(140.76,59.39) 140.65,59.28 140.63,59.25 arc(140.4,59.02) 140.09,58.93 139.95,58.93 arc(139.87,58.92) 139.8,58.87 139.55,58.62 arc(139.41,58.53) 139.25,58.5 139.21,58.5 arc(139.07,58.46) 138.96,58.35 138.85,58.17 arc(138.68,58) 138.44,57.93 138.23,57.93 arc(137.99,58) 137.81,58.18 137.76,58.27 arc(137.63,58.39) 137.47,58.43 137.37,58.43 arc(137.12,58.5) 136.94,58.68 136.84,58.86 arc(136.74,58.96) 136.6,59 136.53,59 arc(136.45,58.98) 136.37,58.93 136.16,58.72 arc(135.99,58.6) 135.78,58.56 135.66,58.56 arc(135.55,58.54) 135.46,58.49 arc(135.43,58.47) 135.4,58.43 135.29,58.24 arc(135.27,58.15) 135.29,58.07 135.35,57.97 arc(135.4,57.93) 135.46,57.94 v2(135.73,58.1)
CXL_TX_P15: length 80.9
  L03_SIG1 w0.085: v2(138.33,58.6) 138.12,58.78 arc(138.06,58.85) 138.07,58.94 138.09,58.98 arc(138.1,58.99) 138.1,58.99 arc(138.15,59.03) 138.21,59.05 138.45,59.05 arc(138.54,59.06) 138.63,59.1 arc(138.69,59.14) 138.75,59.18 138.97,59.4 arc(139.07,59.47) 139.2,59.5 139.25,59.5 arc(139.44,59.55) 139.59,59.7 139.73,59.93 arc(139.82,60.02) 139.94,60.06 140.07,60.06 arc(140.34,60.13) 140.53,60.32 140.59,60.42 arc(140.68,60.52) 140.82,60.56 141.03,60.56 arc(141.19,60.59) 141.33,60.68 141.58,60.93 arc(141.65,60.98) 141.74,61 141.83,61 arc(142.04,61.05) 142.2,61.21 142.32,61.43 arc(142.42,61.52) 142.55,61.56 142.71,61.56 arc(142.88,61.59) 143.01,61.68 143.16,61.83 arc(143.28,61.91) 143.42,61.94 143.9,61.94 144.01,61.83 144.29,61.83 144.4,61.94 144.68,61.94 144.8,61.83 145.08,61.83 145.19,61.94 145.79,61.94 arc(145.83,61.94) 145.87,61.95 150.06,62.78 arc(150.07,62.79) 150.08,62.79 154.42,62.79 arc(154.55,62.76) 154.67,62.7 arc(154.78,62.64) 154.91,62.62 163.62,62.62 arc(163.91,62.68) 164.15,62.84 164.95,63.64 arc(165.2,63.81) 165.49,63.87 167.35,63.87 arc(168.43,64.08) 169.36,64.68 arc(170.23,65.25) 171.25,65.44 arc(172.27,65.56) 173.23,65.89 arc(173.69,66.07) 174.17,66.19 arc(174.21,66.19) 174.25,66.2 174.36,66.2 arc(175.01,66.07) 175.56,65.69 177.28,63.98 arc(177.55,63.78) 177.87,63.66 arc(177.94,63.65) 178,63.64 187.22,63.64 arc(188.32,63.83) 189.3,64.38 arc(189.33,64.41) 189.36,64.44 arc(189.6,64.59) 189.88,64.65 191.19,64.65 arc(191.24,64.65) 191.29,64.65 arc(191.3,64.65) 191.31,64.65 191.59,64.67 arc(191.7,64.69) 191.81,64.73 arc(191.92,64.79) 192.03,64.86 arc(192.15,64.94) 192.25,65.04 192.35,65.13 arc(192.53,65.28) 192.76,65.36 arc(192.76,65.37) 192.76,65.37 195.47,65.37 arc(195.95,65.46) 196.36,65.73 196.39,65.76 arc(196.57,65.89) 196.78,65.93 198.21,65.93 arc(198.9,66.07) 199.49,66.46 199.58,66.55 arc(199.72,66.64) 199.87,66.67 200.91,66.67 arc(201.4,66.57) 201.83,66.29 203.89,64.22 arc(204.1,64.08) 204.35,64.03 206.34,64.03 arc(206.48,64.06) 206.59,64.14 207.72,65.26 arc(208.29,65.65) 208.97,65.79 212.46,65.79 v2(212.59,65.66)
DAOUT0: length 5.8
  TOP w0.149: U119.11 v1(177.81,59.74) 177.81,59.74 177.41,59.34 176.4,59.34 R5875.1
  BOTTOM w0.149: R6291.2 176.8,60.47 177.51,60.47 177.68,60.3 177.68,59.87 v1(177.81,59.74) 178.06,60 178.06,60.19 178.21,60.34 C7678.2
DDR4_COMP_CH0_A0: length 83.9
  L03_SIG1 w0.081: v1(106.76,40.53) 107.16,39.84 arc(107.32,39.67) 107.55,39.61 107.56,39.61 arc(107.79,39.54) 107.95,39.38 107.96,39.37 arc(108.12,39.21) 108.35,39.15 108.36,39.15 arc(108.58,39.08) 108.75,38.92 arc(108.81,38.69) 108.75,38.46 arc(108.69,38.23) 108.74,38.01 108.76,37.99 arc(108.81,37.76) 108.75,37.54 108.48,37.26 108.38,37.26 107.95,36.83 107.95,35.68 108.9,34.74 114.71,34.74 116.11,33.34 116.71,33.34 117.26,32.79 117.26,32.11 117.88,31.49 arc(118.23,30.97) 118.36,30.35 118.36,29.65 118.27,29.56 117.88,29.56 117.8,29.48 117.8,29.31 117.88,29.23 118.3,29.23 118.38,29.15 118.38,28.98 118.3,28.89 117.9,28.89 117.82,28.81 117.82,28.64 117.9,28.56 118.2,28.56 118.28,28.48 118.28,19.29 116.33,17.35 114.12,17.35 114.04,17.43 114.04,17.77 113.96,17.85 111.95,17.85 v1(111.26,18.54)
  L07_SIG3 w0.089: v1(70.59,18.53) 71.01,18.95 77.42,18.95 77.5,18.88 78.44,18.88 78.51,18.94 80.38,18.94 v1(80.78,18.54) 81.18,18.94 90.54,18.94 v1(90.94,18.54) 91.34,18.94 92.14,18.94 92.33,18.75 92.47,18.75 92.66,18.94 100.7,18.94 v1(101.1,18.54) 101.5,18.94 107.66,18.94 107.74,19.03 107.74,19.26 107.85,19.37 107.98,19.37 108.09,19.26 108.09,19.03 108.18,18.94 110.86,18.94 v1(111.26,18.54)
DDR4_COMP_CH0_A1: length 84.5
  L05_SIG2 w0.081: v1(114.46,18.54) 113.28,17.36 104.94,17.36 104.66,17.65 104.66,17.95 104.3,18.3 v1(104.3,18.54) 103.11,17.35 94.79,17.35 94.5,17.65 94.5,17.89 94.14,18.25 v1(94.14,18.54) 92.97,17.37 84.62,17.37 84.41,17.59 84.41,18.11 v1(83.98,18.54) 82.8,17.36 76.14,17.36 75.76,17.74 75.76,17.89 75.55,18.1 74.43,18.1 74,18.53 v1(73.79,18.53)
  L16_SIG6 w0.081: v1(114.46,18.54) 113.63,18.54 113.55,18.62 113.55,18.79 113.47,18.87 113.3,18.87 113.22,18.79 113.22,18.44 113.14,18.36 112.96,18.36 112.88,18.44 112.88,18.89 112.8,18.97 112.63,18.97 112.55,18.89 112.55,18.49 112.47,18.41 112.02,18.41 111.89,18.54 111.89,19.12 112.07,19.31 113.91,19.31 113.99,19.39 113.99,19.56 113.91,19.64 112.15,19.64 112.04,19.75 112.04,19.9 112.12,19.98 113.91,19.98 113.98,20.05 113.98,20.25 113.92,20.31 113.04,20.31 112.92,20.43 112.92,21.11 113.16,21.35 113.98,21.35 114.09,21.45 114.09,28.04 114.43,28.39 114.43,29.49 114.09,29.83 114.09,31.32 113.29,32.11 112.85,32.11 112.76,32.21 112.76,33 112.63,33.12 110.46,33.12 107.62,35.96 107.62,36.94 107.17,37.39 106.64,37.39 106.63,37.4 106.6,37.4 106.33,37.67 106.33,37.89 arc(106.34,37.95) 106.36,38 arc(106.42,38.22) 106.36,38.45 106.36,38.46 arc(106.3,38.68) 106.36,38.91 106.36,38.92 arc(106.42,39.15) 106.36,39.38 v1(105.96,40.07)
DDR4_COMP_CH0_A2: length 84.3
  L03_SIG1 w0.081: v1(106.76,41.45) 107.13,40.8 arc(107.15,40.77) 107.18,40.74 arc(107.36,40.61) 107.56,40.53 arc(107.79,40.46) 107.95,40.3 arc(108.12,40.13) 108.35,40.07 108.36,40.07 arc(108.58,40) 108.75,39.84 109.31,39.52 arc(109.32,39.51) 109.33,39.5 109.45,39.38 arc(109.51,39.29) 109.53,39.19 109.53,37.92 arc(109.53,37.88) 109.51,37.84 109.18,37.03 arc(109.08,36.82) 108.95,36.62 arc(108.8,36.38) 108.69,36.12 arc(108.68,36.08) 108.68,36.04 108.68,35.33 arc(108.68,35.29) 108.71,35.26 108.87,35.1 arc(108.99,35.02) 109.13,34.99 114.46,34.99 arc(115.54,34.78) 116.46,34.16 117.27,33.35 arc(117.44,33.1) 117.5,32.8 117.5,32.53 arc(117.55,32.23) 117.72,31.98 118.16,31.55 arc(118.44,31.15) 118.59,30.68 arc(118.59,30.64) 118.59,30.59 118.59,18.98 arc(118.58,18.94) 118.56,18.9 116.23,16.57 112.43,16.57 v1(111.26,17.74)
  L07_SIG3 w0.089: v1(111.26,17.74) 110.87,17.35 101.49,17.35 v1(101.1,17.74) 100.7,17.34 92.69,17.34 92.6,17.25 92.6,17.07 92.5,16.98 92.35,16.98 92.26,17.07 92.26,17.25 92.17,17.34 91.34,17.34 v1(90.94,17.74) 90.54,17.34 87.95,17.34 87.86,17.43 87.86,17.69 87.77,17.78 87.6,17.78 87.51,17.69 87.51,17.43 87.42,17.34 81.18,17.34 v1(80.78,17.74) 80.4,17.36 73.2,17.36 73.03,17.53 72.86,17.53 72.68,17.36 72.51,17.36 72.34,17.53 72.17,17.53 72,17.36 71.83,17.36 71.65,17.53 71.48,17.53 71.31,17.36 70.97,17.36 v1(70.59,17.73)
DDR4_COMP_CH0_A3: length 84
  L05_SIG2 w0.081: v1(114.46,19.34) 113.23,18.11 105,18.11 104.66,18.45 104.66,18.69 104.3,19.05 v1(104.3,19.34) 103.1,18.14 94.82,18.14 94.5,18.46 94.5,18.69 94.14,19.05 v1(94.14,19.34) 92.95,18.15 84.64,18.15 84.41,18.39 84.41,18.62 83.98,19.05 v1(83.98,19.34) 82.78,18.14 82.32,18.14 82.24,18.22 82.24,18.35 82.16,18.44 82,18.44 81.92,18.35 81.92,18.22 81.84,18.14 81.67,18.14 81.59,18.22 81.59,18.35 81.51,18.44 81.35,18.44 81.27,18.35 81.27,18.22 81.19,18.14 78.24,18.14 78.08,18.3 76.38,18.3 75.78,18.9 74.37,18.9 73.95,19.33 v1(73.79,19.33)
  L16_SIG6 w0.081: v1(105.96,41.91) 105.94,41.9 105.91,41.79 106.3,41.12 arc(106.38,41.04) 106.48,41.01 106.73,40.99 arc(106.74,40.98) 106.75,40.98 106.87,40.94 arc(106.92,40.92) 106.96,40.89 arc(107.06,40.81) 107.13,40.7 arc(107.16,40.63) 107.17,40.54 107.17,40 arc(107.2,39.86) 107.28,39.74 107.41,39.61 arc(107.51,39.54) 107.63,39.52 107.72,39.52 arc(107.8,39.5) 107.87,39.46 107.95,39.38 108.04,39.23 arc(108.06,39.15) 108.04,39.07 107.89,38.81 arc(107.86,38.69) 107.89,38.57 108.01,38.35 arc(108.05,38.23) 108.01,38.1 107.91,37.92 arc(107.87,37.77) 107.91,37.61 107.95,37.54 108.16,37.33 109.17,37.33 109.32,37.17 109.32,37.04 108.32,36.04 108.32,35.92 108.45,35.79 108.61,35.79 109.33,36.51 109.55,36.51 110.06,36 110.06,35.75 109.93,35.62 109.93,35.44 110.01,35.36 110.24,35.36 110.5,35.61 110.5,36.24 110.59,36.34 110.75,36.34 110.83,36.26 110.83,35.8 111.38,35.25 111.71,35.25 112.04,35.58 112.15,35.58 113.85,33.88 113.85,33.42 114.08,33.19 114.17,33.19 114.65,32.71 114.65,32.09 115.29,31.45 115.7,30.64 115.7,30.48 115.57,30.36 115.13,30.36 115.05,30.28 115.05,30.1 115.13,30.02 115.89,30.02 116.01,29.9 116.01,29.79 115.9,29.69 115.13,29.69 115.05,29.61 115.05,29.43 115.13,29.35 115.57,29.35 115.66,29.27 115.66,21.52 115.5,21.37 115.07,21.37 114.88,21.18 114.88,19.13 114.76,19.01 114.58,19.01 114.46,19.13 v1(114.46,19.34)
DDR4_COMP_CH0_A4: length 83.6
  L07_SIG3 w0.089: v1(70.59,19.33) 71,19.74 71.34,19.74 71.51,19.91 71.68,19.91 71.86,19.74 72.03,19.74 72.2,19.91 72.37,19.91 72.54,19.74 72.71,19.74 72.89,19.91 73.06,19.91 73.23,19.74 80.38,19.74 v1(80.78,19.34) 81.18,19.74 87.31,19.74 87.4,19.65 87.4,19.3 87.48,19.21 87.65,19.21 87.74,19.3 87.74,19.65 87.83,19.74 90.54,19.74 v1(90.94,19.34) 91.34,19.74 91.94,19.74 92.03,19.65 92.03,19.42 92.12,19.33 92.28,19.33 92.37,19.42 92.37,19.65 92.46,19.74 100.7,19.74 v1(101.1,19.34) 101.5,19.74 107.21,19.74 107.3,19.83 107.3,20.08 107.38,20.17 107.55,20.17 107.64,20.08 107.64,19.83 107.73,19.74 110.86,19.74 v1(111.26,19.34)
  L16_SIG6 w0.081: v1(105.16,40.53) 104.76,39.83 arc(104.6,39.67) 104.37,39.61 104.36,39.61 arc(104.13,39.54) 103.97,39.38 arc(103.91,39.15) 103.97,38.92 103.97,38.91 arc(104.03,38.68) 103.97,38.46 arc(103.93,38.38) 103.91,38.29 103.91,38.15 arc(103.96,37.91) 104.1,37.7 104.77,37.03 104.77,36.33 108.51,32.59 108.51,32.23 108.59,32.15 108.85,32.15 108.93,32.07 108.93,31.89 108.85,31.81 108.59,31.81 108.51,31.73 108.51,24.8 108.59,24.72 109.36,24.72 109.46,24.62 109.46,24.48 109.36,24.38 108.51,24.38 108.43,24.3 108.43,24.14 108.52,24.05 109.19,24.05 109.27,23.96 109.27,23.79 109.19,23.71 108.51,23.71 108.43,23.63 108.43,23.47 108.52,23.38 109.19,23.38 109.27,23.29 109.27,23.12 109.19,23.04 108.53,23.04 108.42,22.93 108.42,22.79 108.5,22.7 109.19,22.7 109.27,22.62 109.27,22.45 109.19,22.37 108.53,22.37 108.42,22.26 108.42,22.12 108.5,22.03 109.19,22.03 109.27,21.95 109.27,21.78 109.19,21.7 108.47,21.7 108.39,21.61 108.39,21.44 108.47,21.36 109.19,21.36 109.27,21.28 109.27,21.11 109.19,21.03 108.47,21.03 108.39,20.94 108.39,20.77 108.47,20.69 109.35,20.69 109.44,20.61 109.44,20.44 109.35,20.36 108.53,20.36 108.41,20.25 108.41,19.9 108.55,19.77 108.79,19.77 108.87,19.69 108.87,19.34 108.97,19.25 109.13,19.25 109.21,19.33 109.21,19.6 109.38,19.77 111.18,19.77 111.26,19.69 v1(111.26,19.34)
DDR4_COMP_CH0_A5: length 86.9
  L03_SIG1 w0.081: v1(104.37,40.07) 104.77,39.37 arc(104.94,39.21) 105.16,39.15 105.17,39.15 arc(105.4,39.08) 105.56,38.92 105.56,38.91 arc(105.73,38.75) 105.96,38.69 arc(106.19,38.62) 106.36,38.46 arc(106.53,38.29) 106.75,38.23 106.85,38.23 arc(107,38.19) 107.11,38.08 107.16,38 arc(107.23,37.81) 107.26,37.61 107.26,37.47 107.14,37.35 106.94,37.35 106.86,37.27 106.86,37.11 106.95,37.01 107.23,37.01 107.34,36.91 107.34,36.34 107.25,36.25 106.68,36.25 106.6,36.17 106.6,35.99 106.68,35.91 106.99,35.91 108.63,34.27 114.41,34.27 114.64,34.04 114.64,33.41 115.2,32.85 115.32,32.85 115.47,33 115.58,33 115.71,32.88 115.71,32.76 115.55,32.61 115.55,32.5 116.25,31.8 116.86,31.8 117.29,31.37 117.29,25.19 117.21,25.11 116.96,25.11 116.88,25.03 116.88,24.85 116.96,24.77 117.21,24.77 117.29,24.69 117.29,24.52 117.21,24.44 116.81,24.44 116.73,24.36 116.73,24.19 116.82,24.1 117.21,24.1 117.29,24.02 117.29,23.85 117.21,23.77 116.81,23.77 116.73,23.69 116.73,23.52 116.82,23.43 117.21,23.43 117.29,23.35 117.29,23.18 117.21,23.1 116.93,23.1 116.85,23.02 116.85,22.84 116.93,22.76 117.34,22.76 117.43,22.67 117.43,22.51 117.35,22.43 116.93,22.43 116.85,22.34 116.85,22.17 116.93,22.09 117.34,22.09 117.43,22 117.43,21.84 117.35,21.76 116.93,21.76 116.85,21.67 116.85,21.5 116.93,21.42 117.52,21.42 117.61,21.33 117.61,21.17 117.53,21.08 116.93,21.08 116.85,21 116.85,20.23 116.53,19.91 116.53,19.05 116.45,18.97 115.89,18.97 115.46,18.54 v1(115.26,18.54)
  L14_SIG5 w0.081: v1(74.59,18.53) 74.86,18.53 75.29,18.1 76.47,18.1 77.22,17.35 84.12,17.35 84.13,17.37 84.39,17.62 84.39,17.94 84.78,18.33 v1(84.78,18.54) 85.04,18.54 85.42,18.17 86.85,18.17 86.98,18.03 87.17,18.03 87.31,18.17 87.5,18.17 87.63,18.03 87.82,18.03 87.96,18.17 88.15,18.17 88.28,18.03 88.47,18.03 88.61,18.17 94.57,18.17 v1(94.94,18.54) 95.31,18.17 104.73,18.17 v1(105.1,18.54) 105.52,18.11 114.83,18.11 v1(115.26,18.54)
  BOTTOM w0.149: v1(74.59,18.53) 74.99,18.93 75.8,18.93 76.08,18.65 77.03,18.65 R873.2
DDR4_COMP_CH0_A6: length 83.3
  L12_SIG4 w0.089: v1(110.46,18.54) 110.05,18.95 108.47,18.95 108.38,19.04 108.38,19.39 108.29,19.48 108.12,19.48 108.03,19.39 108.03,19.05 107.94,18.95 100.71,18.95 v1(100.3,18.54) 99.89,18.95 92.46,18.95 92.37,18.86 92.37,18.52 92.28,18.44 92.12,18.44 92.03,18.52 92.03,18.86 91.94,18.95 90.55,18.95 v1(90.14,18.54) 89.87,18.54 89.49,18.16 89.06,18.16 88.27,18.95 87.15,18.95 87.06,18.86 87.06,18.7 86.97,18.62 86.81,18.62 86.72,18.7 86.72,18.86 86.63,18.95 80.39,18.95 v1(79.98,18.54) 79.6,18.92 76.7,18.92 76.57,19.05 76.36,19.05 76.23,18.92 73.38,18.92 72.57,18.11 70.21,18.11 69.79,18.53 v1(69.79,18.53)
  L16_SIG6 w0.081: v1(105.16,41.45) 104.77,40.76 arc(104.6,40.59) 104.37,40.53 104.36,40.53 arc(104.13,40.46) 103.97,40.3 arc(103.8,40.13) 103.58,40.07 103.57,40.07 arc(103.34,40.01) 103.17,39.84 103.17,39.83 arc(103.11,39.6) 103.17,39.38 arc(103.23,39.15) 103.17,38.92 103.17,38.91 arc(103.11,38.7) 103.16,38.49 arc(103.19,38.39) 103.2,38.29 103.2,37.66 arc(103.21,37.62) 103.23,37.58 103.42,37.4 103.58,37.4 104.35,36.62 104.35,35.74 104.43,35.66 104.95,35.66 105.03,35.58 105.03,35.41 104.95,35.32 104.43,35.32 104.35,35.24 104.35,35.07 104.43,34.99 105.16,34.99 105.24,34.91 105.24,34.73 105.16,34.65 104.71,34.65 104.63,34.57 104.63,34.46 105.37,33.72 105.48,33.72 106.15,34.39 106.26,34.39 106.4,34.25 106.4,34.13 105.77,33.5 105.77,33.38 105.89,33.26 106.01,33.26 106.57,33.82 arc(106.6,33.84) 106.63,33.85 106.74,33.85 108.17,32.42 108.17,19.11 108.31,18.96 108.69,18.96 108.77,18.88 108.77,17.88 108.85,17.8 109.02,17.8 109.11,17.89 109.11,18.88 109.19,18.96 110.38,18.96 110.46,18.88 v1(110.46,18.54)
  BOTTOM w0.149: R874.2 68.28,18.48 68.74,18.94 69.39,18.94 v1(69.79,18.53)
DDR4_COMP_CH0_A7: length 83.5
  L03_SIG1 w0.081: v1(104.37,41.91) 104.77,41.22 arc(104.83,40.99) 104.77,40.76 104.76,40.75 arc(104.7,40.52) 104.77,40.3 arc(104.93,40.13) 105.16,40.07 105.17,40.07 arc(105.4,40) 105.56,39.84 arc(105.73,39.67) 105.96,39.61 105.96,39.61 arc(106.19,39.54) 106.36,39.38 106.36,39.37 arc(106.53,39.21) 106.76,39.15 106.85,39.15 arc(107,39.1) 107.11,38.99 107.18,38.87 arc(107.32,38.74) 107.5,38.69 107.7,38.69 arc(107.81,38.66) 107.89,38.58 108.02,38.34 arc(108.05,38.22) 108.02,38.1 107.95,38 arc(107.91,37.89) 107.89,37.77 107.62,37.49 107.62,35.62 108.74,34.5 114.53,34.5 115.22,33.81 115.22,33.7 115.03,33.51 115.03,33.39 115.15,33.27 115.26,33.27 115.45,33.46 115.57,33.46 115.92,33.11 116.35,33.11 117.03,32.43 117.03,31.99 117.54,31.48 117.54,24.54 117.62,24.46 117.78,24.46 117.87,24.38 117.87,24.21 117.78,24.13 117.62,24.13 117.54,24.04 117.54,23.87 117.62,23.79 117.91,23.79 117.99,23.71 117.99,23.54 117.91,23.45 117.62,23.45 117.54,23.37 117.54,23.2 117.62,23.12 117.85,23.12 117.93,23.04 117.93,22.7 117.85,22.62 117.75,22.62 117.67,22.54 117.67,22.37 117.75,22.29 117.85,22.29 117.93,22.21 117.93,19.83 116.22,18.12 115.92,18.12 115.51,17.72 115.28,17.72 v1(115.26,17.74)
  L14_SIG5 w0.081: v1(115.26,17.74) 114.87,17.35 105.49,17.35 v1(105.1,17.74) 104.71,17.35 95.33,17.35 v1(94.94,17.74) 94.57,17.37 88.41,17.37 88.28,17.23 88.09,17.23 87.95,17.37 87.76,17.37 87.63,17.23 87.44,17.23 87.3,17.37 87.11,17.37 86.98,17.23 86.79,17.23 86.65,17.37 85.42,17.37 85.05,17.74 v1(84.78,17.74) 84.78,17.47 84.35,17.04 84.35,16.77 84.14,16.56 76.54,16.56 75.74,17.36 75.24,17.36 74.87,17.73 v1(74.59,17.73)
  BOTTOM w0.149: R875.2 75.35,16.41 75.35,16.43 75,16.77 75,17.33 v1(74.59,17.73)
DDR4_COMP_CH0_A8: length 84.8
  L12_SIG4 w0.089: v1(69.79,17.73) 70.2,17.33 76.72,17.33 76.88,17.17 77.06,17.17 77.22,17.33 77.41,17.33 77.56,17.17 77.75,17.17 77.91,17.33 79.57,17.33 v1(79.98,17.74) 80.4,17.32 88.04,17.32 88.79,16.56 89.49,16.56 89.71,16.78 89.71,17.26 90.14,17.69 v1(90.14,17.74) 90.55,17.33 91.82,17.33 91.91,17.24 91.91,16.94 92,16.85 92.16,16.85 92.25,16.94 92.25,17.24 92.34,17.33 99.89,17.33 v1(100.3,17.74) 100.69,17.35 108.05,17.35 108.14,17.44 108.14,17.73 108.23,17.82 108.39,17.82 108.48,17.73 108.48,17.45 108.58,17.35 110.07,17.35 v1(110.46,17.74)
  L16_SIG6 w0.081: v1(110.46,17.74) 110.93,17.93 111,18 arc(111.12,18.08) 111.26,18.11 114.29,18.11 arc(114.52,18.16) 114.71,18.28 114.71,18.29 arc(114.81,18.41) 114.86,18.55 114.87,18.61 arc(114.9,18.68) 114.94,18.74 arc(114.96,18.77) 114.98,18.79 115.05,18.86 arc(115.14,18.92) 115.25,18.94 arc(115.38,18.97) 115.48,19.04 115.54,19.09 arc(115.63,19.22) 115.68,19.37 arc(115.71,19.47) 115.75,19.56 arc(115.78,19.59) 115.81,19.62 arc(115.89,19.68) 115.98,19.73 116.17,19.79 arc(116.21,19.8) 116.25,19.82 arc(116.39,19.96) 116.44,20.16 arc(116.43,20.22) 116.44,20.28 arc(116.44,20.28) 116.44,20.29 116.44,29.16 arc(116.44,29.2) 116.43,29.24 arc(116.28,29.82) 116.08,30.38 arc(116.07,30.46) 116.08,30.54 arc(116.08,30.58) 116.07,30.62 115.8,31.12 arc(115.28,32.16) 114.84,33.24 arc(114.72,33.53) 114.57,33.82 arc(114.55,33.85) 114.52,33.88 113.2,35.2 arc(113.17,35.23) 113.14,35.26 111.94,36.05 arc(111.66,36.24) 111.37,36.4 arc(110.95,36.65) 110.54,36.93 arc(110.37,37.05) 110.19,37.18 arc(110.16,37.2) 110.13,37.22 109.38,37.6 arc(109.14,37.74) 108.92,37.93 108.86,37.99 arc(108.8,38.08) 108.78,38.19 108.78,38.65 108.78,39.4 arc(108.76,39.57) 108.72,39.72 arc(108.7,39.76) 108.68,39.79 108.5,40.01 arc(108.47,40.04) 108.44,40.06 arc(108.37,40.1) 108.3,40.13 108.23,40.15 arc(108.11,40.21) 108.02,40.32 arc(107.99,40.39) 107.98,40.46 107.98,40.74 arc(107.98,40.78) 107.97,40.82 107.93,41.04 arc(107.92,41.08) 107.9,41.11 107.82,41.2 arc(107.8,41.23) 107.77,41.26 107.69,41.32 arc(107.65,41.35) 107.61,41.37 arc(107.44,41.49) 107.28,41.61 arc(107.09,41.74) 106.88,41.85 arc(106.74,41.92) 106.61,42.01 106.35,42.18 arc(106.31,42.21) 106.28,42.24 arc(106.14,42.33) 105.96,42.37 arc(105.77,42.33) 105.62,42.21 arc(105.56,42.16) 105.5,42.12 105.2,41.95 arc(105.16,41.93) 105.13,41.91 104.75,41.63 arc(104.72,41.6) 104.69,41.58 arc(104.61,41.51) 104.51,41.47 arc(104.47,41.45) 104.43,41.43 104.36,41.39 arc(103.97,41.09) 103.67,40.7 v1(103.57,40.53)
  BOTTOM w0.149: R876.2 68.6,16.66 68.6,17.1 68.85,17.34 69.4,17.34 v1(69.79,17.73)
DDR4_COMP_CH0_A9: length 84.3
  L05_SIG2 w0.081: v1(73.79,17.73) 74.07,17.73 74.44,17.36 75.52,17.36 76.38,16.5 82.74,16.5 v1(83.98,17.74) 83.98,17.51 84.41,17.08 84.41,16.79 84.62,16.57 92.97,16.57 v1(94.14,17.74) 94.14,17.51 94.52,17.13 94.52,16.81 94.82,16.51 103.07,16.51 v1(104.3,17.74) 104.3,17.51 104.68,17.13 104.68,16.79 104.96,16.51 113.23,16.51 v1(114.46,17.74)
  L16_SIG6 w0.081: v1(114.46,17.74) 114.93,17.93 115.03,18.03 arc(115.1,18.09) 115.18,18.13 arc(115.21,18.14) 115.24,18.14 115.31,18.14 arc(115.45,18.17) 115.56,18.25 115.57,18.26 arc(115.65,18.37) 115.68,18.51 arc(115.71,18.67) 115.8,18.81 115.86,18.87 arc(115.96,18.94) 116.09,18.96 arc(116.24,19) 116.38,19.07 arc(116.42,19.1) 116.45,19.13 116.5,19.18 arc(116.66,19.43) 116.72,19.73 116.72,29.25 arc(116.71,29.29) 116.71,29.33 arc(116.34,30.58) 115.77,31.75 arc(115.62,32.03) 115.49,32.32 115.11,33.29 arc(115.11,33.3) 115.11,33.31 arc(114.9,33.86) 114.63,34.38 arc(114.61,34.42) 114.59,34.45 112.12,36.91 arc(112.08,36.95) 112.04,36.98 110.51,37.75 arc(110.47,37.77) 110.44,37.79 110.1,38.14 arc(110.07,38.16) 110.03,38.18 109.74,38.29 arc(109.7,38.32) 109.67,38.35 arc(109.64,38.39) 109.62,38.43 arc(109.61,38.44) 109.61,38.45 109.57,38.57 arc(109.57,38.61) 109.56,38.65 109.57,39.73 arc(109.58,39.74) 109.58,39.76 arc(109.58,39.78) 109.58,39.81 109.58,39.96 arc(109.57,40.11) 109.54,40.27 109.54,40.28 arc(109.52,40.32) 109.49,40.35 arc(109.32,40.49) 109.12,40.59 arc(109.08,40.61) 109.04,40.63 arc(108.9,40.75) 108.79,40.9 arc(108.77,40.96) 108.77,41.02 108.77,41.32 arc(108.77,41.36) 108.76,41.4 arc(108.72,41.54) 108.66,41.67 arc(108.64,41.7) 108.61,41.73 108.55,41.78 arc(108.51,41.81) 108.48,41.83 108.25,41.92 arc(108.13,41.98) 108.03,42.06 arc(107.77,42.25) 107.47,42.38 arc(107.32,42.45) 107.2,42.55 arc(107.17,42.58) 107.14,42.62 arc(106.98,42.77) 106.76,42.83 106.76,42.83 arc(106.59,42.9) 106.43,42.99 arc(106.39,43.02) 106.36,43.04 arc(106.34,43.07) 106.32,43.08 arc(106.23,43.14) 106.14,43.19 arc(106.1,43.2) 106.06,43.21 105.89,43.21 arc(105.85,43.2) 105.82,43.19 105.24,42.87 arc(105.17,42.84) 105.09,42.82 arc(104.91,42.75) 104.77,42.6 104.76,42.59 arc(104.6,42.43) 104.37,42.37 arc(104.14,42.31) 103.98,42.15 103.96,42.12 103.83,41.94 arc(103.81,41.91) 103.77,41.89 103.38,41.82 arc(103.25,41.74) 103.2,41.59 103.2,41.27 102.91,40.18 arc(102.89,40.15) 102.86,40.12 v1(102.77,40.07)
  BOTTOM w0.149: v1(73.79,17.73) 74.19,17.34 74.19,16.53 R877.2
DDR4_COMP_CH0_A10: length 84.9
  L03_SIG1 w0.081: v1(111.26,20.14) 111.5,20.14 112.73,18.91 114.61,18.91 114.63,18.89 115.1,18.89 115.11,18.9 115.39,18.9 115.69,19.2 115.69,20.36 115.82,20.5 116.15,20.5 116.44,20.79 116.44,22.7 116.21,22.93 115.9,22.93 115.64,23.19 115.64,29.26 115.52,29.38 115.26,29.38 115.17,29.47 115.17,31.69 114.74,32.12 113.32,32.12 113.24,32.2 113.24,32.67 113.16,32.75 112.99,32.75 112.91,32.67 112.91,32.2 112.83,32.12 111.74,32.12 111.66,32.2 111.66,32.84 111.58,32.92 111.41,32.92 111.33,32.83 111.33,32.2 111.25,32.12 110.07,32.12 109.83,32.36 109.83,32.47 110.03,32.67 110.03,32.79 109.91,32.9 109.78,32.9 109.59,32.71 109.48,32.71 106.74,35.44 106.19,35.44 105.62,36.01 105.62,37.91 arc(105.53,38.14) 105.31,38.23 105.05,38.23 arc(104.93,38.26) 104.83,38.35 104.75,38.5 arc(104.61,38.64) 104.42,38.69 104.24,38.69 arc(103.91,38.88) 103.91,39.27 103.97,39.38 arc(104.03,39.6) 103.97,39.83 103.97,39.84 arc(103.91,40.07) 103.97,40.3 arc(104.03,40.52) 103.97,40.75 v1(103.57,41.45)
  L07_SIG3 w0.089: v1(111.26,20.14) 110.86,20.54 108.1,20.54 107.97,20.67 107.69,20.67 107.56,20.54 107.41,20.54 107.32,20.63 107.32,20.85 107.23,20.94 107.07,20.94 106.98,20.85 106.98,20.64 106.88,20.54 101.5,20.54 v1(101.1,20.14) 100.7,20.54 93.2,20.54 93.11,20.45 93.11,20.34 93.02,20.25 92.86,20.25 92.77,20.34 92.77,20.45 92.68,20.54 92.51,20.54 92.43,20.45 92.43,20.34 92.34,20.25 92.17,20.25 92.08,20.34 92.08,20.45 91.99,20.54 91.34,20.54 v1(90.94,20.14) 90.54,20.54 87.95,20.54 87.86,20.45 87.86,20.09 87.77,20 87.61,20 87.52,20.09 87.52,20.42 87.43,20.51 85.73,20.51 84.93,20.51 84.13,20.51 81.15,20.51 v1(80.78,20.14) 80.38,20.54 73.27,20.54 73.11,20.69 72.92,20.69 72.77,20.54 72.58,20.54 72.43,20.69 72.24,20.69 72.08,20.54 71.9,20.54 71.74,20.69 71.55,20.69 71.4,20.54 71,20.54 v1(70.59,20.13)
DDR4_COMP_CH0_A11: length 83.9
  L12_SIG4 w0.089: v1(110.46,16.94) 110.03,16.51 100.72,16.51 v1(100.3,16.94) 99.72,16.36 93.32,16.36 93.23,16.45 93.23,16.64 93.14,16.73 92.97,16.73 92.88,16.64 92.88,16.45 92.79,16.36 90.72,16.36 v1(90.14,16.94) 90.02,16.83 90.02,16.51 89.84,16.33 82.96,16.33 82.87,16.42 82.87,16.59 82.78,16.68 82.62,16.68 82.53,16.59 82.53,16.42 82.44,16.33 80.59,16.33 v1(79.98,16.94) 79.4,16.36 78.62,16.36 78.46,16.52 78.28,16.52 78.12,16.36 77.94,16.36 77.78,16.52 77.6,16.52 77.43,16.36 70.37,16.36 v1(69.79,16.93)
  L16_SIG6 w0.081: v1(110.46,16.94) 110.46,16.68 110.58,16.55 111.21,16.55 111.29,16.47 111.29,16.28 111.21,16.2 110.53,16.2 arc(110.27,16.22) 110.01,16.29 arc(109.73,16.41) 109.46,16.54 arc(109.42,16.56) 109.39,16.59 108.36,17.46 arc(108.33,17.49) 108.31,17.52 108.06,17.79 arc(108.03,17.83) 108.01,17.86 arc(107.61,18.73) 107.29,19.63 arc(107.28,19.65) 107.27,19.67 107.27,20.39 107.36,20.47 107.56,20.47 107.64,20.55 107.64,20.72 107.56,20.8 107.36,20.8 107.27,20.89 107.27,21.06 107.36,21.14 107.56,21.14 107.64,21.22 107.64,21.39 107.56,21.47 107.36,21.47 107.27,21.56 107.27,21.78 107.36,21.86 107.59,21.86 107.67,21.94 107.67,22.12 107.59,22.2 107.36,22.2 107.27,22.28 107.27,22.45 107.36,22.53 107.59,22.53 107.67,22.61 107.67,22.79 107.59,22.87 107.36,22.87 107.27,22.95 107.27,23.12 107.36,23.2 107.59,23.2 107.67,23.28 107.67,23.46 107.59,23.54 107.36,23.54 107.27,23.62 107.27,23.79 107.36,23.87 107.59,23.87 107.67,23.96 107.67,24.13 107.59,24.21 107.33,24.21 107.25,24.29 107.25,29.97 106.73,30.49 106.73,30.61 106.95,30.83 106.95,30.94 106.72,31.17 106.72,31.28 106.85,31.4 106.96,31.4 107.16,31.2 107.36,31.2 107.62,31.47 107.62,31.66 107.18,32.11 107.06,32.11 106.61,31.65 arc(106.53,31.62) 106.46,31.65 103.64,34.47 arc(103.62,34.5) 103.61,34.54 103.61,36.17 arc(103.61,36.21) 103.6,36.25 arc(103.52,36.55) 103.37,36.81 arc(103.34,36.84) 103.32,36.87 arc(102.86,37.16) 102.33,37.26 102.18,37.26 arc(101.86,37.38) 101.66,37.66 arc(101.64,37.72) 101.64,37.79 101.64,41.62 arc(101.73,41.84) 101.94,41.93 v1(102.79,41.93)
  BOTTOM w0.149: R879.2 69.53,16.67 v1(69.79,16.93)
DDR4_COMP_CH0_A12: length 86.1
  L03_SIG1 w0.081: v1(114.46,20.14) 112.95,20.14 112.87,20.22 112.87,20.83 112.79,20.91 112.61,20.91 112.53,20.83 112.53,20.22 112.45,20.14 112.12,20.14 111.64,20.61 111.64,21.14 111.77,21.27 112.62,21.27 112.7,21.35 112.7,21.61 112.62,21.69 112.39,21.69 112.31,21.77 112.31,22.51 111.9,22.92 111.11,22.92 110.84,23.19 110.84,23.51 110.58,23.77 109.46,23.77 109.03,24.19 109.03,26.02 108.92,26.14 108.68,26.14 108.6,26.22 108.6,26.39 108.68,26.47 108.92,26.47 109,26.55 109,26.72 108.92,26.81 108.68,26.81 108.6,26.89 108.6,27.06 108.68,27.14 108.94,27.14 109.02,27.22 109.02,27.38 108.92,27.48 108.68,27.48 108.6,27.56 108.6,27.73 108.68,27.81 108.97,27.81 109.05,27.89 109.05,28.06 108.96,28.15 108.68,28.15 108.6,28.23 108.6,28.4 108.68,28.48 108.92,28.48 109,28.56 109,28.74 108.92,28.82 108.68,28.82 108.6,28.9 108.6,29.07 108.68,29.15 108.92,29.15 109.08,29.32 109.08,29.62 108.47,30.24 108.21,30.24 107.8,29.83 107.68,29.83 107.58,29.94 107.58,30.08 107.97,30.48 107.97,30.59 107.01,31.55 106.11,31.55 103.1,34.56 103.1,36.14 101.63,37.61 101.63,42.63 101.78,42.78 102.21,42.78 102.37,42.94 102.37,44.26 v1(102.77,44.67)
  L05_SIG2 w0.081: v1(114.46,20.14) 113.74,20.14 113.33,19.73 107.87,19.73 107.79,19.81 107.79,20.03 107.71,20.11 107.54,20.11 107.46,20.03 107.46,19.81 107.38,19.73 104.94,19.73 104.53,20.14 v1(104.3,20.14) 104.01,20.14 103.61,19.74 97.8,19.74 97.72,19.82 97.72,20.08 97.64,20.16 97.46,20.16 97.38,20.08 97.38,19.82 97.3,19.74 94.8,19.74 94.4,20.14 v1(94.14,20.14) 93.88,20.14 93.49,19.74 92.08,19.74 92,19.66 92,19.31 91.92,19.23 91.74,19.23 91.66,19.31 91.66,19.66 91.58,19.74 87.36,19.74 87.28,19.66 87.28,19.46 87.19,19.37 87.04,19.37 86.95,19.46 86.95,19.66 86.87,19.74 84.58,19.74 84.19,20.14 v1(83.98,20.14) 83.21,20.14 82.81,19.74 78.61,19.74 78.47,19.88 78.28,19.88 78.13,19.74 77.94,19.74 77.8,19.88 77.61,19.88 77.46,19.74 77.27,19.74 77.13,19.88 76.94,19.88 76.79,19.74 76.6,19.74 76.46,19.88 76.26,19.88 76.12,19.74 74.19,19.74 v1(73.79,20.13)
DDR4_COMP_CH0_A13: length 81.7
  L14_SIG5 w0.081: v1(115.26,16.94) 114.83,16.51 107.84,16.51 107.76,16.59 107.76,16.87 107.68,16.95 107.51,16.95 107.42,16.87 107.42,16.59 107.34,16.51 107.17,16.51 107.09,16.59 107.09,16.98 107.01,17.06 106.83,17.06 106.75,16.98 106.75,16.59 106.67,16.51 105.52,16.51 v1(105.1,16.94) 104.73,16.57 95.31,16.57 v1(94.94,16.94) 94.57,16.57 85.15,16.57 v1(84.78,16.94) 84.08,16.24 75.29,16.24 v1(74.59,16.93)
  L16_SIG6 w0.081: v1(115.26,16.94) 115.29,16.97 arc(115.32,17) 115.34,17.03 arc(115.54,17.43) 115.68,17.85 arc(115.69,17.89) 115.72,17.92 115.81,18.02 arc(115.91,18.09) 116.03,18.12 arc(116.22,18.18) 116.37,18.33 116.58,18.67 arc(116.78,19.06) 116.89,19.49 116.94,19.89 arc(116.95,19.93) 116.95,19.97 116.95,29.25 arc(116.95,29.29) 116.94,29.34 arc(116.83,29.9) 116.68,30.46 arc(116.43,31.16) 116.13,31.83 arc(116.05,32) 115.97,32.16 arc(115.93,32.26) 115.88,32.37 arc(115.65,32.99) 115.46,33.63 115.39,33.93 arc(115.23,34.31) 114.98,34.64 112.8,36.82 arc(112.77,36.85) 112.75,36.89 112.16,37.67 arc(112.14,37.7) 112.12,37.74 arc(112.08,37.84) 112.04,37.94 arc(112.02,37.97) 112.01,38.01 arc(112.01,38.05) 111.99,38.09 arc(111.97,38.15) 111.97,38.21 arc(111.96,38.26) 111.96,38.3 111.9,38.6 arc(111.89,38.64) 111.88,38.68 arc(111.87,38.7) 111.87,38.73 arc(111.8,38.9) 111.64,39 arc(111.45,39.09) 111.27,39.23 arc(111.13,39.39) 110.99,39.55 arc(110.87,39.65) 110.72,39.7 arc(110.45,39.83) 110.38,40.13 arc(110.38,40.17) 110.38,40.21 110.37,40.47 arc(110.37,40.51) 110.35,40.55 110.28,40.71 arc(110.26,40.75) 110.23,40.78 110.07,40.94 arc(109.98,41.01) 109.88,41.05 109.87,41.05 arc(109.64,41.19) 109.56,41.44 arc(109.56,41.48) 109.55,41.52 arc(109.55,41.58) 109.55,41.63 109.58,41.81 arc(109.58,41.86) 109.59,41.9 109.59,41.91 arc(109.54,42.02) 109.48,42.11 arc(109.46,42.14) 109.42,42.16 arc(109.4,42.18) 109.38,42.19 arc(109.22,42.3) 109.04,42.37 108.87,42.42 arc(108.75,42.47) 108.66,42.57 arc(108.55,42.68) 108.4,42.73 arc(108.3,42.76) 108.22,42.81 arc(107.99,42.97) 107.77,43.13 arc(107.73,43.15) 107.69,43.17 arc(107.62,43.21) 107.56,43.26 107.46,43.36 arc(107.42,43.4) 107.37,43.42 arc(107.29,43.48) 107.23,43.56 arc(107.21,43.6) 107.18,43.63 arc(107.06,43.73) 106.93,43.81 arc(106.87,43.84) 106.81,43.84 arc(106.61,43.87) 106.46,43.99 arc(106.41,44.03) 106.36,44.06 arc(106.17,44.1) 105.99,44.12 arc(105.82,44.11) 105.66,44.05 105.22,43.75 arc(105.18,43.73) 105.15,43.71 104.55,43.42 arc(104.3,43.38) 104.08,43.52 arc(103.95,43.62) 103.79,43.66 103.5,43.66 arc(103.42,43.64) 103.36,43.6 103.17,43.41 arc(103.03,43.32) 102.88,43.29 v1(101.98,43.29)
  BOTTOM w0.149: v1(74.59,16.93) 74.68,16.84 R881.2
DDR4_COMP_CH0_A14: length 84.7
  L03_SIG1 w0.081: v1(101.18,43.75) 101.18,42.77 100.69,42.27 100.69,37.89 102.46,36.12 102.46,35.59 102.38,35.51 101.72,35.51 101.64,35.43 101.64,35.27 101.74,35.17 102.38,35.17 102.46,35.09 102.46,34.44 107.44,29.47 107.44,28.36 107.53,28.28 108.1,28.28 108.18,28.19 108.18,28.02 108.1,27.94 107.57,27.94 107.46,27.83 107.46,27.69 107.54,27.61 108.1,27.61 108.18,27.52 108.18,27.35 108.1,27.27 107.55,27.27 107.47,27.19 107.47,27.02 107.55,26.93 108.1,26.93 108.18,26.85 108.18,26.68 108.1,26.6 107.55,26.6 107.47,26.52 107.47,26.35 107.55,26.26 108.1,26.26 108.18,26.18 108.18,26.01 108.1,25.93 107.12,25.93 107.04,25.85 107.04,25.7 107.14,25.59 108.14,25.59 108.22,25.51 108.22,25.34 108.13,25.26 107.12,25.26 107.04,25.18 107.04,25.03 107.14,24.92 108.14,24.92 108.22,24.84 108.22,24.67 108.13,24.59 107.13,24.59 107.04,24.49 107.04,24.36 107.15,24.25 107.93,24.25 108.02,24.17 108.02,22.67 109.32,21.37 110.03,21.37 v1(110.46,20.94)
  L12_SIG4 w0.089: v1(110.46,20.94) 110.05,21.35 100.71,21.35 v1(100.3,20.94) 99.89,21.35 90.55,21.35 v1(90.14,20.94) 89.75,20.55 88.73,20.55 87.93,21.35 86.99,21.35 86.91,21.26 86.91,21.11 86.82,21.02 86.65,21.02 86.56,21.11 86.56,21.26 86.47,21.35 80.39,21.35 v1(79.98,20.94) 79.55,21.36 78.23,21.36 78.13,21.47 77.64,21.47 77.52,21.34 73.46,21.34 72.67,20.55 70.18,20.55 v1(69.79,20.93)
  BOTTOM w0.149: v1(69.79,20.93) 69.39,21.34 68.83,21.34 68.39,21.78 R882.2
DDR4_COMP_CH0_A15: length 85.8
  L03_SIG1 w0.081: v1(101.98,45.13) 102.4,45.55 102.4,45.74 102.62,45.96 102.93,45.96 103.39,45.5 103.73,45.5 103.94,45.28 103.94,42.27 103.64,41.97 103.46,41.97 103.17,41.67 arc(103.11,41.44) 103.17,41.22 arc(103.23,40.99) 103.18,40.76 103.17,40.75 arc(103.11,40.52) 103.17,40.3 arc(103.23,40.07) 103.17,39.84 103.17,39.83 arc(103.11,39.6) 103.17,39.38 arc(103.23,39.15) 103.17,38.92 103.17,38.91 arc(103.11,38.68) 103.17,38.46 arc(103.34,38.29) 103.56,38.23 103.57,38.23 arc(103.8,38.17) 103.97,38 103.97,38 arc(104.02,37.89) 104.03,37.77 104.28,37.52 104.39,37.52 104.56,37.69 104.68,37.69 104.8,37.57 104.8,37.46 104.63,37.28 104.63,37.17 104.78,37.01 104.78,36.35 105.92,35.21 106.65,35.21 108.32,33.53 108.32,33.42 108.13,33.23 108.13,33.11 108.25,32.99 108.37,32.99 108.56,33.18 108.68,33.18 108.8,33.06 108.8,32.94 108.57,32.72 108.57,32.6 108.69,32.48 108.81,32.48 109.04,32.71 109.15,32.71 109.98,31.88 113.47,31.88 114.84,30.51 114.84,23.21 115.14,22.91 115.41,22.91 115.69,22.63 115.69,20.79 115.26,20.36 v1(115.26,20.14)
  L14_SIG5 w0.081: v1(115.26,20.14) 114.89,19.77 105.47,19.77 v1(105.1,20.14) 104.73,19.77 95.31,19.77 v1(94.94,20.14) 94.57,19.77 92.58,19.77 92.5,19.69 92.5,19.48 92.42,19.4 92.25,19.4 92.17,19.48 92.17,19.69 92.09,19.77 85.38,19.77 85.01,20.14 v1(84.78,20.14) 84.78,19.96 84.35,19.53 84.35,19.19 84.09,18.93 76.83,18.93 76.04,19.72 75,19.72 v1(74.59,20.13)
  BOTTOM w0.149: R883.2 76.16,22.79 75.8,22.42 75.8,21.58 75.56,21.34 75.19,21.34 75,21.15 75,20.54 v1(74.59,20.13)
DDR4_COMP_CH0_A16: length 85.2
  TOP w0.149: U3.L8 84.78,20.91 v1(84.77,20.9)
  L03_SIG1 w0.081: v1(115.26,20.94) 114.87,20.55 113.36,20.55 113.2,20.71 113.2,21.16 113.28,21.24 113.39,21.24 113.47,21.32 113.47,21.49 113.39,21.57 113.28,21.57 113.2,21.65 113.2,21.83 113.28,21.91 113.52,21.91 113.6,21.99 113.6,22.16 113.52,22.24 113.28,22.24 113.2,22.32 113.2,22.5 113.28,22.58 113.52,22.58 113.6,22.66 113.6,22.83 113.52,22.91 113.28,22.91 113.2,22.99 113.2,23.17 113.28,23.25 113.52,23.25 113.6,23.33 113.6,23.5 113.52,23.58 113.28,23.58 113.2,23.67 113.2,23.84 113.28,23.92 113.43,23.92 113.51,24 113.51,24.17 113.03,24.65 112.52,24.65 112.35,24.49 112.05,24.49 111.17,25.36 109.49,25.36 109.27,25.59 109.27,29.78 107.26,31.79 106.2,31.79 103.34,34.65 103.34,36.35 102.45,37.24 102.45,37.9 102.31,38.03 102.31,38.42 102.38,38.48 102.38,38.92 102.37,38.92 arc(102.31,39.15) 102.38,39.38 arc(102.44,39.6) 102.38,39.83 102.37,39.84 arc(102.31,40.07) 102.38,40.3 arc(102.44,40.52) 102.38,40.75 102.37,40.76 arc(102.31,40.99) 102.38,41.22 arc(102.44,41.44) 102.38,41.67 102.38,41.68 arc(102.31,41.9) 102.37,42.12 102.38,42.15 102.57,42.34 102.98,42.34 103.19,42.55 103.19,44.78 102.93,45.04 102.62,45.04 102.25,44.67 101.98,44.67 v1(101.18,44.67)
  L14_SIG5 w0.081: v1(115.26,20.94) 114.48,20.94 114.11,21.31 105.47,21.31 v1(105.1,20.94) 104.68,21.36 95.6,21.36 95.18,20.94 v1(94.94,20.94) 94.53,21.35 88.67,21.35 87.87,20.55 85.43,20.55 85.09,20.9 v1(84.77,20.9) 84.5,20.9 84.14,20.54 78.43,20.54 78.29,20.67 78.09,20.67 77.96,20.54 77.75,20.54 77.62,20.67 77.42,20.67 77.28,20.54 77.08,20.54 76.95,20.67 76.75,20.67 76.61,20.54 74.99,20.54 74.6,20.93 v1(74.59,20.93)
  BOTTOM w0.149: v1(74.59,20.93) 74.59,21.18 74.99,21.57 74.99,22.68 75.23,22.93 75.54,22.93 76.28,23.66 R884.2
DDR4_COMP_CH0_ACT_N: length 82.6
  L07_SIG3 w0.089: v1(70.59,20.93) 70.59,21 70.95,21.35 77.47,21.35 77.59,21.47 78.14,21.47 78.26,21.35 80.37,21.35 v1(80.78,20.94) 81.18,21.34 87.39,21.34 87.48,21.25 87.48,20.94 87.59,20.83 87.72,20.83 87.82,20.94 87.82,21.25 87.91,21.34 90.54,21.34 v1(90.94,20.94) 91.99,20.94 92.17,21.11 92.17,21.25 92.26,21.34 92.42,21.34 92.51,21.25 92.51,21.11 92.6,21.02 92.76,21.02 92.85,21.11 92.85,21.25 92.94,21.34 96.27,21.34 96.36,21.25 96.36,20.99 96.45,20.9 96.62,20.9 96.71,20.99 96.71,21.25 96.8,21.34 96.98,21.34 97.07,21.25 97.07,21 97.16,20.91 97.33,20.91 97.42,21 97.42,21.25 97.51,21.34 100.7,21.34 v1(101.1,20.94) 101.5,21.34 107.06,21.34 107.21,21.5 107.42,21.5 107.58,21.34 110.86,21.34 v1(111.26,20.94)
  L16_SIG6 w0.081: v1(105.96,39.15) 105.6,38.52 105.5,38.42 105.5,38.05 105.62,37.92 105.62,37.57 106.26,36.93 106.26,35.94 106.49,35.71 106.61,35.71 106.85,35.95 106.96,35.95 107.08,35.82 107.08,35.71 106.84,35.47 106.84,35.35 106.97,35.23 107.08,35.23 107.32,35.47 107.43,35.47 107.56,35.35 107.56,35.23 107.32,35 107.32,34.88 107.44,34.76 107.56,34.76 107.79,35 107.91,35 108.03,34.87 108.03,34.76 107.79,34.52 107.79,34.41 107.91,34.28 108.03,34.28 108.27,34.52 108.38,34.52 108.51,34.4 108.51,34.29 108.27,34.05 108.27,33.93 108.39,33.81 108.5,33.81 108.74,34.05 108.86,34.05 108.98,33.93 108.98,33.81 108.74,33.57 108.74,33.46 108.86,33.34 108.98,33.34 109.22,33.57 109.33,33.57 109.45,33.45 109.45,33.34 109.22,33.1 109.22,32.98 109.34,32.86 109.45,32.86 109.69,33.1 109.81,33.1 109.93,32.98 109.93,32.86 109.69,32.62 109.69,32.51 110.76,31.44 112.04,31.44 112.41,31.08 112.41,30.2 112.5,30.1 112.64,30.1 112.74,30.2 112.74,30.71 112.84,30.81 112.98,30.81 113.08,30.71 113.08,28 112.99,27.92 112.2,27.92 112.12,27.84 112.12,27.67 112.2,27.58 112.54,27.58 112.63,27.49 112.63,27.34 112.54,27.25 112.2,27.25 112.12,27.17 112.12,27 112.2,26.91 112.54,26.91 112.63,26.82 112.63,26.67 112.54,26.58 112.2,26.58 112.12,26.5 112.12,26.32 112.2,26.24 112.34,26.24 112.42,26.16 112.42,26.04 112.5,25.96 112.67,25.96 112.75,26.04 112.75,26.16 112.84,26.24 113.18,26.24 113.26,26.16 113.26,24.81 113.18,24.73 112.68,24.73 112.59,24.64 112.59,24.47 112.67,24.39 113.18,24.39 113.26,24.31 113.26,24.14 113.18,24.06 112.74,24.06 112.66,23.98 112.66,23.81 112.75,23.72 113.26,23.72 113.49,23.5 113.49,22.83 112.87,22.21 112.76,22.21 112.56,22.4 112.45,22.4 112.33,22.28 112.33,22.16 112.64,21.85 112.64,21.64 111.94,20.94 v1(111.26,20.94)
DDR4_COMP_CH0_ALERT_N: length 84.3
  L03_SIG1 w0.081: v1(116.06,18.54) 115.64,18.12 112.24,18.12 111.39,18.97 111.1,18.97 110.89,19.19 110.89,19.63 110.77,19.75 109.46,19.75 108.81,20.41 108.69,20.41 108.55,20.27 108.44,20.27 108.32,20.39 108.32,20.51 108.45,20.65 108.45,20.76 108.33,20.88 108.22,20.88 108.06,20.72 107.94,20.72 107.82,20.85 107.82,20.96 107.98,21.12 107.98,21.24 107.86,21.36 107.74,21.36 107.58,21.2 107.47,21.2 107.34,21.32 107.34,21.43 107.51,21.6 107.51,21.71 106.58,22.63 106.58,29.13 103.58,32.13 103.58,32.58 100.25,35.91 100.25,36.33 98.73,37.85 98.73,38.48 98.75,38.5 98.75,39.77 97.96,40.57 97.96,41.64 99.6,43.29 v1(100.38,43.29)
  L12_SIG4 w0.089: v1(116.06,18.54) 115.68,18.16 106.27,18.16 v1(105.9,18.54) 105.52,18.16 96.11,18.16 v1(95.74,18.54) 95.33,18.13 90.02,18.13 89.71,17.83 89.71,17.58 89.49,17.36 88.79,17.36 88.04,18.11 86,18.11 v1(85.58,18.54) 85.19,18.15 78.38,18.15 77.99,18.53 v1(75.39,18.53)
  BOTTOM w0.149: v1(75.39,18.53) 75.59,18.34 76.6,18.34 76.77,18.18 76.77,18.04 77.2,17.6 R28.2
DDR4_COMP_CH0_BA0: length 84.2
  L03_SIG1 w0.081: v1(110.46,19.34) 110.46,19.05 110.38,18.97 109.02,18.97 arc(108.98,18.98) 108.95,19 106.39,21.55 arc(106.37,21.59) 106.36,21.63 106.36,29 103.44,31.92 102.69,31.92 102.29,32.31 102.29,32.43 102.71,32.84 102.71,32.96 102.59,33.07 102.47,33.07 102.06,32.66 101.94,32.66 101.71,32.9 101.71,33.02 102.06,33.37 102.06,33.49 101.94,33.6 101.82,33.6 101.47,33.25 101.35,33.25 101.23,33.38 101.23,33.49 101.49,33.75 101.49,33.87 101.37,33.99 101.26,33.99 100.99,33.73 100.88,33.73 100.76,33.85 100.76,33.97 101.02,34.23 101.02,34.34 100.9,34.47 100.78,34.47 100.52,34.2 100.4,34.2 99.43,35.18 99.43,36.04 97.99,37.47 97.99,37.89 arc(98.06,38.13) 97.99,38.38 97.99,38.39 arc(97.92,38.63) 97.99,38.88 97.99,38.89 arc(98.06,39.14) 97.99,39.39 97.57,39.8 97.05,39.8 96.32,40.54 96.32,41.79 97,42.47 97.57,42.47 97.99,42.89 arc(98.09,43) 98.23,43.05 98.73,43.13 arc(98.96,43.18) 99.15,43.31 99.59,43.74 v1(99.59,43.75)
  L12_SIG4 w0.089: v1(69.79,19.33) 70.18,18.95 72.38,18.95 73.18,19.75 76.34,19.75 76.5,19.91 76.68,19.91 76.84,19.75 77.02,19.75 77.18,19.91 77.37,19.91 77.53,19.75 77.71,19.75 77.87,19.91 78.05,19.91 78.21,19.75 79.57,19.75 v1(79.98,19.34) 80.39,19.75 88.16,19.75 88.96,18.95 89.75,18.95 v1(90.14,19.34) 90.55,19.75 99.89,19.75 v1(100.3,19.34) 100.71,19.75 110.05,19.75 v1(110.46,19.34)
  BOTTOM w0.149: R887.2 68.36,19.31 68.79,19.74 69.39,19.74 v1(69.79,19.33)
DDR4_COMP_CH0_BA1: length 84
  L03_SIG1 w0.081: v1(115.26,19.34) 115.44,19.52 115.44,19.63 115.36,19.71 113.66,19.71 113.58,19.63 113.58,19.46 113.49,19.37 113.32,19.37 113.24,19.45 113.24,19.63 113.16,19.71 112.19,19.71 111.62,20.28 111.62,20.29 111.41,20.5 110.93,20.5 110.83,20.6 110.83,21.94 110.6,22.17 109.32,22.17 108.42,23.07 108.42,28.91 108.17,29.16 108.17,29.28 108.52,29.63 108.52,29.75 108.4,29.87 108.29,29.87 107.87,29.46 107.71,29.46 106.79,30.38 106.79,30.61 107.14,30.96 107.14,31.09 107.03,31.21 106.91,31.21 106.58,30.87 106.46,30.87 102.8,34.53 102.8,36.11 101.43,37.48 101.43,42.75 101.58,42.9 101.58,43.06 arc(101.52,43.29) 101.58,43.51 101.58,43.52 arc(101.64,43.75) 101.58,43.98 arc(101.41,44.14) 101.19,44.21 101.17,44.21 arc(100.95,44.27) 100.78,44.44 v1(100.38,45.13)
  L14_SIG5 w0.081: v1(115.26,19.34) 114.89,18.97 105.47,18.97 v1(105.1,19.34) 104.73,18.97 95.31,18.97 v1(94.94,19.34) 94.57,18.97 85.4,18.97 85.03,19.34 v1(84.78,19.34) 84.35,18.91 84.35,18.39 84.13,18.17 78.21,18.17 78.08,18.3 76.9,18.3 76.23,18.96 75.24,18.96 74.87,19.33 v1(74.59,19.33)
  BOTTOM w0.149: R888.2 76.31,20.7 76.22,20.7 76.04,20.52 76.04,20 75.78,19.74 75.57,19.74 75.56,19.73 75.23,19.73 75.22,19.74 75,19.74 v1(74.59,19.33)
DDR4_COMP_CH0_BG0: length 83.5
  L03_SIG1 w0.081: v1(99.59,44.67) 99.99,43.97 arc(100.16,43.81) 100.38,43.75 100.39,43.75 arc(100.62,43.68) 100.78,43.52 arc(100.83,43.41) 100.84,43.29 100.84,43.24 arc(100.82,43.09) 100.73,42.97 100.31,42.54 arc(100.3,42.53) 100.29,42.53 99.75,41.92 arc(99.7,41.88) 99.65,41.85 arc(99.46,41.75) 99.29,41.61 99.04,41.36 arc(98.95,41.22) 98.92,41.07 98.92,39.87 98.95,39.84 98.95,38.43 98.92,38.4 98.92,37.98 99.64,37.26 99.68,37.26 100.6,36.33 100.85,36.33 101.17,36.66 101.39,36.66 101.53,36.51 101.53,35.86 101.22,35.54 101.22,35.35 104.17,32.4 104.17,32.28 104.02,32.13 104.02,32.02 104.15,31.9 104.26,31.9 104.41,32.05 104.53,32.05 104.65,31.92 104.65,31.81 104.5,31.66 104.5,31.54 104.62,31.42 104.73,31.42 104.89,31.57 105,31.57 105.12,31.45 105.12,31.34 104.97,31.19 104.97,31.07 105.09,30.95 105.21,30.95 105.36,31.1 105.47,31.1 105.6,30.98 105.6,30.86 105.45,30.71 105.45,30.6 105.57,30.47 105.68,30.47 105.83,30.62 105.95,30.62 106.07,30.5 106.07,30.39 105.92,30.24 105.92,30.12 106.04,30 106.16,30 106.31,30.15 106.42,30.15 106.79,29.78 106.79,29.33 106.87,29.25 107.12,29.25 107.2,29.17 107.2,29 107.12,28.92 106.87,28.92 106.79,28.84 106.79,28.66 106.87,28.58 107.12,28.58 107.2,28.5 107.2,28.33 107.12,28.25 106.87,28.25 106.79,28.17 106.79,27.99 106.87,27.91 107.12,27.91 107.2,27.83 107.2,27.66 107.12,27.58 106.87,27.58 106.79,27.5 106.79,27.32 106.87,27.24 107.12,27.24 107.2,27.16 107.2,26.99 107.12,26.91 106.87,26.91 106.79,26.82 106.79,26.65 106.87,26.57 107.12,26.57 107.2,26.49 107.2,26.32 107.12,26.24 106.87,26.24 106.79,26.15 106.79,23.23 109.46,20.56 110.03,20.56 v1(110.46,20.14)
  L12_SIG4 w0.089: v1(110.46,20.14) 110.05,20.55 100.71,20.55 v1(100.3,20.14) 99.89,20.55 90.55,20.55 v1(90.14,20.14) 89.73,19.73 88.86,19.73 88.04,20.55 87.09,20.55 87,20.46 87,20.34 86.91,20.25 86.75,20.25 86.66,20.34 86.66,20.43 86.57,20.52 80.36,20.52 v1(79.98,20.14) 79.57,20.55 77.04,20.55 76.93,20.44 76.7,20.44 76.62,20.52 73.15,20.52 72.35,19.71 70.21,19.71 v1(69.79,20.13)
  BOTTOM w0.149: R885.2 68.38,20.95 68.68,20.65 68.7,20.65 68.83,20.53 69.4,20.53 v1(69.79,20.13)
DDR4_COMP_CH0_BG1: length 84.5
  L03_SIG1 w0.081: v1(116.06,20.14) 116.62,20.7 116.62,22.85 116.43,23.04 116.43,28.04 116.59,28.2 116.88,28.2 117.1,28.41 117.1,29.27 117,29.37 116.01,29.37 115.91,29.47 115.91,29.62 115.99,29.7 116.94,29.7 117.02,29.78 117.02,29.95 116.94,30.04 116.03,30.04 115.95,30.12 115.95,30.29 116.03,30.37 116.88,30.37 116.96,30.45 116.96,30.63 116.88,30.71 116.52,30.71 116.44,30.79 116.44,30.96 116.52,31.04 116.88,31.04 116.96,31.12 116.96,31.3 116.88,31.38 116.16,31.38 114.41,33.13 113.71,33.13 113.62,33.22 113.62,33.84 113.53,33.93 113.37,33.93 113.29,33.85 113.29,33.24 113.21,33.16 113.04,33.16 112.95,33.24 112.95,33.84 112.86,33.93 112.7,33.93 112.62,33.85 112.62,33.22 112.54,33.13 112.36,33.13 112.28,33.22 112.28,33.84 112.19,33.93 112.03,33.93 111.95,33.85 111.95,33.22 111.87,33.13 111.69,33.13 111.61,33.22 111.61,33.84 111.52,33.93 111.36,33.93 111.28,33.85 111.28,33.22 111.2,33.13 110.22,33.13 110.14,33.22 110.14,33.81 110.06,33.89 109.88,33.89 109.8,33.81 109.8,33.22 109.72,33.13 109.38,33.13 106.84,35.68 106.58,35.68 106.25,36.01 105.96,36.01 105.86,36.11 105.86,36.25 105.96,36.35 106.2,36.35 106.28,36.43 106.28,36.6 106.2,36.68 105.96,36.68 105.86,36.78 105.86,37.66 106.07,37.87 106.66,37.87 v1(106.76,37.77)
  L14_SIG5 w0.081: v1(75.39,20.13) 76.23,20.13 76.6,19.77 84.04,19.77 84.04,19.77 84.13,19.77 84.35,19.99 84.35,20.27 84.58,20.5 85.22,20.5 v1(85.58,20.14) 88.32,20.14 88.72,20.53 95.35,20.53 v1(95.74,20.14) 95.74,20.21 96.06,20.53 105.51,20.53 v1(105.9,20.14) 106.28,20.52 115.68,20.52 v1(116.06,20.14)
  BOTTOM w0.149: v1(75.39,20.13) 75.39,20.32 75.82,20.75 75.82,21.06 76.16,21.39 76.16,21.68 R886.2
