# Allegro board FM85_AGILEX_PCIE_DK_CMC_ADI_REVC.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
FDMC8878_VER2
  rect 0.406x0.914 smd: 1(-0.975,-1.643) 2(-0.325,-1.643) 3(0.325,-1.643) 4(0.975,-1.643)
  custom 0.589x0.589 smd: 5(0,0.85)
IFSC1008ABER1R0M01
  rect 1.372x2.261 smd: 1(-1.086,0) 2(1.086,0)
IND_FP0805-CUS
  rect 2.79x3.43 smd: 1(-2.565,0) 2(2.565,0)
IND_XGL5030
  rect 1.18x4.7 smd: 1(-1.655,0) 2(1.655,0)
LCC12_S30_50DF25X17MA
  rect 0.279x0.787 smd: 1(-1.25,-1.494) 2(-0.75,-1.494) 3(-0.25,-1.494) 4(0.25,-1.494) 5(0.75,-1.494) 6(1.25,-1.494) 7(1.25,1.494) 8(0.75,1.494) 9(0.25,1.494) 10(-0.25,1.494) 11(-0.75,1.494) 12(-1.25,1.494)
  rect 2.616x1.422 smd: 13(0,0)
LED0603_4PIN_APHB1608
  rect 0.787x0.406 smd: 1(0.744,-0.353) 2(-0.744,-0.353) 3(0.744,0.353) 4(-0.744,0.353)
LED_0603
  rect 1.092x0.991 smd: A(-0.851,0) C(0.851,0)
LGA25C127P5X5_625X625X192N
  round 0.73 smd: A1(-2.54,2.54) A2(-1.27,2.54) A3(0,2.54) A4(1.27,2.54) A5(2.54,2.54) B1(-2.54,1.27) B2(-1.27,1.27) B3(0,1.27) B4(1.27,1.27) B5(2.54,1.27) C1(-2.54,0) C2(-1.27,0) C3(0,0) C4(1.27,0) C5(2.54,0) D1(-2.54,-1.27) D2(-1.27,-1.27) D3(0,-1.27) D4(1.27,-1.27) D5(2.54,-1.27) E1(-2.54,-2.54) E2(-1.27,-2.54) E3(0,-2.54) E4(1.27,-2.54) E5(2.54,-2.54)
LGA108C127P9X12_1190X1600X192N
  round 0.63 smd: A1(-5.08,6.985) A2(-3.81,6.985) A3(-2.54,6.985) A4(-1.27,6.985) A5(0,6.985) A6(1.27,6.985) A7(2.54,6.985) A8(3.81,6.985) A9(5.08,6.985) B1(-5.08,5.715) B2(-3.81,5.715) B3(-2.54,5.715) B4(-1.27,5.715) B5(0,5.715) B6(1.27,5.715) B7(2.54,5.715) B8(3.81,5.715) B9(5.08,5.715) C1(-5.08,4.445) C2(-3.81,4.445) C3(-2.54,4.445) C4(-1.27,4.445) C5(0,4.445) C6(1.27,4.445) C7(2.54,4.445) C8(3.81,4.445) C9(5.08,4.445) D1(-5.08,3.175) D2(-3.81,3.175) D3(-2.54,3.175) D4(-1.27,3.175) D5(0,3.175) D6(1.27,3.175) D7(2.54,3.175) D8(3.81,3.175) D9(5.08,3.175) E1(-5.08,1.905) E2(-3.81,1.905) E3(-2.54,1.905) E4(-1.27,1.905) E5(0,1.905) E6(1.27,1.905) E7(2.54,1.905) E8(3.81,1.905) E9(5.08,1.905) F1(-5.08,0.635) F2(-3.81,0.635) F3(-2.54,0.635) F4(-1.27,0.635) F5(0,0.635) F6(1.27,0.635) F7(2.54,0.635) F8(3.81,0.635) F9(5.08,0.635) G1(-5.08,-0.635) G2(-3.81,-0.635) G3(-2.54,-0.635) G4(-1.27,-0.635) G5(0,-0.635) G6(1.27,-0.635) G7(2.54,-0.635) G8(3.81,-0.635) G9(5.08,-0.635) H1(-5.08,-1.905) H2(-3.81,-1.905) H3(-2.54,-1.905) H4(-1.27,-1.905) H5(0,-1.905) H6(1.27,-1.905) H7(2.54,-1.905) H8(3.81,-1.905) H9(5.08,-1.905) J1(-5.08,-3.175) J2(-3.81,-3.175) J3(-2.54,-3.175) J4(-1.27,-3.175) J5(0,-3.175) J6(1.27,-3.175) J7(2.54,-3.175) J8(3.81,-3.175) J9(5.08,-3.175) K1(-5.08,-4.445) K2(-3.81,-4.445) K3(-2.54,-4.445) K4(-1.27,-4.445) K5(0,-4.445) K6(1.27,-4.445) K7(2.54,-4.445) K8(3.81,-4.445) K9(5.08,-4.445) L1(-5.08,-5.715) L2(-3.81,-5.715) L3(-2.54,-5.715) L4(-1.27,-5.715) L5(0,-5.715) L6(1.27,-5.715) L7(2.54,-5.715) L8(3.81,-5.715) L9(5.08,-5.715) M1(-5.08,-6.985) M2(-3.81,-6.985) M3(-2.54,-6.985) M4(-1.27,-6.985) M5(0,-6.985) M6(1.27,-6.985) M7(2.54,-6.985) M8(3.81,-6.985) M9(5.08,-6.985)
LIGHTPIPE_P-U90-1101-T00A-BP
  round 1.549 hole 1.549 unplated: (0,0) (0,-4) (2.1,-8)
LQFN_28_5MMX4MM
  rect 0.375x0.375 smd: (-1.812,2.312) (-1.812,-2.312) (1.812,2.312) (1.812,-2.312)
  oval 0.787x0.279 smd: 1(-1.994,1.75) 2(-1.994,1.25) 3(-1.994,0.75) 4(-1.994,0.25) 5(-1.994,-0.25) 6(-1.994,-0.75) 7(-1.994,-1.25) 8(-1.994,-1.75) 15(1.994,-1.75) 16(1.994,-1.25) 17(1.994,-0.75) 18(1.994,-0.25) 19(1.994,0.25) 20(1.994,0.75) 21(1.994,1.25) 22(1.994,1.75)
  oval 0.279x0.787 smd: 9(-1.25,-2.494) 10(-0.75,-2.494) 11(-0.25,-2.494) 12(0.25,-2.494) 13(0.75,-2.494) 14(1.25,-2.494) 23(1.25,2.494) 24(0.75,2.494) 25(0.25,2.494) 26(-0.25,2.494) 27(-0.75,2.494) 28(-1.25,2.494)
  rect 1.092x1.575 smd: 29(0.673,0.927) 30(-0.673,0.927) 31(-0.673,-0.927) 32(0.673,-0.927)
LT3042IDD
  rect 0.279x0.787 smd: 1(-1,-1.494) 2(-0.5,-1.494) 3(0,-1.494) 4(0.5,-1.494) 5(1,-1.494) 6(1,1.494) 7(0.5,1.494) 8(0,1.494) 9(-0.5,1.494) 10(-1,1.494)
  rect 2.489x1.422 smd: 11(0,0)
LTC-BGA-49-1518
  round 0.406 smd: A1(-2.4,2.4) A2(-1.6,2.4) A3(-0.8,2.4) A4(0,2.4) A5(0.8,2.4) A6(1.6,2.4) A7(2.4,2.4) B1(-2.4,1.6) B2(-1.6,1.6) B3(-0.8,1.6) B4(0,1.6) B5(0.8,1.6) B6(1.6,1.6) B7(2.4,1.6) C1(-2.4,0.8) C2(-1.6,0.8) C3(-0.8,0.8) C4(0,0.8) C5(0.8,0.8) C6(1.6,0.8) C7(2.4,0.8) D1(-2.4,0) D2(-1.6,0) D3(-0.8,0) D4(0,0) D5(0.8,0) D6(1.6,0) D7(2.4,0) E1(-2.4,-0.8) E2(-1.6,-0.8) E3(-0.8,-0.8) E4(0,-0.8) E5(0.8,-0.8) E6(1.6,-0.8) E7(2.4,-0.8) F1(-2.4,-1.6) F2(-1.6,-1.6) F3(-0.8,-1.6) F4(0,-1.6) F5(0.8,-1.6) F6(1.6,-1.6) F7(2.4,-1.6) G1(-2.4,-2.4) G2(-1.6,-2.4) G3(-0.8,-2.4) G4(0,-2.4) G5(0.8,-2.4) G6(1.6,-2.4) G7(2.4,-2.4)
MH_D125C175T_TB315
  round 8.001 hole 3.175: 1(0,0)
MLX_SD-5569_8POS_RA
  round 2.997 hole 2.997 unplated: (0,7.29) (12.573,7.29)
  rect 2.286x2.286 hole 1.803: 1(0,0)
  round 2.286 hole 1.803: 2(4.191,0) 3(8.382,0) 4(12.573,0) 5(0,-4.202) 6(4.191,-4.202) 7(8.382,-4.202) 8(12.573,-4.202)
MOLEX-MICRO-USB-47589-001
  rect 1.8x1.9 smd: (-1.15,0) (1.15,0)
  rect 0.406x1.346 smd: 1(1.3,-2.673) 2(0.65,-2.673) 3(0,-2.673) 4(-0.65,-2.673) 5(-1.3,-2.673)
  oval 1.05x1.25 hole 0.65x0.85: 6(-2.225,-3) 7(2.225,-3)
  rect 2.075x1.9 hole 1.3x0.6: 8(-4.175,0) 9(4.175,0)
MOLEX_70247-1051
  rect 1.651x1.651 hole 1.143: 1(0,0)
  round 1.651 hole 1.143: 2(0,2.54) 3(2.54,0) 4(2.54,2.54) 5(5.08,0) 6(5.08,2.54) 7(7.62,0) 8(7.62,2.54) 9(10.16,0) 10(10.16,2.54)
MOLEX_0470533000
  round 1.245 hole 1.245 unplated: (-5.08,-2.16)
  rect 1.524x1.524 hole 1.016: 1(0,0)
  round 1.524 hole 1.016: 2(-2.54,0) 3(-5.08,0) 4(-7.62,0)
MOLEX_QSFPDD_CAGE
  rect 2.007x4.013 hole 1.05: 1(0,0) 2(0,10.7) 3(0,19.7) 4(0,28.7) 5(0,37.7) 6(-19,-4.5) 7(-19,6.2) 8(-19,15.2) 9(-19,24.2) 10(-19,33.2)
  round 1.575 hole 1.05: 11(-4.5,-20) 12(-11.7,-20)
MSOP-8
  rect 0.406x1.778 smd: 1(-0.975,-2.271) 2(-0.325,-2.271) 3(0.325,-2.271) 4(0.975,-2.271) 5(0.975,2.271) 6(0.325,2.271) 7(-0.325,2.271) 8(-0.975,2.271)
NFET_PSMN1R0-30YLD
  rect 0.635x1.6 smd: 1(-1.905,-2.8) 2(-0.635,-2.8) 3(0.635,-2.8) 4(1.905,-2.8)
  rect 4.674x4.775 smd: 5(0,1.213)
PADSTYLE1
  round 0.762 smd: 1(0,0)
PCIX-16PORT
  rect 0.6x3 smd: A1(0,0) A2(1,0) A3(2,0) A4(3,0) A5(4,0) A6(5,0) A7(6,0) A8(7,0) A9(8,0) A10(9,0) A11(10,0) A12(13,0) A13(14,0) A14(15,0) A15(16,0) A16(17,0) A17(18,0) A18(19,0) A19(20,0) A20(21,0) A21(22,0) A22(23,0) A23(24,0) A24(25,0) A25(26,0) A26(27,0) A27(28,0) A28(29,0) A29(30,0) A30(31,0) A31(32,0) A32(33,0) A33(34,0) A34(35,0) A35(36,0) A36(37,0) A37(38,0) A38(39,0) A39(40,0) A40(41,0) A41(42,0) A42(43,0) A43(44,0) A44(45,0) A45(46,0) A46(47,0) A47(48,0) A48(49,0) A49(50,0) A50(51,0) A51(52,0) A52(53,0) A53(54,0) A54(55,0) A55(56,0) A56(57,0) A57(58,0) A58(59,0) A59(60,0) A60(61,0) A61(62,0) A62(63,0) A63(64,0) A64(65,0) A65(66,0) A66(67,0) A67(68,0) A68(69,0) A69(70,0) A70(71,0) A71(72,0) A72(73,0) A73(74,0) A74(75,0) A75(76,0) A76(77,0) A77(78,0) A78(79,0) A79(80,0) A80(81,0) A81(82,0) A82(83,0) B1(0,0) B2(1,0) B3(2,0) B4(3,0) B5(4,0) B6(5,0) B7(6,0) B8(7,0) B9(8,0) B10(9,0) B11(10,0) B12(13,0) B13(14,0) B14(15,0) B15(16,0) B16(17,0) B17(18,0) B18(19,0) B19(20,0) B20(21,0) B21(22,0) B22(23,0) B23(24,0) B24(25,0) B25(26,0) B26(27,0) B27(28,0) B28(29,0) B29(30,0) B30(31,0) B31(32,0) B32(33,0) B33(34,0) B34(35,0) B35(36,0) B36(37,0) B37(38,0) B38(39,0) B39(40,0) B40(41,0) B41(42,0) B42(43,0) B43(44,0) B44(45,0) B45(46,0) B46(47,0) B47(48,0) B48(49,0) B49(50,0) B50(51,0) B51(52,0) B52(53,0) B53(54,0) B54(55,0) B55(56,0) B56(57,0) B57(58,0) B58(59,0) B59(60,0) B60(61,0) B61(62,0) B62(63,0) B63(64,0) B64(65,0) B65(66,0) B66(67,0) B67(68,0) B68(69,0) B69(70,0) B70(71,0) B71(72,0) B72(73,0) B73(74,0) B74(75,0) B75(76,0) B76(77,0) B77(78,0) B78(79,0) B79(80,0) B80(81,0) B81(82,0) B82(83,0)
QFN32L
  oval 0.787x0.279 smd: 1(-2.494,1.75) 2(-2.494,1.25) 3(-2.494,0.75) 4(-2.494,0.25) 5(-2.494,-0.25) 6(-2.494,-0.75) 7(-2.494,-1.25) 8(-2.494,-1.75) 17(2.494,-1.75) 18(2.494,-1.25) 19(2.494,-0.75) 20(2.494,-0.25) 21(2.494,0.25) 22(2.494,0.75) 23(2.494,1.25) 24(2.494,1.75)
  oval 0.279x0.787 smd: 9(-1.75,-2.494) 10(-1.25,-2.494) 11(-0.75,-2.494) 12(-0.25,-2.494) 13(0.25,-2.494) 14(0.75,-2.494) 15(1.25,-2.494) 16(1.75,-2.494) 25(1.75,2.494) 26(1.25,2.494) 27(0.75,2.494) 28(0.25,2.494) 29(-0.25,2.494) 30(-0.75,2.494) 31(-1.25,2.494) 32(-1.75,2.494)
  rect 3.404x3.404 smd: 33(0,0)
QFN40P500X800X80-53N
  rect 0.69x0.22 smd: 1(-2.42,3.2) 2(-2.42,2.8) 3(-2.42,2.4) 4(-2.42,2) 5(-2.42,1.6) 6(-2.42,1.2) 7(-2.42,0.8) 8(-2.42,0.4) 9(-2.42,0) 10(-2.42,-0.4) 11(-2.42,-0.8) 12(-2.42,-1.2) 13(-2.42,-1.6) 14(-2.42,-2) 15(-2.42,-2.4) 16(-2.42,-2.8) 17(-2.42,-3.2) 27(2.42,-3.2) 28(2.42,-2.8) 29(2.42,-2.4) 30(2.42,-2) 31(2.42,-1.6) 32(2.42,-1.2) 33(2.42,-0.8) 34(2.42,-0.4) 35(2.42,0) 36(2.42,0.4) 37(2.42,0.8) 38(2.42,1.2) 39(2.42,1.6) 40(2.42,2) 41(2.42,2.4) 42(2.42,2.8) 43(2.42,3.2)
  rect 0.22x0.69 smd: 18(-1.6,-3.92) 19(-1.2,-3.92) 20(-0.8,-3.92) 21(-0.4,-3.92) 22(0,-3.92) 23(0.4,-3.92) 24(0.8,-3.92) 25(1.2,-3.92) 26(1.6,-3.92) 44(1.6,3.92) 45(1.2,3.92) 46(0.8,3.92) 47(0.4,3.92) 48(0,3.92) 49(-0.4,3.92) 50(-0.8,3.92) 51(-1.2,3.92) 52(-1.6,3.92)
  rect 3.75x6.75 smd: 53(0,0)
QFN50P410X410X80-25-CUST
  rrect 0.254x0.61 smd: 1(-1.25,-1.9) 2(-0.75,-1.9) 3(-0.25,-1.9) 4(0.25,-1.9) 5(0.75,-1.9) 6(1.25,-1.9) 13(1.25,1.9) 14(0.75,1.9) 15(0.25,1.9) 16(-0.25,1.9) 17(-0.75,1.9) 18(-1.25,1.9)
  rrect 0.61x0.254 smd: 7(1.9,-1.25) 8(1.9,-0.75) 9(1.9,-0.25) 10(1.9,0.25) 11(1.9,0.75) 12(1.9,1.25) 19(-1.9,1.25) 20(-1.9,0.75) 21(-1.9,0.25) 22(-1.9,-0.25) 23(-1.9,-0.75) 24(-1.9,-1.25)
  rrect 2.438x2.438 smd: 25(0,0)
QFN56
  oval 0.813x0.279 smd: 1(-3.9,3.25) 2(-3.9,2.75) 3(-3.9,2.25) 4(-3.9,1.75) 5(-3.9,1.25) 6(-3.9,0.75) 7(-3.9,0.25) 8(-3.9,-0.25) 9(-3.9,-0.75) 10(-3.9,-1.25) 11(-3.9,-1.75) 12(-3.9,-2.25) 13(-3.9,-2.75) 14(-3.9,-3.25) 29(3.9,-3.25) 30(3.9,-2.75) 31(3.9,-2.25) 32(3.9,-1.75) 33(3.9,-1.25) 34(3.9,-0.75) 35(3.9,-0.25) 36(3.9,0.25) 37(3.9,0.75) 38(3.9,1.25) 39(3.9,1.75) 40(3.9,2.25) 41(3.9,2.75) 42(3.9,3.25)
  oval 0.279x0.813 smd: 15(-3.25,-3.9) 16(-2.75,-3.9) 17(-2.25,-3.9) 18(-1.75,-3.9) 19(-1.25,-3.9) 20(-0.75,-3.9) 21(-0.25,-3.9) 22(0.25,-3.9) 23(0.75,-3.9) 24(1.25,-3.9) 25(1.75,-3.9) 26(2.25,-3.9) 27(2.75,-3.9) 28(3.25,-3.9) 43(3.25,3.9) 44(2.75,3.9) 45(2.25,3.9) 46(1.75,3.9) 47(1.25,3.9) 48(0.75,3.9) 49(0.25,3.9) 50(-0.25,3.9) 51(-0.75,3.9) 52(-1.25,3.9) 53(-1.75,3.9) 54(-2.25,3.9) 55(-2.75,3.9) 56(-3.25,3.9)
  rect 5.842x5.842 smd: 57(0,0)
QFN64_9X9_SI5391
  round 1.016 smd: (-5.881,-6.135) (5.5,5.5)
  oval 0.838x0.279 smd: 1(-4.469,3.75) 2(-4.469,3.25) 3(-4.469,2.75) 4(-4.469,2.25) 5(-4.469,1.75) 6(-4.469,1.25) 7(-4.469,0.75) 8(-4.469,0.25) 9(-4.469,-0.25) 10(-4.469,-0.75) 11(-4.469,-1.25) 12(-4.469,-1.75) 13(-4.469,-2.25) 14(-4.469,-2.75) 15(-4.469,-3.25) 16(-4.469,-3.75) 33(4.469,-3.75) 34(4.469,-3.25) 35(4.469,-2.75) 36(4.469,-2.25) 37(4.469,-1.75) 38(4.469,-1.25) 39(4.469,-0.75) 40(4.469,-0.25) 41(4.469,0.25) 42(4.469,0.75) 43(4.469,1.25) 44(4.469,1.75) 45(4.469,2.25) 46(4.469,2.75) 47(4.469,3.25) 48(4.469,3.75)
  oval 0.279x0.838 smd: 17(-3.75,-4.469) 18(-3.25,-4.469) 19(-2.75,-4.469) 20(-2.25,-4.469) 21(-1.75,-4.469) 22(-1.25,-4.469) 23(-0.75,-4.469) 24(-0.25,-4.469) 25(0.25,-4.469) 26(0.75,-4.469) 27(1.25,-4.469) 28(1.75,-4.469) 29(2.25,-4.469) 30(2.75,-4.469) 31(3.25,-4.469) 32(3.75,-4.469) 49(3.75,4.469) 50(3.25,4.469) 51(2.75,4.469) 52(2.25,4.469) 53(1.75,4.469) 54(1.25,4.469) 55(0.75,4.469) 56(0.25,4.469) 57(-0.25,4.469) 58(-0.75,4.469) 59(-1.25,4.469) 60(-1.75,4.469) 61(-2.25,4.469) 62(-2.75,4.469) 63(-3.25,4.469) 64(-3.75,4.469)
  rect 5.283x5.283 smd: 65(0,0)
QFN65P400X400X80-17NA
  rect 1.01x0.32 smd: 1(-1.86,0.975) 2(-1.86,0.325) 3(-1.86,-0.325) 4(-1.86,-0.975) 9(1.86,-0.975) 10(1.86,-0.325) 11(1.86,0.325) 12(1.86,0.975)
  rect 0.32x1.01 smd: 5(-0.975,-1.86) 6(-0.325,-1.86) 7(0.325,-1.86) 8(0.975,-1.86) 13(0.975,1.86) 14(0.325,1.86) 15(-0.325,1.86) 16(-0.975,1.86)
  rect 2.25x2.25 smd: 17(0,0)
QFN-56
  oval 0.787x0.279 smd: 1(-2.494,4.75) 2(-2.494,4.25) 3(-2.494,3.75) 4(-2.494,3.25) 5(-2.494,2.75) 6(-2.494,2.25) 7(-2.494,1.75) 8(-2.494,1.25) 9(-2.494,0.75) 10(-2.494,0.25) 11(-2.494,-0.25) 12(-2.494,-0.75) 13(-2.494,-1.25) 14(-2.494,-1.75) 15(-2.494,-2.25) 16(-2.494,-2.75) 17(-2.494,-3.25) 18(-2.494,-3.75) 19(-2.494,-4.25) 20(-2.494,-4.75) 29(2.494,-4.75) 30(2.494,-4.25) 31(2.494,-3.75) 32(2.494,-3.25) 33(2.494,-2.75) 34(2.494,-2.25) 35(2.494,-1.75) 36(2.494,-1.25) 37(2.494,-0.75) 38(2.494,-0.25) 39(2.494,0.25) 40(2.494,0.75) 41(2.494,1.25) 42(2.494,1.75) 43(2.494,2.25) 44(2.494,2.75) 45(2.494,3.25) 46(2.494,3.75) 47(2.494,4.25) 48(2.494,4.75)
  oval 0.279x0.787 smd: 21(-1.75,-5.494) 22(-1.25,-5.494) 23(-0.75,-5.494) 24(-0.25,-5.494) 25(0.25,-5.494) 26(0.75,-5.494) 27(1.25,-5.494) 28(1.75,-5.494) 49(1.75,5.494) 50(1.25,5.494) 51(0.75,5.494) 52(0.25,5.494) 53(-0.25,5.494) 54(-0.75,5.494) 55(-1.25,5.494) 56(-1.75,5.494)
  rect 2.489x8.484 smd: 57(0,0)
R0402
  rect 0.508x0.508 smd: 1(0,0.445) 2(0,-0.445)
RC0402
  rect 0.63x0.73 smd: 1(-0.51,0) 2(0.51,0)
RES_CSNL2512_0_005-0_006
  rect 2.38x3.4 smd: 1(-2.21,0) 2(2.21,0)
RESC1005X40L20L
  rect 0.508x0.508 smd: 1(0,0.445) 2(0,-0.445)
RESC1608X60L27N
  rect 1.016x1.016 smd: 1(-0.762,0) 2(0.762,0)
SC70-6
  rect 1.219x0.406 smd: 1(-1.01,0.65) 2(-1.01,0) 3(-1.01,-0.65) 4(1.01,-0.65) 5(1.01,0) 6(1.01,0.65)
SC70_TI
  rect 0.406x1.245 smd: 1(-0.65,-0.997) 2(0,-0.997) 3(0.65,-0.997) 4(0.65,0.997) 5(-0.65,0.997)
SCONN74_K64129002_PIP
  round 0.254 hole 1.295 unplated: (1.5,1.35) (1.5,-22.95)
  rect 1.194x0.356 smd: A1(0,0) A2(0,-0.6) A3(0,-1.2) A4(0,-1.8) A5(0,-2.4) A6(0,-3) A7(0,-3.6) A8(0,-4.2) A9(0,-4.8) A10(0,-5.4) A11(0,-6) A12(0,-6.6) A13(0,-7.2) A14(0,-7.8) A15(0,-8.4) A16(0,-9) A17(0,-9.6) A18(0,-10.2) A19(0,-10.8) A20(0,-11.4) A21(0,-12) A22(0,-12.6) A23(0,-13.2) A24(0,-13.8) A25(0,-14.4) A26(0,-15) A27(0,-15.6) A28(0,-16.2) A29(0,-16.8) A30(0,-17.4) A31(0,-18) A32(0,-18.6) A33(0,-19.2) A34(0,-19.8) A35(0,-20.4) A36(0,-21) A37(0,-21.6) B1(4.6,0) B2(4.6,-0.6) B3(4.6,-1.2) B4(4.6,-1.8) B5(4.6,-2.4) B6(4.6,-3) B7(4.6,-3.6) B8(4.6,-4.2) B9(4.6,-4.8) B10(4.6,-5.4) B11(4.6,-6) B12(4.6,-6.6) B13(4.6,-7.2) B14(4.6,-7.8) B15(4.6,-8.4) B16(4.6,-9) B17(4.6,-9.6) B18(4.6,-10.2) B19(4.6,-10.8) B20(4.6,-11.4) B21(4.6,-12) B22(4.6,-12.6) B23(4.6,-13.2) B24(4.6,-13.8) B25(4.6,-14.4) B26(4.6,-15) B27(4.6,-15.6) B28(4.6,-16.2) B29(4.6,-16.8) B30(4.6,-17.4) B31(4.6,-18) B32(4.6,-18.6) B33(4.6,-19.2) B34(4.6,-19.8) B35(4.6,-20.4) B36(4.6,-21) B37(4.6,-21.6)
  round 1.194 hole 0.813: MH1(-0.9,1.875) MH2(4.69,1.375) MH3(-0.9,-23.475) MH4(4.69,-22.975)
SHORT
  rect 0.305x0.406 smd: 1(0,0.254) 2(0,-0.254)
SI53254_QFN40
  oval 0.787x0.279 smd: 1(-2.994,2.25) 2(-2.994,1.75) 3(-2.994,1.25) 4(-2.994,0.75) 5(-2.994,0.25) 6(-2.994,-0.25) 7(-2.994,-0.75) 8(-2.994,-1.25) 9(-2.994,-1.75) 10(-2.994,-2.25) 21(2.994,-2.25) 22(2.994,-1.75) 23(2.994,-1.25) 24(2.994,-0.75) 25(2.994,-0.25) 26(2.994,0.25) 27(2.994,0.75) 28(2.994,1.25) 29(2.994,1.75) 30(2.994,2.25)
  oval 0.279x0.787 smd: 11(-2.25,-2.994) 12(-1.75,-2.994) 13(-1.25,-2.994) 14(-0.75,-2.994) 15(-0.25,-2.994) 16(0.25,-2.994) 17(0.75,-2.994) 18(1.25,-2.994) 19(1.75,-2.994) 20(2.25,-2.994) 31(2.25,2.994) 32(1.75,2.994) 33(1.25,2.994) 34(0.75,2.994) 35(0.25,2.994) 36(-0.25,2.994) 37(-0.75,2.994) 38(-1.25,2.994) 39(-1.75,2.994) 40(-2.25,2.994)
  rect 4.42x4.42 smd: 41(0,0)
SL1616A-R10MHF
  rect 1.956x1.905 smd: 1(-1.428,0) 2(1.428,0)
SMC0201IA
  rect 0.33x0.305 smd: 1(-0.267,0) 2(0.267,0)
SO8
  rect 2.032x0.635 smd: 1(-2.584,1.905) 2(-2.584,0.635) 3(-2.584,-0.635) 4(-2.584,-1.905) 5(2.584,-1.905) 6(2.584,-0.635) 7(2.584,0.635) 8(2.584,1.905)
SOIC-8
  rect 2.032x0.635 smd: 1(-2.584,1.905) 2(-2.584,0.635) 3(-2.584,-0.635) 4(-2.584,-1.905) 5(2.584,-1.905) 6(2.584,-0.635) 7(2.584,0.635) 8(2.584,1.905)
SOT23
  rect 1.016x1.422 smd: 1(-0.95,-1.1) 2(0.95,-1.1) 3(0,1.1)
SOT23-3
  rect 0.965x1.422 smd: 1(-0.95,-1.111) 2(0.95,-1.111) 3(0,1.111)
SOT-143
  rect 0.9x1.2 smd: 1(-1,0.9)
  rect 0.9x0.8 smd: 2(-1,-0.9) 3(1,-1) 4(1,1)
T-PBGA24
  round 0.406 smd: A2(-1,2) A3(0,2) A4(1,2) A5(2,2) B1(-2,1) B2(-1,1) B3(0,1) B4(1,1) B5(2,1) C1(-2,0) C2(-1,0) C3(0,0) C4(1,0) C5(2,0) D1(-2,-1) D2(-1,-1) D3(0,-1) D4(1,-1) D5(2,-1) E1(-2,-2) E2(-1,-2) E3(0,-2) E4(1,-2) E5(2,-2)
TFBGA24
  round 0.33 smd: A2(-1,2) A3(0,2) A4(1,2) A5(2,2) B1(-2,1) B2(-1,1) B3(0,1) B4(1,1) B5(2,1) C1(-2,0) C2(-1,0) C3(0,0) C4(1,0) C5(2,0) D1(-2,-1) D2(-1,-1) D3(0,-1) D4(1,-1) D5(2,-1) E1(-2,-2) E2(-1,-2) E3(0,-2) E4(1,-2) E5(2,-2)
TSSOP-14
  rect 1.499x0.406 smd: 1(-2.95,1.95) 2(-2.95,1.3) 3(-2.95,0.65) 4(-2.95,0) 5(-2.95,-0.65) 6(-2.95,-1.3) 7(-2.95,-1.95) 8(2.95,-1.95) 9(2.95,-1.3) 10(2.95,-0.65) 11(2.95,0) 12(2.95,0.65) 13(2.95,1.3) 14(2.95,1.95)
TVS_5P0SMDJ12A
  rect 2.438x3.454 smd: 1(3.378,0) 2(-3.378,0)
UMLP
  rect 0.45x0.25 smd: 1(-0.5,0)
  rect 0.25x0.35 smd: 2(-0.4,-0.45) 3(0,-0.45) 4(0.4,-0.45) 6(0.4,0.45) 7(0,0.45) 8(-0.4,0.45)
  rect 0.35x0.25 smd: 5(0.55,0)
unnamed#2
  round 0 smd: 1(0.02,0.198)
unnamed#3
  round 1.016 smd: 1(0,0)
UQFN-16
  rect 0.203x0.889 smd: 1(-0.6,-0.843)
  rect 0.203x0.787 smd: 2(-0.2,-0.894) 3(0.2,-0.894) 4(0.6,-0.894) 9(0.6,0.894) 10(0.2,0.894) 11(-0.2,0.894) 12(-0.6,0.894)
  rect 0.787x0.203 smd: 5(1.294,-0.6) 6(1.294,-0.2) 7(1.294,0.2) 8(1.294,0.6) 13(-1.294,0.6) 14(-1.294,0.2) 15(-1.294,-0.2) 16(-1.294,-0.6)
VSON-11
  custom 0.07x0.07 smd: 1(-1,-1.525) 2(-0.5,-1.525) 3(0,-1.525) 4(0.5,-1.525) 5(1,-1.525) 6(1,1.525) 7(0.5,1.525) 8(0,1.525) 9(-0.5,1.525) 10(-1,1.525)
  custom 0.412x0.412 smd: 11(0,0)
VSSOP-8
  rect 0.406x1.651 smd: 1(-0.975,-2.225) 2(-0.325,-2.225) 3(0.325,-2.225) 4(0.975,-2.225) 5(0.975,2.225) 6(0.325,2.225) 7(-0.325,2.225) 8(-0.975,2.225)
WURTH_6X3P5_TACT_SWITCH
  rect 2.311x1.499 smd: 1(-3.355,0) 2(3.355,0)
XEL4020-821
  rect 1.549x3.505 smd: 1(-1.41,0) 2(1.41,0)
XEL4030-201ME
  rect 1.651x3.505 smd: 1(-1.476,0) 2(1.476,0)
XTAL_3MMX2MM
  rect 1.372x1.143 smd: 1(-1.186,-0.922) 2(1.186,-0.922) 3(1.186,0.922) 4(-1.186,0.922)
XTAL_FA-128
  rect 0.94x0.838 smd: 1(-0.725,-0.575) 2(0.725,-0.575) 3(0.725,0.575) 4(-0.725,0.575)
XTAL_KC2520Z
  rect 1.05x0.95 smd: 1(-0.925,-0.725) 2(0.925,-0.725) 3(0.925,0.725) 4(-0.925,0.725)

## Nets
5V: C721.1 C722.1 C723.1 C724.1 C725.2 C7521.2 C7525.1 C7574.1 C7626.2 C7630.2 C7636.2 C7640.2 C7646.2 C7648.2 C7649.2 C7778.2 C7779.2 R357.2 R586.1 R836.1 R5837.2 R5927.2 R6054.1 R6056.1 R6102.2 R6108.1 R6119.1 R6121.1 R6127.1 R6132.2 R6133.2 R6134.2 U122.C1 U122.D1 U122.D2 U122.E1 U122.E2(VOUT5) U123.D5 U123.E5 U124.D5 U124.E5 U128.D5 U128.E5 U142.D5 U142.E5
5V_AGND: C720.1 C726.1 C727.1 R584.2 R588.2 R590.1 U122.B4
5V_PG: R578.1 R579.1 U34.C10 U122.C2
12V_AUX: C572.2 C573.1 D12.1(C) J11.1 J11.2 J11.3 R477.1 TP954.1 TP955.1 U44.1 U44.2 U44.3(S3) U46.2
12V_G1: C574.1 C575.2 C576.2 C577.2 C578.2 C583.1 C584.1 C585.1 C586.1 C1533.2 C1560.2 C1561.2 C1562.2 C1563.2 C1564.1 C1565.1 C1578.2 C1579.2 C1580.2 C1581.2 C1582.1 C1625.1(P) C1626.1(P) C1627.1(P) C1628.1(P) C1629.1(P) C1630.2 C1631.2 C1632.2 C1633.2 C1730.1 C1731.1 C1732.2 C1733.2 C1734.2 C1735.2 C1741.1 C1742.1 C1743.2 C1744.2 C1745.2 C1746.2 C7556.1 C7602.2 C7603.2 C7685.2 J9.2 R77.1 R78.1 R95.1 R96.1 R500.1 R6069.2 TP958.1 TP959.1 U45.1 U45.2 U45.3(S3) U47.6(VOUT) U116.A2 U116.B3 U116.D3 U116.E2 U119.32 U120.20 U120.21 U120.37 U120.38 U120.43(VIN5) U121.20 U121.21 U121.37 U121.38 U121.43(VIN5) U125.20 U125.21 U125.37 U125.38 U125.43(VIN5) U126.20 U126.21 U126.37 U126.38 U126.43(VIN5)
12V_G1_OV_PG: R499.1 U34.B10 U53.6
12V_G1_PG: R481.2 U34.D12 U47.7
12V_G1_UV_PG: R498.1 U34.E11 U53.1
12V_G2: C591.1 C592.1 C593.1 C594.1 C595.1 C596.1 C597.2 C717.2 C718.2 C719.2 C810.2 C811.2 C812.2 C813.2 C814.1 C827.2 C828.2 C829.2 C830.2 C831.1 C1333.2 C1334.2 C1335.2 C1336.2 C1360.1 C1361.1 C1364.2 C1381.1 C1382.1 C1385.2 C1890.1 C1891.2 C1892.2 C1893.2 C1894.2 C1958.2 C1959.2 C1960.1 C7465.1 C7517.2 C7526.1 C7588.1 C7589.2 C7590.2 C7591.2 C7592.2 C7604.2 C7605.2 C7606.2 C7607.2 C7608.1 C7616.2 C7617.2 C7618.1 C7655.2 C7656.2 C7667.2 C7668.2 C7674.2 C7713.2 C7767.2 C7768.2 C7769.2 C7770.2 C7777.1 C7783.1 FB40.1 R580.1 R587.2 R663.2 R673.2 R949.2 R956.2 R966.2 R5838.1 R5928.1 R5953.2 R5954.1 R5955.1 R6268.2 TP964.1 TP965.1 TP968.1 U50.1 U50.2 U50.3(S3) U52.6(VOUT) U53.5(VDD) U66.D3 U66.D4 U66.E3 U66.E4 U66.F4 U66.G4 U67.D3 U67.D4 U67.E3 U67.E4 U67.F4 U67.G4 U68.4 U68.5 U68.18 U68.19 U69.4 U69.5 U69.18 U69.19 U71.4 U71.5 U71.18 U71.19 U114.B3 U114.B4 U114.B5 U114.E3 U114.E4 U114.E5 U114.H3 U114.H4 U114.H5 U114.L3 U114.L4 U114.L5 U117.A4 U117.B4 U117.F4 U117.G4 U118.A9 U118.B9 U118.C9 U118.D9 U118.J9 U118.K9 U118.L9 U118.M9 U122.D5 U122.E5 U133.C5 U133.D5 U133.E5 U134.C5 U134.D5 U134.E5 U136.A9 U136.B9 U136.C9 U136.D9 U136.J9 U136.K9 U136.L9 U136.M9 U137.4 U137.5 U137.18 U137.19 U138.B3 U138.B4 U138.B5 U138.E3 U138.E4 U138.E5 U138.H3 U138.H4 U138.H5 U138.L3 U138.L4 U138.L5 U139.B3 U139.B4 U139.B5 U139.E3 U139.E4 U139.E5 U139.H3 U139.H4 U139.H5 U139.L3 U139.L4 U139.L5
12V_G2_PG: R494.1 U34.C13 U52.7
12V_GROUP1: C580.1 Q13.1 Q13.2 Q13.3(S3) R478.1 R479.1 R485.1 R501.2 TP956.1 TP957.1 U44.5 U45.5 U46.1 U46.6(VDD) U47.4 U48.2 U48.4
12V_GROUP2: C582.1 C590.1 Q13.5 R491.1 R492.1 TP962.1 TP963.1 U48.8 U49.5 U50.5 U51.1 U51.6(VDD) U52.4
AGND_1P2V_PRE: C7644.2 R6012.1 ST23.1
AGND_1P8V_PRE: C7645.2 R6106.1 ST29.1
AGND_2P5V_PRE: C7643.2 R6100.1 ST1.1
AGND_3P3V_STBY: C7642.2 R6103.1 ST2.1
AGND_VCCFUSEWR_SDM: C7651.2 R6006.1 ST24.1
