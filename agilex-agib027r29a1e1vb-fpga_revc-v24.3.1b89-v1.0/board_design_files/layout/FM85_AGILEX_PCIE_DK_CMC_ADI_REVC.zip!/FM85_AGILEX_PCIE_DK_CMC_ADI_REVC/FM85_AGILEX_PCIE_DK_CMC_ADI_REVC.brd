# Allegro board FM85_AGILEX_PCIE_DK_CMC_ADI_REVC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_COMP_CH0_PAR: length 81.1
  L07_SIG3 w0.089: v1(70.59,16.93) 71.01,16.52 71.35,16.52 71.52,16.7 71.69,16.7 71.87,16.52 72.04,16.52 72.21,16.7 72.38,16.7 72.55,16.52 72.72,16.52 72.9,16.7 73.06,16.7 73.24,16.52 80.36,16.52 v1(80.78,16.94) 81.18,16.54 87.53,16.54 87.63,16.64 87.63,16.87 87.72,16.96 87.88,16.96 87.97,16.87 87.97,16.63 88.07,16.54 90.54,16.54 v1(90.94,16.94) 91.37,16.51 100.67,16.51 v1(101.1,16.94) 101.52,16.51 107.33,16.51 107.42,16.6 107.42,16.86 107.51,16.95 107.67,16.95 107.76,16.86 107.76,16.6 107.85,16.51 108.02,16.51 108.1,16.6 108.1,16.86 108.19,16.95 108.36,16.95 108.45,16.86 108.45,16.6 108.54,16.51 110.83,16.51 v1(111.26,16.94)
  L16_SIG6 w0.081: v1(102.77,39.15) 102.48,38.63 arc(102.43,38.51) 102.41,38.39 102.4,38.38 102.4,38.07 102.62,37.86 102.67,37.86 103.86,36.67 arc(103.89,36.63) 103.89,36.59 103.89,34.81 106.25,32.45 107.3,32.45 107.86,31.9 107.86,29.97 107.77,29.88 107.56,29.88 107.48,29.8 107.48,29.63 107.56,29.55 107.77,29.55 107.86,29.47 107.86,29.3 107.77,29.21 107.59,29.21 107.51,29.13 107.51,28.98 107.61,28.88 107.77,28.88 107.86,28.8 107.86,28.62 107.77,28.54 107.59,28.54 107.51,28.46 107.51,28.31 107.61,28.21 107.77,28.21 107.86,28.13 107.86,27.95 107.77,27.87 107.59,27.87 107.51,27.79 107.51,27.64 107.61,27.54 107.77,27.54 107.86,27.46 107.86,27.28 107.77,27.2 107.59,27.2 107.51,27.12 107.51,26.97 107.61,26.87 107.77,26.87 107.86,26.79 107.86,26.61 107.77,26.53 107.59,26.53 107.51,26.45 107.51,26.3 107.61,26.2 107.77,26.2 107.86,26.12 107.86,25.94 107.77,25.86 107.59,25.86 107.51,25.78 107.51,25.63 107.61,25.53 107.77,25.53 107.86,25.44 107.86,25.27 107.77,25.19 107.59,25.19 107.51,25.11 107.51,24.96 107.61,24.86 107.77,24.86 107.86,24.77 107.86,20.76 107.86,20.76 107.86,19.25 arc(108.02,18.43) 108.49,17.73 108.62,17.6 arc(108.94,17.38) 109.31,17.31 113.33,17.31 113.43,17.22 113.43,17.06 113.3,16.94 v1(111.26,16.94)
  BOTTOM w0.149: R27.2 70.67,16.86 v1(70.59,16.93)
DDR4_COMP_CH0_RESET_N: length 84.5
  L07_SIG3 w0.089: v1(109.66,18.54) 109.28,18.16 107.57,18.16 107.49,18.25 107.49,18.46 107.4,18.54 107.23,18.54 107.14,18.46 107.14,18.25 107.05,18.16 99.88,18.16 v1(99.5,18.54) 99.11,18.15 92.6,18.15 92.51,18.06 92.51,17.75 92.42,17.66 92.26,17.66 92.17,17.75 92.17,18.06 92.08,18.15 89.72,18.15 v1(89.34,18.54) 88.96,18.16 88,18.16 87.91,18.25 87.91,18.57 87.83,18.65 87.66,18.65 87.57,18.57 87.57,18.25 87.48,18.16 79.82,18.16 79.45,18.54 v1(79.18,18.54) 78.94,18.3 77.54,18.3 77.39,18.16 69.37,18.16 v1(68.99,18.53)
  L16_SIG6 w0.081: v1(105.96,38.23) 105.96,38.04 105.99,38.01 105.99,37.55 106.33,37.21 107.02,37.21 107.39,36.84 107.39,35.86 110.32,32.93 110.32,32.21 110.86,31.67 111.07,31.67 111.16,31.77 111.16,32.04 111.24,32.12 111.47,32.12 111.55,32.21 111.55,32.38 111.47,32.46 111.24,32.46 111.16,32.54 111.16,32.78 111.27,32.89 111.77,32.89 111.92,32.75 111.92,31.93 112.01,31.84 112.51,31.84 112.61,31.74 112.61,31.2 112.71,31.09 112.85,31.09 112.94,31.18 112.94,31.74 113.04,31.84 113.18,31.84 113.28,31.74 113.28,31.16 113.39,31.05 113.6,31.05 113.73,30.93 113.73,30.79 113.63,30.69 113.4,30.69 113.32,30.61 113.32,30.43 113.4,30.35 113.6,30.35 113.68,30.27 113.68,30.1 113.6,30.02 113.4,30.02 113.32,29.93 113.32,29.76 113.4,29.68 113.6,29.68 113.68,29.6 113.68,29.43 113.6,29.35 113.4,29.35 113.32,29.26 113.32,29.09 113.4,29.01 113.6,29.01 113.68,28.93 113.68,28.76 113.6,28.67 113.4,28.67 113.32,28.59 113.32,28.42 113.4,28.34 113.6,28.34 113.68,28.26 113.68,27.72 113.6,27.64 112.98,27.64 112.9,27.56 112.9,27.39 112.98,27.31 113.6,27.31 113.68,27.22 113.68,27.05 113.6,26.97 112.98,26.97 112.9,26.89 112.9,26.72 112.98,26.63 113.6,26.63 113.68,26.55 113.68,22.29 112.31,20.92 112.31,20.81 112.63,20.49 112.63,20.37 112.51,20.25 112.39,20.25 112.08,20.57 111.96,20.57 111.63,20.24 111.63,19.03 111.52,18.92 111.05,18.92 110.89,18.76 110.89,18.27 110.73,18.11 109.74,18.11 109.66,18.19 v1(109.66,18.54)
  BOTTOM w0.149: v1(68.99,18.53) 68.12,17.66 R30.2 R29.2
DDR4_COMP_CH0_RZQ: length 11.9
  BOTTOM w0.149: v1(103.57,45.13) 102.55,45.13 102.15,44.72 101.81,44.72 101.35,44.26 101.01,44.26 100.55,43.8 100.33,43.8 98.57,42.04 98.25,42.04 98.02,41.8 98.02,38.03 97.87,37.88 R1034.2
DDR4_COMP_CH0_TEN: length 46.8
  L05_SIG2 w0.081: v1(75.39,19.33) 76.93,19.33 77.35,18.92 82.68,18.92 83.47,19.71 84.16,19.71 84.39,19.48 84.39,19.17 84.61,18.94 85.18,18.94 v1(85.58,19.34) 85.97,18.94 93.07,18.94 93.84,19.72 94.34,19.72 94.54,19.52 94.54,19.21 94.8,18.94 95.34,18.94 v1(95.74,19.34) 96.13,18.94 103.2,18.94 103.97,19.72 104.5,19.72 104.73,19.49 104.73,19.19 104.73,19.18 104.73,19.17 104.96,18.94 105.5,18.94 v1(105.9,19.34) 106.29,18.94 113.24,18.94 114.02,19.72 115.68,19.72 v1(116.06,19.34)
  BOTTOM w0.149: R33.1 R31.2 75.89,19.3 75.85,19.33 v1(75.39,19.33)
DDR4_COMP_CH1_A0: length 86.1
  TOP w0.149: U11.P3 v1(165.74,18.46) ; U9.P3 v1(145.29,18.46) ; U7.P3 v1(124.97,18.46) ; U10.P3 v1(155.45,18.5) ; U8.P3 v1(135.13,18.46)
  L07_SIG3 w0.089: v1(124.97,18.46) 125.4,18.89 130.96,18.89 131.05,18.98 131.05,19.07 131.14,19.15 131.31,19.15 131.4,19.07 131.4,18.98 131.49,18.89 134.71,18.89 v1(135.13,18.46) 135.52,18.85 136.29,18.85 136.39,18.95 136.39,19.21 136.5,19.31 136.64,19.31 136.74,19.21 136.74,18.95 136.84,18.85 144.9,18.85 v1(145.29,18.46) 145.71,18.88 155.08,18.88 v1(155.45,18.5) 155.84,18.88 161.95,18.88 162.04,18.97 162.27,18.97 162.39,18.85 165.35,18.85 v1(165.74,18.46)
  L12_SIG4 w0.089: v1(124.97,18.46) 124.91,18.53 124.91,18.77 125,18.86 126.29,18.86 126.49,19.06 126.49,19.33 126.01,19.81 125.84,19.81 125.75,19.72 125.75,19.32 125.66,19.24 125.5,19.24 125.41,19.32 125.41,19.55 125.32,19.64 124.55,19.64 124.42,19.77 124.42,20.4 124.5,20.49 125.35,20.49 125.44,20.58 125.44,21.08 125.35,21.17 124.94,21.17 124.85,21.25 124.85,21.42 124.94,21.51 125.35,21.51 125.5,21.65 125.5,22.27 125.33,22.43 124.96,22.43 124.87,22.52 124.87,22.65 125,22.78 125.65,22.78 125.74,22.87 125.74,23.16 125.51,23.38 125.28,23.38 125.18,23.48 125.18,24.3 125.31,24.43 126.09,24.43 126.16,24.5 126.16,24.69 126.08,24.77 125.57,24.77 125.48,24.86 125.48,25.3 125.71,25.53 125.71,25.81 125.45,26.07 125.45,27.05 126.17,27.76 126.17,28.71 126.08,28.8 125.67,28.8 125.58,28.89 125.58,29.05 125.67,29.14 126.08,29.14 126.17,29.23 126.17,29.4 126.08,29.48 125.67,29.48 125.58,29.57 125.58,29.74 125.67,29.83 126.08,29.83 126.17,29.92 126.17,30.08 126.08,30.17 125.67,30.17 125.58,30.26 125.58,30.42 125.67,30.51 126.08,30.51 126.17,30.6 126.17,30.77 126.08,30.86 125.67,30.86 125.58,30.95 125.58,31.11 125.67,31.2 126.08,31.2 126.17,31.29 126.17,31.45 126.08,31.54 125.67,31.54 125.58,31.63 125.58,31.8 125.67,31.89 126.08,31.89 126.17,31.97 126.17,32.51 126,32.67 126,33.25 125.84,33.42 125.63,33.42 125.52,33.52 125.52,33.87 125.61,33.96 126.17,33.96 126.26,34.04 126.26,34.21 126.17,34.3 125.61,34.3 125.52,34.39 125.52,35.3 125.82,35.6 125.82,37.3 125.47,37.65 125.47,37.88 125.73,38.14 125.73,38.31 125.51,38.53 125.51,38.84 125.73,39.06 125.73,39.23 125.51,39.45 125.51,39.76 125.73,39.98 125.89,39.98 126.44,40.53 v1(127.48,40.53)
DDR4_COMP_CH1_A1: length 85.9
  TOP w0.149: U11.P7 v1(167.67,18.46) ; U8.P7 v1(137.32,18.46) ; U9.P7 v1(147.48,18.46) ; U10.P7 v1(157.64,18.5) ; U7.P7 v1(126.9,18.46)
  L12_SIG4 w0.089: v1(126.68,40.07) 126.3,39.69 126.3,36.72 126.73,36.29 126.73,35.21 126.49,34.97 126.49,34.64 126.91,34.22 126.91,33.7 126.35,33.14 126.35,32.81 126.51,32.65 126.51,31.8 126.62,31.69 126.9,31.69 126.99,31.61 126.99,31.44 126.9,31.35 126.6,31.35 126.51,31.26 126.51,31.1 126.6,31.01 126.9,31.01 126.99,30.92 126.99,30.75 126.9,30.67 126.6,30.67 126.51,30.58 126.51,30.41 126.6,30.32 126.9,30.32 126.99,30.23 126.99,30.07 126.9,29.98 126.6,29.98 126.51,29.89 126.51,29.46 126.6,29.37 126.79,29.37 126.88,29.28 126.88,29.11 126.79,29.02 126.6,29.02 126.51,28.94 126.51,28.77 126.6,28.68 126.71,28.68 126.8,28.59 126.8,28.43 126.71,28.34 126.6,28.34 126.51,28.25 126.51,26.48 126.31,26.27 126.31,25.99 126.51,25.79 126.51,24.09 126.42,24 125.76,24 125.68,23.91 125.68,23.74 125.76,23.65 126.56,23.65 126.72,23.5 126.72,22.34 126.63,22.25 125.95,22.25 125.84,22.14 125.84,22.02 125.95,21.91 126.96,21.91 127.05,21.82 127.05,21.48 126.96,21.39 125.87,21.39 125.78,21.3 125.78,21.13 125.87,21.04 126.61,21.04 126.72,20.94 126.72,20.79 126.63,20.7 125.87,20.7 125.78,20.61 125.78,20.45 125.87,20.36 126.35,20.36 126.44,20.27 126.44,19.88 126.53,19.79 126.68,19.79 126.78,19.89 126.78,20.36 126.91,20.48 127.56,20.48 127.69,20.35 127.69,20.04 127.32,19.67 127.32,19.67 127.31,19.65 127.31,17.8 127.09,17.58 125.41,17.58 125.32,17.67 125.32,17.79 125.67,18.15 126.59,18.15 v1(126.9,18.46)
  L14_SIG5 w0.081: v1(137.32,18.46) 136,17.15 135.37,17.15 135.29,17.23 132.78,17.23 131.88,18.13 130,18.13 129.9,18.03 128.11,18.03 127.68,18.46 v1(126.9,18.46)
  L16_SIG6 w0.081: v1(167.67,18.46) 167.26,18.88 166.65,18.88 166.53,19 166.31,19 166.19,18.88 158.02,18.88 v1(157.64,18.5) 157.26,18.88 147.89,18.88 v1(147.48,18.46) 147.06,18.88 137.73,18.88 v1(137.32,18.46)
DDR4_COMP_CH1_A2: length 87.1
  TOP w0.149: U11.R3 v1(165.74,17.66) ; U8.R3 v1(135.13,17.66) ; U10.R3 v1(155.45,17.7) ; U9.R3 v1(145.29,17.66)
  L07_SIG3 w0.089: v1(165.74,17.66) 165.33,18.07 161.23,18.07 161.1,18.2 160.29,18.2 160.18,18.09 155.84,18.09 v1(155.45,17.7) 155.07,18.09 150.68,18.09 150.63,18.14 150.32,18.14 150.23,18.04 145.67,18.04 v1(145.29,17.66) 144.88,17.25 136.7,17.25 136.6,17.35 136.6,17.51 136.49,17.62 136.37,17.62 136.26,17.51 136.26,17.35 136.16,17.25 135.55,17.25 v1(135.13,17.66) 134.72,17.25 127.16,17.25 126.75,17.66 v1(124.47,17.66)
  L12_SIG4 w0.089: v1(127.48,41.45) 127.18,41.74 127.18,42 126.81,42.38 126.49,42.38 125.94,41.82 125.53,41.82 125.24,41.53 124.93,41.53 124.45,41.05 124.12,41.05 123.9,40.83 123.9,39.49 124.16,39.23 124.16,39.08 123.91,38.84 123.91,38.53 124.13,38.31 124.13,38.11 123.91,37.89 123.91,37.59 123.84,37.52 123.68,37.52 123.6,37.44 123.6,37.25 123.69,37.16 124.52,37.16 124.61,37.07 124.61,36.9 124.52,36.81 123.71,36.81 123.62,36.72 123.62,35.89 123.71,35.8 124.47,35.8 124.56,35.71 124.56,35.55 124.47,35.46 123.55,35.46 123.46,35.37 123.46,35.21 123.56,35.12 124.53,35.12 124.66,34.99 124.66,34.86 124.57,34.77 123.55,34.77 123.46,34.68 123.46,34.53 123.56,34.43 124.77,34.43 124.84,34.36 124.84,34.17 124.76,34.09 123.71,34.09 123.62,34 123.62,33.33 123.74,33.21 124.1,33.21 124.19,33.12 124.19,32.95 124.1,32.87 123.58,32.87 123.46,32.74 123.46,32.05 123.6,31.91 124.6,31.91 124.7,31.81 124.7,31.67 124.6,31.57 123.67,31.57 123.54,31.44 123.54,31.14 123.64,31.04 123.97,31.04 124.08,30.92 124.08,30.56 123.99,30.47 123.88,30.47 123.79,30.38 123.79,30.21 123.88,30.12 123.99,30.12 124.08,30.03 124.08,24.91 arc(124.05,24.73) 123.96,24.58 123.86,24.47 arc(123.85,24.47) 123.85,24.46 123.49,23.92 arc(123.46,23.85) 123.43,23.77 123.31,23.22 arc(123.3,23.16) 123.29,23.09 123.29,18.42 arc(123.3,18.36) 123.31,18.3 arc(123.34,18.26) 123.36,18.23 123.52,18.08 arc(123.56,18.05) 123.61,18.04 124.06,18.04 arc(124.09,18.03) 124.12,18.01 v1(124.47,17.66)
DDR4_COMP_CH1_A3: length 86.4
  TOP w0.149: U7.N7 v1(126.9,19.26) ; U11.N7 v1(167.67,19.26) ; U10.N7 v1(157.64,19.3) ; U8.N7 v1(137.32,19.26) ; U9.N7 v1(147.48,19.26)
  L12_SIG4 w0.089: v1(126.68,41.91) 126.26,41.48 126.26,41.29 126.04,41.07 125.84,41.07 125.21,40.44 124.93,40.44 124.71,40.22 124.71,38.99 124.95,38.75 124.95,35.52 125.18,35.29 125.18,33.69 125.09,33.6 124.62,33.6 124.53,33.51 124.53,33.13 124.63,33.03 125.53,33.03 125.62,32.94 125.62,32.77 125.53,32.68 124.57,32.68 124.47,32.59 124.47,32.43 124.56,32.34 125.09,32.34 125.22,32.21 125.22,31.16 125.09,31.03 124.52,31.03 124.43,30.95 124.43,30.78 124.52,30.69 125.11,30.69 125.23,30.58 125.23,30.44 125.14,30.35 124.52,30.35 124.43,30.26 124.43,30.09 124.52,30.01 125.14,30.01 125.23,29.91 125.23,29.75 125.14,29.66 124.52,29.66 124.43,29.57 124.43,29.41 124.52,29.32 124.98,29.32 125.07,29.23 125.07,28.88 124.9,28.71 124.9,28.54 125.07,28.37 125.07,28.2 124.9,28.03 124.9,27.85 125.08,27.67 125.08,27.27 124.91,27.09 124.91,26.84 125.07,26.67 125.07,26.5 124.91,26.33 124.91,26.15 125.09,25.96 125.09,25.84 124.91,25.65 124.91,25.47 125.14,25.24 125.14,24.89 124.53,24.28 124.53,23.83 124.44,23.74 123.9,23.74 123.81,23.65 123.81,23.51 123.92,23.4 124.77,23.4 124.86,23.31 124.86,23.14 124.75,23.04 124.15,23.04 124.07,22.95 124.07,22.42 124.15,22.33 124.35,22.33 124.44,22.24 124.44,22.08 124.35,21.99 124.15,21.99 124.07,21.9 124.07,21.73 124.15,21.65 124.41,21.65 124.5,21.56 124.5,21.39 124.41,21.3 124.15,21.3 124.07,21.21 124.07,19.41 124.15,19.32 124.41,19.32 124.49,19.23 124.49,19.07 124.41,18.98 124.15,18.98 124.07,18.89 124.07,18.44 124.13,18.38 124.34,18.38 124.78,17.94 124.98,17.94 125.54,18.49 126.41,18.49 126.9,18.99 v1(126.9,19.26)
  L14_SIG5 w0.081: v1(137.32,19.26) 137.23,19.26 136.86,18.89 128.15,18.89 127.77,19.26 v1(126.9,19.26)
  L16_SIG6 w0.081: v1(167.67,19.26) 167.26,19.68 158.02,19.68 v1(157.64,19.3) 157.26,19.68 147.89,19.68 v1(147.48,19.26) 147.06,19.68 141.95,19.68 141.85,19.78 141.85,20.04 141.75,20.14 141.61,20.14 141.51,20.04 141.51,19.78 141.42,19.68 137.73,19.68 v1(137.32,19.26)
DDR4_COMP_CH1_A4: length 85.9
  TOP w0.149: U9.N3 v1(145.29,19.26) ; U7.N3 v1(124.97,19.26) ; U11.N3 v1(165.74,19.26) ; U8.N3 v1(135.13,19.26) ; U10.N3 v1(155.45,19.3)
  L07_SIG3 w0.089: v1(165.74,19.26) 165.33,19.68 155.83,19.68 v1(155.45,19.3) 155.08,19.68 145.71,19.68 v1(145.29,19.26) 144.9,19.65 135.52,19.65 v1(135.13,19.26) 134.71,19.69 131.4,19.69 131.32,19.78 131.32,19.97 131.23,20.06 131.06,20.06 130.97,19.97 130.97,19.78 130.88,19.69 125.4,19.69 v1(124.97,19.26)
  L16_SIG6 w0.081: v1(129.07,40.53) 129.93,40.53 130.02,40.44 130.24,40.22 130.24,40.22 130.48,39.98 130.82,39.98 131.28,39.52 131.61,39.52 131.87,39.26 131.87,37.6 134.24,35.22 134.24,34.79 134.16,34.71 133.81,34.71 133.73,34.63 133.73,34.45 133.81,34.37 134.16,34.37 134.24,34.29 134.24,33.91 134.16,33.83 133.8,33.83 133.72,33.74 133.72,33.57 133.8,33.49 134.16,33.49 134.24,33.41 134.24,33.24 134.16,33.15 133.8,33.15 133.72,33.07 133.72,32.9 133.8,32.82 134.16,32.82 134.24,32.74 134.24,32.57 134.16,32.48 133.8,32.48 133.72,32.4 133.72,32.23 133.8,32.15 134.16,32.15 134.24,32.07 134.24,31.89 134.16,31.81 133.8,31.81 133.72,31.73 133.72,31.56 133.8,31.48 134.16,31.48 134.24,31.4 134.24,31.22 134.16,31.14 133.8,31.14 133.72,31.06 133.72,30.89 133.8,30.81 134.16,30.81 134.24,30.73 134.24,29.84 134.32,29.76 134.61,29.76 134.69,29.68 134.69,29.54 134.57,29.43 134.32,29.43 134.24,29.35 134.24,24.66 133.08,23.5 132.24,23.5 132.1,23.36 132.09,23.36 131.45,22.73 131.45,21.83 131.13,21.51 131.13,21.39 131.38,21.13 131.38,21.02 131.26,20.9 131.15,20.9 130.89,21.15 130.77,21.15 130.12,20.5 129.54,20.5 129.39,20.36 129.39,19.6 128.63,18.83 127.8,18.83 127.06,18.09 125.91,18.09 125.49,18.51 125.49,18.62 125.95,19.08 125.95,19.19 125.83,19.32 125.71,19.32 125.26,18.86 125.14,18.86 124.97,19.03 v1(124.97,19.26)
DDR4_COMP_CH1_A5: length 86.7
  L03_SIG1 w0.081: v1(128.47,18.46) 128.84,18.09 129.96,18.09 130,18.13 130.31,18.13 130.36,18.09 130.78,18.09 130.86,18.17 130.86,18.32 130.94,18.4 131.11,18.4 131.19,18.32 131.19,18.17 131.27,18.09 138.25,18.09 v1(138.63,18.46) 139,18.09 140.12,18.09 140.16,18.13 140.47,18.13 140.51,18.09 141.2,18.09 141.32,18.22 141.53,18.22 141.66,18.09 148.41,18.09 v1(148.79,18.46) 149.18,18.07 150.26,18.07 150.32,18.13 150.63,18.13 150.69,18.08 158.52,18.08 v1(158.95,18.5) 159.36,18.09 160.44,18.09 160.48,18.13 163.31,18.13 163.35,18.09 167.83,18.09 167.85,18.12 168.76,18.12 v1(169.11,18.46)
  L16_SIG6 w0.081: v1(128.47,18.46) 128.74,18.46 129.11,18.83 130.55,18.83 130.64,18.91 130.64,19.11 130.08,19.67 130.08,19.78 130.2,19.9 130.32,19.9 130.94,19.29 131.06,19.29 131.18,19.4 131.18,19.52 130.56,20.14 130.56,20.26 130.68,20.38 130.79,20.38 131.13,20.05 131.43,20.05 131.81,20.42 131.81,22.61 132.22,23.03 132.24,23.03 132.38,23.17 133.28,23.17 135.04,24.93 135.04,30.1 134.95,30.18 134.67,30.18 134.59,30.26 134.59,30.44 134.67,30.52 134.95,30.52 135.04,30.6 135.04,30.77 134.95,30.85 134.67,30.85 134.59,30.93 134.59,31.11 134.67,31.19 134.95,31.19 135.04,31.27 135.04,31.44 134.95,31.52 134.67,31.52 134.59,31.6 134.59,31.78 134.67,31.86 134.95,31.86 135.04,31.94 135.04,32.27 134.95,32.36 134.66,32.36 134.58,32.44 134.58,32.61 134.66,32.69 135.08,32.69 135.17,32.77 135.17,32.94 135.08,33.03 134.66,33.03 134.58,33.11 134.58,33.28 134.66,33.36 135.08,33.36 135.17,33.44 135.17,33.96 134.64,34.48 134.64,36.43 133.46,37.61 133.46,38.32 133.19,38.59 133.06,38.59 132.67,38.98 132.67,39.72 132.41,39.98 132.07,39.98 131.61,40.44 131.32,40.44 130.76,40.99 130.39,40.99 129.96,41.42 129.67,41.42 129.21,41.88 128.86,41.88 128.46,41.48 128.2,41.48 127.9,41.18 127.9,40.44 v1(128.27,40.07)
  BOTTOM w0.149: R897.2 170.8,18.34 170.26,18.87 169.52,18.87 v1(169.11,18.46)
DDR4_COMP_CH1_A6: length 85.4
  L05_SIG2 w0.081: v1(123.67,18.46) 124.05,18.07 129.94,18.07 130,18.13 130.31,18.13 130.37,18.07 130.74,18.07 130.82,18.16 130.82,18.28 130.9,18.36 131.07,18.36 131.15,18.28 131.15,18.16 131.24,18.07 133.44,18.07 v1(133.83,18.46) 134.22,18.06 140.09,18.06 140.16,18.13 140.47,18.13 140.54,18.06 143.59,18.06 v1(143.99,18.46) 144.41,18.04 150.23,18.04 150.32,18.13 150.63,18.13 150.72,18.04 153.69,18.04 v1(154.15,18.5) 154.57,18.08 160.43,18.08 160.48,18.13 160.79,18.13 160.85,18.07 163.92,18.07 v1(164.31,18.46)
  L16_SIG6 w0.081: v1(129.07,41.45) 128.7,41.08 128.7,39.21 128.85,39.06 129.33,39.06 129.5,38.89 129.5,37.93 129.61,37.81 130.14,37.81 130.26,37.69 130.26,37.5 129.96,37.2 129.96,37.06 130.07,36.95 130.18,36.95 130.5,37.27 130.61,37.27 130.74,37.14 130.74,37.03 130.5,36.8 130.5,36.66 130.62,36.55 130.73,36.55 130.97,36.79 131.09,36.79 131.21,36.67 131.21,36.56 131.08,36.42 131.08,36.31 131.2,36.19 131.32,36.19 131.45,36.32 131.56,36.32 132.19,35.69 132.41,35.69 132.78,36.06 132.9,36.06 133.02,35.94 133.02,35.83 132.6,35.4 132.6,35.15 133.38,34.36 133.38,33.58 133.23,33.43 133.23,33.24 133.38,33.09 133.38,32.91 133.23,32.76 133.23,32.57 133.38,32.42 133.38,32.23 133.23,32.08 133.23,31.9 133.38,31.75 133.38,31.56 133.23,31.41 133.23,31.23 133.38,31.08 133.38,30.89 133.23,30.74 133.23,30.56 133.38,30.41 133.38,29.65 133.4,29.63 133.4,24.71 133.12,24.43 132.05,24.43 131.55,23.93 131.55,23.3 131.05,22.8 131.05,22.13 130.74,21.82 130.63,21.82 130.27,22.19 130.15,22.19 130.03,22.06 130.03,21.95 130.39,21.59 130.39,21.47 130.16,21.23 129.11,21.23 128.9,21.02 128.9,19.97 128.62,19.69 128.32,19.69 127.8,19.17 127.66,19.17 127.33,18.83 126.81,18.83 126.14,19.5 126.14,20.13 125.84,20.43 125.08,20.43 124.27,19.63 124.27,19.06 v1(123.67,18.46)
  BOTTOM w0.149: v1(164.31,18.46) 163.9,18.87 162.96,18.87 162.51,18.41 R898.2
DDR4_COMP_CH1_A7: length 85.8
  L03_SIG1 w0.081: v1(128.47,17.66) 128.84,17.29 130.77,17.29 130.85,17.37 130.85,17.56 130.93,17.65 131.09,17.65 131.18,17.55 131.18,17.37 131.26,17.29 138.26,17.29 v1(138.63,17.66) 139,17.29 148.42,17.29 v1(148.79,17.66) 149.16,17.29 158.54,17.29 v1(158.95,17.7) 159.36,17.29 168.74,17.29 v1(169.11,17.66)
  L12_SIG4 w0.089: v1(128.27,41.91) 128.27,41.92 arc(128.23,42.12) 128.13,42.28 127.77,42.63 arc(127.64,42.74) 127.48,42.8 arc(127.38,42.84) 127.29,42.89 126.86,43.18 arc(126.82,43.19) 126.78,43.2 126.63,43.2 arc(126.53,43.18) 126.45,43.12 arc(126.28,43) 126.1,42.91 125.36,42.55 arc(125.32,42.52) 125.29,42.5 arc(125.22,42.46) 125.15,42.43 arc(124.95,42.36) 124.77,42.23 124.57,42.03 arc(124.47,41.96) 124.35,41.94 124.33,41.94 arc(124.28,41.93) 124.24,41.91 arc(124,41.75) 123.78,41.56 arc(123.66,41.47) 123.52,41.43 arc(123.27,41.3) 123.12,41.07 arc(123.11,41.02) 123.1,40.98 123.1,40.24 123.1,40.24 123.1,39.93 123.1,39.93 123.1,39.29 123.1,39.28 123.1,38.97 123.1,38.96 123.1,38.39 123.09,38.38 123.09,38.07 123.1,38.07 123.1,35.95 123.01,35.86 122.39,35.86 122.3,35.78 122.3,35.63 122.41,35.52 122.99,35.52 123.1,35.41 123.1,35.22 123.01,35.13 122.3,35.13 122.21,35.04 122.21,34.89 122.31,34.79 123.01,34.79 123.1,34.7 123.1,34.51 123.01,34.43 122.47,34.43 122.38,34.34 122.38,34.16 122.47,34.07 122.98,34.07 123.1,33.95 123.1,31.24 arc(123.11,31.2) 123.11,31.15 123.23,30.69 arc(123.23,30.67) 123.24,30.65 arc(123.3,30.56) 123.34,30.46 arc(123.43,30.18) 123.46,29.89 123.46,29.75 arc(123.46,29.71) 123.46,29.67 arc(123.45,29.59) 123.43,29.52 arc(123.41,29.45) 123.4,29.38 123.4,29.25 arc(123.39,29.15) 123.35,29.06 arc(123.27,28.88) 123.24,28.68 123.24,28.22 123.24,28.22 123.24,27.91 123.24,27.91 123.24,27.42 123.24,27.42 123.24,27.11 123.24,27.11 123.24,26.62 123.24,26.62 123.24,26.31 123.24,26.31 123.24,25.82 123.24,25.82 123.24,25.51 123.24,25.51 123.24,24.88 arc(123.15,24.62) 122.91,24.49 122.68,24.46 arc(122.53,24.38) 122.47,24.22 122.47,18.4 arc(122.48,18.33) 122.52,18.27 122.59,18.19 arc(122.63,18.16) 122.67,18.14 122.86,18.06 arc(122.9,18.04) 122.95,18.03 arc(123.04,18) 123.12,17.94 123.13,17.92 arc(123.21,17.81) 123.24,17.67 123.24,17.61 arc(123.25,17.56) 123.27,17.53 123.42,17.38 arc(123.55,17.3) 123.7,17.26 123.72,17.26 arc(123.82,17.25) 123.9,17.19 124.03,17.06 arc(124.2,16.93) 124.41,16.85 arc(124.45,16.84) 124.49,16.84 125.83,16.84 arc(125.9,16.83) 125.98,16.81 126.38,16.65 arc(126.44,16.62) 126.5,16.58 arc(126.6,16.53) 126.72,16.49 arc(126.76,16.48) 126.81,16.48 127.64,16.48 arc(127.81,16.51) 127.96,16.61 128.32,17.01 arc(128.41,17.14) 128.44,17.3 v1(128.47,17.66)
  BOTTOM w0.149: v1(169.11,17.66) 169.11,17.1 R899.2
DDR4_COMP_CH1_A8: length 88.1
  L05_SIG2 w0.081: v1(164.31,17.66) 163.89,17.24 163.09,17.24 162.99,17.34 162.99,17.52 162.89,17.62 162.76,17.62 162.66,17.52 162.66,17.23 162.56,17.13 162.43,17.13 162.32,17.24 162.32,17.52 162.22,17.62 162.08,17.62 161.99,17.52 161.99,17.34 161.89,17.24 161.75,17.24 161.65,17.34 161.65,17.52 161.55,17.62 161.41,17.62 161.32,17.52 161.32,17.35 161.23,17.27 154.58,17.27 v1(154.15,17.7) 153.69,17.24 151.65,17.24 151.55,17.34 151.55,17.52 151.45,17.62 151.31,17.62 151.22,17.52 151.22,17.34 151.12,17.24 144.41,17.24 v1(143.99,17.66) 143.57,17.24 134.25,17.24 v1(133.83,17.66) 133.41,17.24 131.25,17.24 131.17,17.32 131.17,17.55 131.09,17.64 130.92,17.64 130.84,17.55 130.84,17.32 130.76,17.24 124.09,17.24 v1(123.67,17.66)
  L12_SIG4 w0.089: v1(130.66,40.53) 131.09,40.1 131.09,38.07 131.52,37.63 131.52,36.81 132.24,36.1 132.24,32.01 132.59,31.66 132.59,28.78 132.5,28.69 131.93,28.69 131.85,28.6 131.85,28.44 131.93,28.35 132.49,28.35 132.59,28.25 132.59,28.07 132.5,27.98 131.73,27.98 131.64,27.89 131.64,27.73 131.73,27.64 132.46,27.64 132.59,27.51 132.59,26.93 132.5,26.84 131.72,26.84 131.63,26.75 131.63,26.57 131.72,26.48 132.54,26.48 132.64,26.38 132.64,26.21 132.55,26.13 131.74,26.13 131.65,26.04 131.65,25.86 131.74,25.77 132.5,25.77 132.64,25.63 132.64,24.91 132.5,24.77 131.83,24.77 131.74,24.68 131.74,24.51 131.83,24.42 132.5,24.42 132.59,24.34 132.59,23.7 132.68,23.61 132.94,23.61 133.02,23.53 133.02,23.36 132.94,23.27 132.68,23.27 132.59,23.18 132.59,22.33 131.96,21.7 131.96,20.12 131.48,19.64 128.31,19.64 128.05,19.38 128.05,17.41 127.88,17.24 124.55,17.24 arc(124.38,17.27) 124.23,17.37 123.94,17.66 v1(123.67,17.66)
  BOTTOM w0.149: v1(164.31,17.66) 164.31,16.95 163.9,16.55 163.9,16.48 163.48,16.06 R900.2
DDR4_COMP_CH1_A9: length 86.6
  TOP w0.149: U8.R7 v1(137.32,17.66) ; U10.R7 v1(157.64,17.7) ; U11.R7 v1(167.67,17.66) ; U9.R7 v1(147.48,17.66)
  L12_SIG4 w0.089: v1(129.87,40.07) 129.73,40.01 129.44,39.32 129.44,37.74 129.64,37.54 129.64,37.42 129.41,37.18 129.41,37.06 129.53,36.93 129.66,36.93 129.89,37.17 130.02,37.17 130.15,37.04 130.15,36.92 129.91,36.68 129.91,36.56 130.04,36.43 130.16,36.43 130.35,36.62 130.48,36.62 130.59,36.5 130.59,28.4 130.92,28.08 130.92,27.59 130.83,27.5 130.66,27.5 130.58,27.41 130.58,27.25 130.66,27.16 130.83,27.16 130.92,27.07 130.92,26.9 130.83,26.81 130.56,26.81 130.47,26.72 130.47,26.56 130.56,26.47 130.83,26.47 130.92,26.38 130.92,26.22 130.83,26.13 130.56,26.13 130.47,26.04 130.47,25.87 130.56,25.78 130.83,25.78 130.92,25.7 130.92,25.26 130.81,25.15 130.6,25.15 130.33,24.87 129.73,24.87 129.64,24.79 129.64,24.71 129.64,24.71 129.64,24.53 129.73,24.44 130.38,24.44 130.46,24.35 130.46,24.17 130.38,24.08 129.73,24.08 129.64,23.99 129.64,23.81 129.73,23.73 130.37,23.73 130.6,23.5 131.1,23.5 131.27,23.33 131.27,22.96 131.13,22.81 130.62,22.81 130.53,22.72 130.53,22.56 130.62,22.47 131.13,22.47 131.24,22.36 131.24,22.23 131.13,22.12 130.53,22.12 130.44,22.03 130.44,21.88 130.54,21.78 131.13,21.78 131.22,21.69 131.22,20.43 131.11,20.32 130.86,20.32 130.78,20.4 130.78,21.34 130.69,21.43 130.51,21.43 130.42,21.34 130.42,20.82 130.33,20.73 130.16,20.73 130.07,20.82 130.07,22.13 129.95,22.24 129.8,22.24 129.71,22.15 129.71,21.33 129.62,21.24 129.11,21.24 128.89,21.02 128.89,20.59 128.74,20.44 128.23,20.44 128.09,20.3 128.09,19.95 127.67,19.53 v1(127.67,17.66)
  L14_SIG5 w0.081: v1(127.67,17.66) 127.67,17.62 128,17.29 128.31,17.29 132.07,17.29 132.87,16.49 136.04,16.49 136.84,17.29 136.95,17.29 v1(137.32,17.66)
  L16_SIG6 w0.081: v1(137.32,17.66) 137.71,17.27 147.09,17.27 v1(147.48,17.66) 147.87,17.27 150.66,17.27 151.46,18.07 157.26,18.07 v1(157.64,17.7) 158.03,18.09 159.9,18.09 159.94,18.13 160.79,18.13 160.83,18.09 161.66,18.09 161.83,18.26 162,18.26 162.17,18.09 162.34,18.09 162.51,18.26 162.67,18.26 162.84,18.09 167.24,18.09 v1(167.67,17.66)
  BOTTOM w0.149: v1(167.67,17.66) 167.09,17.08 R901.2
DDR4_COMP_CH1_A10: length 86.6
  TOP w0.149: U9.M3 v1(145.29,20.06) ; U11.M3 v1(165.74,20.06) ; U10.M3 v1(155.45,20.1) ; U8.M3 v1(135.13,20.06) ; U7.M3 v1(125.23,20.06)
  L07_SIG3 w0.089: v1(165.74,20.06) 165.32,20.49 157.45,20.49 157.07,20.1 v1(155.45,20.1) 155.07,20.48 145.71,20.48 v1(145.29,20.06) 144.9,20.45 135.52,20.45 v1(135.13,20.06) 134.71,20.49 131.56,20.49 131.47,20.58 131.47,20.73 131.38,20.82 131.21,20.82 131.12,20.73 131.12,20.58 131.03,20.49 130.87,20.49 130.78,20.58 130.78,20.73 130.69,20.82 130.53,20.82 130.44,20.73 130.44,20.58 130.35,20.49 125.65,20.49 v1(125.23,20.06)
  L16_SIG6 w0.081: v1(130.66,41.45) 131.55,41.45 132.1,40.9 132.41,40.9 132.87,40.44 133.21,40.44 133.44,40.2 133.44,39.36 133.75,39.06 134,39.06 134.22,38.84 134.22,38.15 134.42,37.96 134.42,37.32 135.13,36.61 135.13,34.55 135.64,34.04 135.64,29 136.03,28.61 136.03,27.69 135.87,27.53 135.87,26.44 arc(135.81,25.71) 135.62,24.99 arc(135.61,24.95) 135.58,24.92 134.17,23.42 arc(134.14,23.39) 134.11,23.36 133.56,22.89 arc(133.52,22.87) 133.49,22.86 arc(133.44,22.85) 133.4,22.84 arc(133.36,22.84) 133.32,22.83 133,22.83 arc(132.88,22.81) 132.79,22.75 132.66,22.62 132.66,22.4 132.27,22.01 arc(132.25,21.99) 132.24,21.95 132.24,20.09 132.02,19.54 130.61,18.13 130,18.13 129.92,18.05 127.49,18.05 127.2,17.76 125.15,17.76 124.64,17.25 123.39,17.25 123.27,17.37 123.27,17.93 123.38,18.03 124.27,18.03 124.6,18.37 124.6,19.49 125.14,20.03 125.19,20.03 v1(125.23,20.06)
DDR4_COMP_CH1_A11: length 85.2
  TOP w0.149: U11.T2 v1(164.31,16.35)
  L05_SIG2 w0.081: v1(123.67,16.86) 126.01,16.86 126.1,16.78 126.1,16.5 126.18,16.42 128,16.42 128.31,16.73 128.62,16.73 128.93,16.42 133.38,16.42 v1(133.83,16.86) 134.23,16.46 138.21,16.46 138.47,16.73 138.78,16.73 139.04,16.46 143.59,16.46 v1(143.99,16.86) 144.44,16.41 148.31,16.41 148.63,16.73 148.94,16.73 149.26,16.41 153.65,16.41 v1(154.15,16.9) 154.59,16.46 158.49,16.46 158.79,16.76 158.83,16.76 159.1,16.76 159.51,16.35 v1(164.31,16.35)
  L16_SIG6 w0.081: v1(129.87,41.91) 130.45,41.91 arc(130.73,41.96) 130.97,42.12 arc(131.16,42.24) 131.37,42.28 131.46,42.28 arc(131.6,42.25) 131.73,42.19 arc(131.88,42.09) 132.06,42.02 arc(132.12,42) 132.18,41.97 132.44,41.86 arc(132.47,41.84) 132.5,41.81 132.6,41.71 arc(132.68,41.65) 132.78,41.6 arc(132.82,41.58) 132.85,41.56 134,40.9 134.15,40.75 arc(134.21,40.67) 134.23,40.57 134.23,40.06 arc(134.23,40.02) 134.23,39.98 arc(134.29,39.83) 134.39,39.7 arc(134.42,39.67) 134.45,39.65 arc(134.56,39.59) 134.68,39.55 arc(134.79,39.5) 134.89,39.43 134.94,39.38 arc(135.02,39.26) 135.05,39.12 135.05,37.85 arc(135.09,37.62) 135.22,37.42 135.41,37.23 arc(135.5,37.14) 135.57,37.04 arc(135.72,36.71) 135.78,36.35 135.78,35.44 arc(135.78,35.4) 135.78,35.36 arc(135.87,34.88) 135.97,34.41 arc(135.98,34.37) 136,34.33 arc(136.03,34.26) 136.06,34.19 arc(136.2,33.87) 136.29,33.53 136.61,31.95 arc(136.61,31.91) 136.62,31.87 136.62,21.81 136.04,21.23 134.36,21.23 134.2,21.07 134.2,19.91 133.92,19.63 133.67,19.63 133.46,19.42 133.46,19.17 133.12,18.83 132.87,18.83 131.33,17.29 126.09,17.29 126.01,17.21 126.01,16.65 125.92,16.57 125.75,16.57 125.67,16.65 125.67,17.21 125.59,17.29 125.19,17.29 124.76,16.86 v1(123.67,16.86)
DDR4_COMP_CH1_A12: length 85.8
  TOP w0.149: U9.M7 v1(147.48,20.06) ; U10.M7 v1(157.64,20.1) ; U8.M7 v1(137.32,20.06) ; U11.M7 v1(167.67,20.06) ; U7.M7 v1(127.16,20.06)
  L14_SIG5 w0.081: v1(127.16,20.06) 127.53,19.69 130.28,19.69 131.02,20.44 131.66,20.44 131.75,20.52 131.75,20.63 131.83,20.71 132,20.71 132.08,20.63 132.08,20.52 132.16,20.44 136.17,20.44 136.55,20.06 v1(137.32,20.06)
  L16_SIG6 w0.081: v1(128.27,43.75) 128.4,43.62 128.4,43.36 128.24,43.2 128.12,43.2 127.84,42.92 127.5,42.92 127.02,42.44 126.55,42.44 126.31,42.2 126.31,38.99 126.53,38.78 126.82,38.78 127.46,38.14 127.63,38.14 127.93,37.83 128.08,37.83 128.24,37.67 128.24,37.53 129.84,35.92 129.96,35.92 130.02,35.99 130.14,35.99 130.26,35.87 130.26,35.75 130.2,35.69 130.2,35.57 130.5,35.26 130.62,35.26 130.81,35.46 130.93,35.46 131.05,35.34 131.05,35.22 130.85,35.03 130.85,34.91 131.1,34.67 131.3,34.67 131.65,35.02 131.76,35.02 131.88,34.9 131.88,34.78 131.64,34.54 131.64,34.42 131.76,34.3 131.88,34.3 132.12,34.54 132.23,34.54 132.34,34.43 132.34,34.28 131.97,33.91 131.97,33.8 132.52,33.25 132.52,33.02 132.42,32.92 131.95,32.92 131.87,32.84 131.87,32.67 131.95,32.59 132.37,32.59 132.45,32.51 132.45,32.36 132.34,32.25 131.95,32.25 131.87,32.17 131.87,32 131.95,31.92 132.37,31.92 132.45,31.84 132.45,31.69 132.34,31.58 131.95,31.58 131.87,31.5 131.87,31.33 131.95,31.25 132.4,31.25 132.48,31.17 132.48,31.02 132.37,30.91 131.95,30.91 131.87,30.83 131.87,30.39 131.95,30.31 132.43,30.31 132.52,30.23 132.52,30.06 132.44,29.98 131.95,29.98 131.87,29.9 131.87,29.72 131.95,29.64 132.22,29.64 132.3,29.56 132.3,29.39 132.22,29.31 131.95,29.31 131.87,29.23 131.87,28.89 131.95,28.81 132.22,28.81 132.3,28.73 132.3,28.56 132.22,28.47 131.88,28.47 131.79,28.39 131.79,28.23 131.88,28.14 132.22,28.14 132.3,28.06 132.3,27.89 132.22,27.8 131.95,27.8 131.81,27.66 131.81,25.22 130.83,24.24 130.49,24.24 130.15,23.9 130.15,23.78 130.24,23.69 130.24,23.58 130.12,23.45 130,23.45 129.91,23.55 129.79,23.55 129.09,22.84 129.08,22.84 128.9,22.66 128.9,22.33 128.66,22.09 128.15,22.09 128.04,21.98 128.04,21.52 127.53,21.02 127.53,20.71 127.16,20.34 v1(127.16,20.06) ; v1(137.32,20.06) 137.73,20.48 147.06,20.48 v1(147.48,20.06) 147.89,20.48 155.74,20.48 155.98,20.24 157.5,20.24 v1(157.64,20.1) 158.02,20.48 167.26,20.48 v1(167.67,20.06)
DDR4_COMP_CH1_A13: length 85.7
  TOP w0.149: U7.T8 v1(128.47,16.35) ; U9.T8 v1(148.79,16.35) ; U8.T8 v1(138.63,16.35) ; U11.T8 v1(169.11,16.35) ; U10.T8 v1(158.95,16.39)
  L12_SIG4 w0.089: v1(130.65,42.35) 131.05,42.75 131.05,43.9 131.39,44.25 131.77,44.25 132.1,44.58 132.41,44.58 132.66,44.33 132.66,42.71 132.9,42.48 133.1,42.48 133.43,42.15 133.43,37.6 arc(133.44,37.45) 133.49,37.31 133.63,36.97 arc(133.64,36.93) 133.64,36.89 133.64,36.07 arc(133.65,36.03) 133.68,35.99 134.25,35.42 134.25,35.08 134.34,34.99 135.1,34.99 135.19,34.9 135.19,34.73 135.1,34.64 134.34,34.64 134.25,34.56 134.25,34.39 134.34,34.3 135.1,34.3 135.19,34.21 135.19,34.05 135.1,33.96 134.46,33.96 134.37,33.87 134.37,33.64 arc(134.4,33.49) 134.48,33.37 135.11,32.74 arc(135.61,32) 135.78,31.12 135.78,28.45 136.01,28.22 136.01,27.91 135.78,27.68 135.78,21.2 arc(135.76,21.05) 135.71,20.91 arc(135.64,20.79) 135.55,20.69 135.36,20.5 arc(135.29,20.45) 135.21,20.44 133.67,20.44 133.45,20.22 133.45,19.83 133.26,19.64 132.87,19.64 132.65,19.42 132.65,19.05 130.84,17.24 130,17.24 129.78,17.02 129.78,16.84 129.56,16.62 arc(129.27,16.42) 128.93,16.35 v1(128.47,16.35)
  L16_SIG6 w0.081: v1(169.11,16.35) 168.71,15.96 159.38,15.96 v1(158.95,16.39) 158.91,16.35 v1(148.79,16.35) v1(138.63,16.35) 131.57,16.35 131.49,16.44 131.49,16.6 131.41,16.68 131.24,16.68 131.16,16.6 131.16,16.44 131.07,16.35 v1(128.47,16.35)
  BOTTOM w0.149: R905.2 169.2,16.27 v1(169.11,16.35)
DDR4_COMP_CH1_A14: length 86
  L05_SIG2 w0.081: v1(123.67,20.86) 124.09,20.44 125.84,20.44 125.92,20.52 125.92,20.69 126,20.77 126.17,20.77 126.25,20.69 126.25,20.52 126.34,20.44 133.39,20.44 133.82,20.86 v1(133.83,20.86) 134.25,20.44 143.57,20.44 v1(143.99,20.86) 144.38,20.47 153.72,20.47 v1(154.15,20.9) 154.56,20.49 163.93,20.49 v1(164.31,20.86)
  L16_SIG6 w0.081: v1(123.67,20.86) 123.91,20.86 124.34,21.29 126.39,21.29 128.28,23.18 128.95,23.18 130.36,24.59 130.36,24.96 130.75,25.34 130.86,25.34 131.05,25.16 131.17,25.16 131.29,25.28 131.29,25.39 131.1,25.58 131.1,25.7 131.46,26.06 131.46,29.08 131.52,29.15 131.52,29.82 131.44,29.9 131.28,29.9 131.2,29.98 131.2,30.15 131.28,30.24 131.44,30.24 131.52,30.32 131.52,30.49 131.44,30.57 131.28,30.57 131.2,30.65 131.2,30.83 131.28,30.91 131.44,30.91 131.52,30.99 131.52,31.16 131.44,31.24 131.28,31.24 131.2,31.32 131.2,31.5 131.28,31.58 131.44,31.58 131.52,31.66 131.52,34.04 131.24,34.32 130.97,34.32 130.86,34.43 130.75,34.43 130.49,34.18 130.38,34.18 130.26,34.3 130.26,34.42 130.51,34.67 130.51,34.78 130.39,34.91 130.27,34.91 130.02,34.65 129.9,34.65 129.78,34.78 129.78,34.89 130.03,35.14 130.03,35.26 129.8,35.5 129.68,35.5 129.44,35.25 129.32,35.25 129.2,35.37 129.2,35.49 129.45,35.73 129.45,35.85 129.32,35.97 129.21,35.97 128.96,35.72 128.85,35.72 128.72,35.85 128.72,35.96 128.97,36.21 128.97,36.32 127.9,37.4 126.99,37.4 126.07,38.32 125.73,38.32 125.51,38.53 125.51,42.52 125.73,42.74 126.07,42.74 126.53,43.2 126.81,43.2 127.45,43.84 127.63,43.84 127.97,44.17 128.58,44.17 128.92,43.84 129.25,43.84 129.92,43.17 129.92,42.88 v1(129.86,42.81)
  BOTTOM w0.149: R906.2 162.9,21.71 163.34,21.27 163.9,21.27 v1(164.31,20.86)
DDR4_COMP_CH1_A15: length 88.9
  L03_SIG1 w0.081: v1(128.47,20.06) 128.84,19.69 135.67,19.69 135.77,19.79 135.77,19.98 135.86,20.06 136.03,20.06 136.11,19.98 136.11,19.79 136.21,19.69 136.35,19.69 136.44,19.79 136.44,19.99 136.52,20.07 136.7,20.07 136.78,19.99 136.78,19.79 136.88,19.69 138.26,19.69 v1(138.63,20.06) 139,19.69 148.42,19.69 v1(148.79,20.06) 149.16,19.69 158.54,19.69 v1(158.95,20.1) 159.36,19.69 166.6,19.69 166.7,19.79 166.7,19.93 166.8,20.03 166.94,20.03 167.04,19.93 167.04,19.79 167.14,19.69 168.74,19.69 v1(169.11,20.06)
  L12_SIG4 w0.089: v1(128.47,20.06) 128.55,19.98 128.92,19.98 129.42,20.48 129.9,20.48 130.4,19.98 131.34,19.98 131.62,20.26 131.62,24.02 131.28,24.35 131.28,29.41 131.37,29.49 132.12,29.49 132.21,29.58 132.21,29.76 132.12,29.85 131.06,29.85 130.97,29.94 130.97,30.12 131.06,30.21 132.15,30.21 132.24,30.29 132.24,30.46 132.14,30.56 131.06,30.56 130.97,30.65 130.97,30.83 131.06,30.92 132.15,30.92 132.24,31.01 132.24,31.17 132.14,31.27 131.06,31.27 130.97,31.36 130.97,31.54 131.06,31.63 131.8,31.63 131.89,31.72 131.89,32.64 131.8,32.73 131.49,32.73 131.38,32.83 131.38,32.98 131.47,33.07 131.8,33.07 131.89,33.16 131.89,33.32 131.8,33.41 131.5,33.41 131.41,33.5 131.41,33.67 131.5,33.76 131.8,33.76 131.89,33.85 131.89,34.49 131.8,34.58 131.05,34.58 130.96,34.67 130.96,34.85 131.05,34.93 131.8,34.93 131.89,35.02 131.89,35.2 131.8,35.29 131.09,35.29 131,35.38 131,35.56 131.09,35.65 131.8,35.65 131.89,35.73 131.89,35.96 130.29,37.56 130.29,38.53 130.29,39.45 130.29,40.17 130.24,40.22 130.24,42.06 130.05,42.25 130.05,42.48 130.23,42.66 130.23,42.97 130.23,42.97 130.23,43.38 130.66,43.82 v1(130.66,44.21)
  BOTTOM w0.149: v1(169.11,20.06) 169.2,20.06 169.54,20.4 170.27,20.4 170.41,20.54 170.41,22.16 171.06,22.8 R907.2
DDR4_COMP_CH1_A16: length 87.5
  L03_SIG1 w0.081: v1(128.47,20.86) 128.47,20.71 128.68,20.49 129.99,20.49 130.09,20.59 130.09,20.85 130.16,20.91 130.36,20.91 130.43,20.84 130.43,20.59 130.53,20.49 138.26,20.49 v1(138.63,20.86) 139,20.49 148.42,20.49 v1(148.79,20.86) 149.16,20.49 158.54,20.49 v1(158.95,20.9) 159.36,20.49 168.74,20.49 v1(169.11,20.86)
  L12_SIG4 w0.089: v1(128.47,20.86) 128.47,21.08 128.85,21.46 128.85,23.1 128.94,23.19 129.2,23.19 129.29,23.28 129.29,23.44 129.2,23.53 128.94,23.53 128.85,23.62 128.85,25.17 128.94,25.26 129.76,25.26 129.92,25.43 129.92,25.87 129.72,26.07 129.04,26.07 128.85,26.26 128.85,26.73 129,26.88 129.63,26.88 129.73,26.98 129.73,27.48 129.56,27.65 129.08,27.65 128.87,27.86 128.87,28.29 129.07,28.49 130,28.49 130.23,28.72 130.23,31.15 130.14,31.23 129.65,31.23 129.56,31.32 129.56,31.5 129.65,31.59 130.14,31.59 130.23,31.68 130.23,31.86 130.14,31.95 129.76,31.95 129.67,32.03 129.67,32.21 129.76,32.3 130.14,32.3 130.23,32.39 130.23,32.57 130.14,32.66 129.78,32.66 129.69,32.75 129.69,32.92 129.78,33.01 130.14,33.01 130.23,33.1 130.23,35.73 128.66,37.3 128.66,39.99 128.82,40.15 129.23,40.15 129.44,40.37 129.44,40.55 129.45,40.55 129.45,44.83 129.54,44.93 129.54,45.26 129.45,45.35 129.45,46.45 129.65,46.66 130.44,46.66 130.51,46.59 130.85,46.59 131.31,46.13 131.63,46.13 131.84,45.93 131.84,45.15 131.73,45.04 131.11,45.04 130.82,44.75 130.51,44.75 129.87,44.11 v1(129.87,43.75)
  BOTTOM w0.149: R908.2 170.17,22.87 169.77,22.87 169.5,22.6 169.5,21.25 v1(169.11,20.86)
DDR4_COMP_CH1_ACT_N: length 84.1
  TOP w0.149: U10.L3 v1(155.45,20.9) ; U9.L3 v1(145.29,20.86) ; U11.L3 v1(165.74,20.86)
  L03_SIG1 w0.081: v1(120.56,20.89) 120.56,20.85 120.92,20.49 124.1,20.49 v1(124.47,20.86)
  L07_SIG3 w0.089: v1(165.74,20.86) 165.74,21.1 165.59,21.25 161.38,21.25 161.29,21.34 161.29,21.52 161.17,21.63 161.05,21.63 160.93,21.52 160.93,21.37 160.84,21.28 157.37,21.28 156.83,20.75 155.61,20.75 v1(155.45,20.9) 155.06,21.3 149.84,21.3 149.71,21.42 149.54,21.42 149.37,21.25 145.68,21.25 v1(145.29,20.86) 145.29,20.86 145.29,20.87 144.9,21.25 141.37,21.25 141.22,21.41 141.02,21.41 140.86,21.25 140.66,21.25 140.51,21.41 140.31,21.41 140.15,21.25 135.86,21.25 arc(135.57,21.21) 135.31,21.07 135.3,21.06 arc(135,20.91) 134.68,20.86 v1(134.63,20.86) 134.55,20.94 arc(134.21,21.17) 133.81,21.25 127.32,21.25 arc(127.03,21.24) 126.74,21.2 125.76,21.04 arc(125.12,20.94) v1(124.47,20.86)
  L12_SIG4 w0.089: v1(120.56,20.89) 120.56,20.9 120.94,21.82 arc(120.96,21.86) 120.97,21.91 arc(121.1,22.57) 121.15,23.25 121.15,24.2 121.06,24.29 120.57,24.29 120.48,24.38 120.48,24.55 120.57,24.63 121.06,24.63 121.15,24.72 121.15,24.89 121.06,24.98 120.58,24.98 120.49,25.07 120.49,25.23 120.58,25.32 121.06,25.32 121.15,25.41 121.15,25.57 121.06,25.66 120.56,25.66 120.47,25.75 120.47,25.92 120.56,26.01 121.06,26.01 121.15,26.09 121.15,28.98 121.06,29.07 120.7,29.07 120.61,29.16 120.61,29.32 120.7,29.41 121.06,29.41 121.15,29.5 121.15,29.66 121.06,29.75 120.7,29.75 120.61,29.84 120.61,30.01 120.7,30.1 121.06,30.1 121.15,30.18 121.15,30.35 121.06,30.44 120.7,30.44 120.61,30.53 120.61,30.69 120.7,30.78 121.06,30.78 121.15,30.87 121.15,31.04 121.06,31.12 120.61,31.12 120.52,31.21 120.52,31.39 120.6,31.47 121.06,31.47 121.15,31.56 121.15,31.72 121.06,31.81 120.61,31.81 120.52,31.9 120.52,32.08 120.6,32.15 121.06,32.15 121.15,32.24 121.15,33.69 arc(121.19,34.71) 121.34,35.73 arc(121.48,36.74) 121.52,37.76 121.52,41.14 121.53,41.14 121.53,41.75 121.52,41.75 121.52,41.93 arc(121.55,42.05) 121.62,42.16 121.72,42.26 arc(121.76,42.29) 121.8,42.31 122,42.39 arc(122.04,42.41) 122.08,42.43 122.43,42.67 122.5,42.74 arc(122.59,42.81) 122.7,42.85 arc(122.81,42.89) 122.9,42.96 122.99,43.05 arc(123.08,43.18) 123.11,43.34 123.11,45.54 arc(123.21,46.06) v1(123.49,46.51)
DDR4_COMP_CH1_ALERT_N: length 86.3
  L12_SIG4 w0.089: v1(132.26,42.36) 132.56,42.36 132.63,42.29 132.63,37.92 132.63,36.85 133.17,36.31 133.17,35.83 133.78,35.22 133.78,33.48 133.78,32.8 133.91,32.67 134.47,32.67 134.64,32.51 134.64,32.31 134.51,32.19 133.92,32.19 133.83,32.1 133.83,31.93 133.92,31.84 134.48,31.84 134.57,31.76 134.57,31.57 134.5,31.5 133.92,31.5 133.83,31.41 133.83,31.25 133.92,31.16 134.48,31.16 134.57,31.07 134.57,30.88 134.5,30.81 133.92,30.81 133.83,30.73 133.83,30.56 133.92,30.47 134.82,30.47 135.15,30.14 135.15,24.39 134.8,24.05 133.81,24.05 133.72,23.96 133.72,23.79 133.81,23.7 134.55,23.7 134.63,23.62 134.63,23.49 134.51,23.36 133.81,23.36 133.72,23.27 133.72,23.11 133.81,23.02 134.24,23.02 134.41,22.85 134.41,21.46 134.25,21.29 133.59,21.29 133.45,21.15 133.45,20.63 133.3,20.48 132.88,20.48 132.62,20.21 132.62,19.79 130.98,18.16 130.98,17.79 130.87,17.68 130.63,17.68 130.54,17.77 130.54,18.35 130.37,18.52 129.79,18.52 129.7,18.44 129.7,17.35 129.61,17.27 128.97,17.27 128.88,17.35 128.88,18.37 128.98,18.46 v1(129.27,18.46)
  L14_SIG5 w0.081: v1(129.27,18.46) 132.5,18.46 132.87,18.09 136.46,18.09 137.2,18.83 139.06,18.83 v1(139.43,18.46) 139.84,18.88 146.41,18.88 146.51,18.97 146.51,19.26 146.59,19.34 146.76,19.34 146.84,19.26 146.84,18.96 146.93,18.88 149.17,18.88 v1(149.59,18.46) 149.94,18.46 150.37,18.89 159.36,18.89 v1(159.75,18.5) 160.13,18.88 169.49,18.88 v1(169.91,18.46)
  BOTTOM w0.149: v1(169.91,18.46) 170.45,17.92 171.2,17.92 R66.2
DDR4_COMP_CH1_BA0: length 85
  L05_SIG2 w0.081: v1(164.31,19.26) 163.92,18.87 154.58,18.87 v1(154.15,19.3) 153.69,18.84 144.41,18.84 v1(143.99,19.26) 143.57,18.84 134.25,18.84 v1(133.83,19.26) 133.41,18.84 131.09,18.84 131.01,18.92 131.01,19.02 130.93,19.1 130.75,19.1 130.67,19.02 130.67,18.92 130.59,18.84 124.09,18.84 v1(123.67,19.26)
  L16_SIG6 w0.081: v1(123.67,19.26) 123.93,19.53 123.93,19.77 124.04,19.87 124.04,20.33 124.2,20.49 124.62,20.49 125.07,20.95 126.64,20.95 126.76,20.83 126.76,19.78 126.9,19.63 127.73,19.63 127.87,19.77 127.87,20.82 128.36,21.31 128.72,21.31 128.84,21.43 128.84,21.64 arc(128.86,21.78) 128.94,21.9 129.03,21.98 arc(129.15,22.06) 129.29,22.09 129.51,22.09 arc(129.57,22.1) 129.62,22.14 129.67,22.19 arc(129.72,22.26) 129.73,22.34 129.73,22.51 arc(129.74,22.55) 129.75,22.59 129.77,22.67 arc(129.79,22.71) 129.81,22.74 130.03,22.96 arc(130.15,23.04) 130.3,23.07 130.34,23.07 arc(130.64,23.13) 130.89,23.29 arc(131.06,23.54) 131.13,23.83 arc(131.13,23.87) 131.14,23.91 arc(131.16,23.98) 131.2,24.04 arc(131.22,24.07) 131.25,24.1 132.61,25.47 arc(132.63,25.49) 132.63,25.52 132.63,25.76 132.55,25.84 132.2,25.84 132.15,25.9 132.15,26.12 132.2,26.18 132.51,26.18 132.63,26.3 132.63,26.43 132.55,26.51 132.21,26.51 132.15,26.57 132.15,26.82 132.19,26.87 132.55,26.87 132.63,26.95 132.63,28.72 arc(132.66,28.99) 132.76,29.24 arc(132.82,29.4) 132.86,29.57 arc(132.87,29.61) 132.87,29.65 132.87,33.9 arc(132.78,34.36) 132.52,34.75 132.05,35.22 arc(131.78,35.43) 131.48,35.59 arc(131.31,35.66) 131.15,35.75 129.4,36.93 arc(129.36,36.95) 129.33,36.98 128.75,37.56 arc(128.7,37.63) 128.69,37.71 128.69,38.15 arc(128.61,38.44) 128.39,38.65 arc(128.13,38.79) 127.88,38.95 arc(127.76,39.02) 127.64,39.06 arc(127.48,39.12) 127.35,39.2 127.26,39.28 arc(127.15,39.42) 127.11,39.59 127.11,41.49 arc(127.13,41.59) 127.19,41.68 127.25,41.75 arc(127.33,41.8) 127.42,41.82 127.51,41.82 arc(127.64,41.84) 127.75,41.92 128.04,42.21 arc(128.16,42.29) 128.31,42.33 arc(128.39,42.36) 128.47,42.41 128.72,42.66 arc(128.75,42.69) 128.79,42.7 arc(128.88,42.73) 128.97,42.74 129.09,42.74 arc(129.21,42.71) 129.32,42.64 129.41,42.56 arc(129.55,42.46) 129.72,42.43 129.98,42.43 arc(130.15,42.46) 130.31,42.56 130.31,42.57 arc(130.66,42.8) 131.07,42.88 v1(131.46,42.88)
  BOTTOM w0.149: v1(164.31,19.26) 163.93,19.64 163.69,19.64 163.67,19.65 163.34,19.65 163.33,19.64 163.25,19.64 162.85,19.24 R911.2
DDR4_COMP_CH1_BA1: length 84.9
  L03_SIG1 w0.081: v1(128.47,19.26) 128.84,18.89 131.36,18.89 131.58,19.11 131.77,19.11 131.99,18.89 136.34,18.89 136.43,18.99 136.43,19.21 136.54,19.32 136.65,19.32 136.77,19.2 136.77,18.99 136.87,18.89 138.26,18.89 v1(138.63,19.26) 139,18.89 148.42,18.89 v1(148.79,19.26) 149.16,18.89 158.54,18.89 v1(158.95,19.3) 159.36,18.89 168.9,18.89 169.11,19.1 v1(169.11,19.26)
  L12_SIG4 w0.089: v1(128.47,19.26) 128.84,18.89 130.12,18.89 130.21,18.98 130.21,19.21 130.29,19.29 130.46,19.29 130.55,19.21 130.55,18.98 130.64,18.89 131.24,18.89 132.3,19.95 132.3,21.56 132.78,22.04 133.23,22.04 133.43,22.24 133.43,26 133.52,26.09 134.08,26.09 134.24,26.24 134.24,26.74 134.13,26.85 133.52,26.85 133.43,26.94 133.43,27.58 133.52,27.67 134.13,27.67 134.24,27.79 134.24,28.37 134.15,28.46 133.52,28.46 133.43,28.54 133.43,29.59 133.36,29.66 133.36,32.01 133.2,32.17 132.68,32.17 132.59,32.26 132.59,32.44 132.68,32.53 133.2,32.53 133.29,32.62 133.29,32.8 133.2,32.88 132.68,32.88 132.59,32.97 132.59,33.15 132.68,33.24 133.2,33.24 133.29,33.33 133.29,33.51 133.2,33.6 132.68,33.6 132.59,33.68 132.59,33.86 132.68,33.95 133.2,33.95 133.29,34.04 133.29,34.22 133.2,34.31 132.68,34.31 132.59,34.4 132.59,34.65 132.68,34.73 133.22,34.73 133.29,34.81 133.29,34.99 133.2,35.08 132.74,35.08 132.59,35.22 132.59,36.23 132.16,36.66 132.16,37.11 131.87,37.4 131.87,43.81 v1(132.26,44.21)
  BOTTOM w0.149: v1(169.11,19.26) 169.49,19.64 170.71,19.64 170.95,19.88 170.95,20.23 171.13,20.4 171.13,20.51 R912.2
DDR4_COMP_CH1_BG0: length 82.8
  L05_SIG2 w0.081: v1(164.31,20.06) 163.94,19.7 163.66,19.7 163.66,19.69 163.35,19.69 163.35,19.7 154.55,19.7 v1(154.15,20.1) 153.72,19.67 144.38,19.67 v1(143.99,20.06) 143.57,19.64 134.25,19.64 v1(133.83,20.06) 133.41,19.64 130.94,19.64 130.86,19.72 130.86,19.85 130.77,19.94 130.61,19.94 130.52,19.85 130.52,19.72 130.44,19.64 124.09,19.64 v1(123.67,20.06)
  L16_SIG6 w0.081: v1(123.67,20.06) 123.62,20.06 123.27,20.41 123.27,21 123.56,21.29 123.86,21.29 124.19,21.63 126.26,21.63 128.32,23.69 128.62,23.69 128.84,23.91 128.84,24.21 129.12,24.49 129.42,24.49 129.69,24.76 arc(130.59,26.11) 130.91,27.7 130.91,29.14 arc(130.91,29.18) 130.9,29.22 130.68,31.95 arc(130.67,31.99) 130.66,32.03 130.52,32.36 arc(129.83,33.67) 128.89,34.82 128.09,35.62 arc(127.99,35.75) 127.92,35.89 arc(127.87,36.01) 127.79,36.11 127.33,36.65 arc(127.3,36.68) 127.27,36.7 127.08,36.8 arc(126.89,36.9) 126.69,36.99 125.8,37.36 arc(125.7,37.42) 125.61,37.5 arc(125.51,37.63) 125.42,37.77 arc(125.22,38.05) 125,38.33 arc(124.79,38.68) 124.71,39.08 124.71,42.87 arc(124.73,42.97) 124.79,43.06 125.11,43.38 125.24,43.38 125.7,43.84 126.04,43.84 126.22,44.02 arc(126.36,44.13) 126.52,44.22 arc(126.55,44.23) 126.59,44.23 126.81,44.23 arc(126.97,44.27) 127.1,44.35 127.4,44.66 arc(127.51,44.73) 127.64,44.76 127.67,44.76 arc(127.83,44.79) 127.96,44.87 128.04,44.95 arc(128.13,45.02) 128.24,45.04 128.36,45.04 arc(128.42,45.02) 128.48,44.99 128.58,44.88 arc(128.75,44.77) 128.96,44.73 arc(129.02,44.72) 129.08,44.71 arc(129.11,44.69) 129.14,44.67 129.34,44.47 arc(129.53,44.34) 129.76,44.3 129.79,44.3 arc(129.9,44.27) 130,44.21 130.24,43.97 arc(130.49,43.8) 130.78,43.75 v1(131.46,43.75)
  BOTTOM w0.149: v1(164.31,20.06) 164.05,20.06 163.9,20.21 163.9,20.23 163.67,20.45 163.65,20.45 163.65,20.46 163.34,20.46 163.22,20.58 163.2,20.58 162.89,20.88 R909.2
DDR4_COMP_CH1_BG1: length 87.5
  TOP w0.149: U8.M9 v1(139.93,20.06) ; U10.M9 v1(160.25,20.1) ; U9.M9 v1(150.09,20.06) ; U11.M9 v1(170.54,20.06) ; U7.M9 v1(129.77,20.06)
  L14_SIG5 w0.081: v1(170.54,20.06) 170.17,20.43 160.59,20.43 v1(160.25,20.1) 159.87,20.49 152.48,20.49 152.42,20.43 150.47,20.43 v1(150.09,20.06) 149.72,20.44 140.31,20.44 v1(139.93,20.06) 139.51,20.49 136.83,20.49 136.08,21.23 130.95,21.23 129.78,20.06 v1(129.77,20.06) 129.4,20.43 127,20.43 126.79,20.65 126.79,22.49 126.87,22.58 127.05,22.58 127.13,22.66 127.13,22.83 127.05,22.91 126.87,22.91 126.79,22.99 126.79,23.37 126.87,23.45 127.21,23.45 127.29,23.53 127.29,23.71 127.21,23.79 126.87,23.79 126.79,23.87 126.79,24.04 126.87,24.12 127.21,24.12 127.29,24.2 127.29,24.38 127.21,24.46 126.87,24.46 126.79,24.54 126.79,24.71 126.87,24.79 127.21,24.79 127.29,24.87 127.29,25.05 127.21,25.13 126.87,25.13 126.79,25.21 126.79,25.38 126.87,25.46 127.21,25.46 127.29,25.54 127.29,25.72 127.21,25.8 126.87,25.8 126.79,25.88 126.79,26.05 126.87,26.13 127.21,26.13 127.29,26.21 127.29,26.39 127.21,26.47 126.87,26.47 126.79,26.55 126.79,26.72 126.87,26.8 127.21,26.8 127.29,26.89 127.29,27.06 127.21,27.14 126.87,27.14 126.79,27.22 126.79,27.39 126.87,27.47 127.21,27.47 127.29,27.56 127.29,27.73 127.21,27.81 126.87,27.81 126.79,27.89 126.79,32.3 127.88,33.4 127.88,34 127.96,34.08 128.42,34.08 128.5,34.16 128.5,34.33 128.42,34.42 127.96,34.42 127.88,34.5 127.88,34.67 127.96,34.75 128.42,34.75 128.5,34.83 128.5,35 128.42,35.09 127.96,35.09 127.88,35.17 127.88,35.34 127.96,35.42 128.42,35.42 128.5,35.5 128.5,35.68 128.42,35.76 127.96,35.76 127.88,35.84 127.88,36.36 128.16,36.64 128.16,37.81 127.9,38.07 127.9,38.88 127.54,39.24 127.32,39.24 127.05,39.51 127.05,40.22 126.83,40.44 126.34,40.44 126.25,40.53 126.25,40.68 126.04,40.9 125.88,40.9 125.24,41.54 124.93,41.54 124.71,41.75 124.71,42.06 124.71,42.07 124.71,44.61 124.29,45.03 v1(124.29,45.13)
  BOTTOM w0.149: v1(170.54,20.06) 170.65,20.17 170.65,20.35 170.71,20.42 170.71,21.23 R910.2
DDR4_COMP_CH1_CKE: length 84.9
  L03_SIG1 w0.081: v1(133.83,21.66) 134.22,22.06 136.9,22.06 137.67,21.29 143.37,21.29 143.75,21.66 v1(143.99,21.66) 144.37,21.28 153.72,21.28 v1(154.15,21.7)
  L07_SIG3 w0.089: v1(133.83,21.66) 133.43,22.06 131.28,22.06 131.19,22.15 131.19,22.35 131.09,22.45 130.93,22.45 130.84,22.36 130.84,22.15 130.76,22.06 126.72,22.06 126.35,21.69 125.18,21.69 124.87,21.38 123.96,21.38 123.68,21.66 v1(123.67,21.66)
  L12_SIG4 w0.089: v1(154.15,21.7) 154.54,22.1 159.08,22.1 159.14,22.04 163.93,22.04 v1(164.31,21.66)
  L14_SIG5 w0.081: v1(125.88,46.05) 125.88,46.05 124.95,46.44 arc(124.91,46.45) 124.87,46.46 124.48,46.49 arc(124.18,46.44) 123.95,46.25 123.94,46.24 arc(123.92,46.21) 123.9,46.17 arc(123.88,46.12) 123.86,46.06 123.87,45.84 arc(123.87,45.77) 123.89,45.7 arc(123.91,45.63) 123.92,45.55 123.92,45.29 123.67,45.04 123.34,45.04 123.12,44.82 123.12,40.83 123.34,40.62 123.68,40.62 124.14,40.16 124.35,40.16 124.83,39.68 125.37,39.68 125.51,39.54 125.51,38.53 125.73,38.32 126.06,38.32 126.38,38 126.38,37.37 125.82,36.81 125.82,36.08 126.14,35.75 arc(126.17,35.72) 126.17,35.68 126.17,35.19 126.4,34.96 126.4,34.13 arc(126.39,34.09) 126.37,34.06 125.91,33.6 arc(125.87,33.57) 125.83,33.57 125.35,33.57 125.27,33.48 125.27,33.31 125.35,33.23 125.74,33.23 125.83,33.15 125.83,32.98 125.74,32.9 125.35,32.9 125.27,32.81 125.27,32.64 125.35,32.56 125.74,32.56 125.83,32.48 125.83,32.31 125.74,32.22 125.35,32.22 125.27,32.14 125.27,31.97 125.35,31.89 125.74,31.89 125.83,31.81 125.83,31.64 125.74,31.55 125.35,31.55 125.27,31.47 125.27,31.3 125.35,31.22 125.74,31.22 125.83,31.14 125.83,30.8 125.74,30.72 125.35,30.72 125.27,30.64 125.27,30.28 125.35,30.2 125.67,30.2 125.75,30.12 125.75,29.95 125.67,29.86 125.35,29.86 125.27,29.78 125.27,29.61 125.35,29.53 125.67,29.53 125.75,29.45 125.75,29.28 125.67,29.19 125.35,29.19 125.27,29.11 125.27,28.54 124.92,28.2 124.92,24.82 124.55,24.45 124.44,24.45 124.17,24.72 124.05,24.72 123.93,24.6 123.93,24.49 124.2,24.22 124.2,24.1 124.08,23.98 123.96,23.98 123.7,24.25 123.58,24.25 123.46,24.13 123.46,24.01 123.73,23.74 123.73,23.63 123.24,23.14 123.24,22.09 v1(123.67,21.66)
  BOTTOM w0.149: v1(164.31,21.66) 163.91,22.05 163.34,22.05 163.1,22.3 163.1,22.38 162.94,22.54 R72.1 R70.2
