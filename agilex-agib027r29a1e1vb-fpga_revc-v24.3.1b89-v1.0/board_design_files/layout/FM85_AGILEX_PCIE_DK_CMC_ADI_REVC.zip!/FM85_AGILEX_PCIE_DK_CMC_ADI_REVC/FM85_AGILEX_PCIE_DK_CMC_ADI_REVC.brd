# Allegro board FM85_AGILEX_PCIE_DK_CMC_ADI_REVC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_DDIMM_BG0: length 73.2
  L05_SIG2 w0.081: v1(143.09,106.96) 143.09,104.71 142.99,104.61 141.76,104.61 141.68,104.53 141.68,104.36 141.76,104.27 143.01,104.27 143.09,104.19 143.09,104.04 142.99,103.94 141.76,103.94 141.68,103.86 141.68,103.69 141.76,103.6 143.01,103.6 143.09,103.52 143.09,102.94 143.17,102.86 143.38,102.86 143.47,102.95 143.47,104.28 143.61,104.41 143.76,104.41 143.84,104.33 143.84,103.57 143.92,103.49 144.09,103.49 144.17,103.57 144.17,104.33 144.26,104.41 144.43,104.41 144.51,104.33 144.51,103.57 144.59,103.49 144.76,103.49 144.84,103.57 144.84,104.33 144.93,104.41 145.1,104.41 145.18,104.33 145.18,103.57 145.26,103.49 145.43,103.49 145.51,103.57 145.51,104.33 145.6,104.41 145.77,104.41 145.85,104.33 145.85,103.57 145.93,103.49 146.1,103.49 146.19,103.57 146.19,104.33 146.27,104.41 146.44,104.41 146.52,104.33 146.52,103.57 146.6,103.49 147,103.49 147.16,103.33 147.16,101.68 146.91,101.43 143.18,101.43 142.93,101.68 141.55,101.68 141.55,101.68 141.24,101.68 141.24,101.68 139,101.68 139,101.68 138.69,101.68 138.69,101.68 136.76,101.68 136.51,101.43 136.2,101.43 135.31,102.32 132.55,102.32 132.27,102.04 131.51,102.04 130.74,101.27 130.74,92.89 127.92,90.07 127.92,82.66 128.68,81.9 128.68,79.88 129.41,79.15 129.41,78.71 arc(129.42,78.59) 129.47,78.48 arc(129.53,78.25) 129.47,78.02 arc(129.41,77.79) 129.47,77.56 129.47,77.56 arc(129.53,77.33) 129.47,77.1 129.46,77.08 arc(129.41,76.86) 129.47,76.64 arc(129.53,76.41) 129.47,76.19 129.47,76.18 arc(129.41,75.95) 129.47,75.72 129.47,75.71 arc(129.53,75.48) 129.47,75.26 arc(129.41,75.03) 129.47,74.8 129.47,74.8 arc(129.53,74.57) 129.47,74.35 129.47,74.33 arc(129.41,74.11) 129.47,73.88 129.47,73.88 arc(129.53,73.65) 129.47,73.42 129.47,73.42 arc(129.3,73.25) 129.07,73.19 129.06,73.19 arc(128.84,73.13) 128.67,72.96 v1(128.27,72.27)
DDR4_DDIMM_BG1: length 73.7
  TOP w0.149: J2.207 143.09,102.99 142.46,103.62 140.58,103.62 v1(139.96,102.99)
  L07_SIG3 w0.089: v1(119.51,73.65) 119.51,73.94 120.16,74.59 120.46,74.59 120.9,74.15 121.38,74.15 121.74,74.51 122.05,74.51 122.49,74.94 122.68,74.94 123.12,75.38 123.12,75.79 123.12,75.79 123.12,76.1 123.12,76.11 123.12,76.71 123.12,76.71 123.12,77.02 123.12,77.03 123.12,77.63 123.12,77.63 123.12,77.94 123.12,77.95 123.12,78.55 123.12,78.55 123.12,78.86 123.12,78.87 123.12,79.47 123.12,79.47 123.12,79.78 123.12,79.79 123.12,80.39 123.12,80.39 123.12,80.7 123.12,80.71 123.12,82 123.04,82.08 123.04,85.35 130.3,92.61 133.98,92.61 135.17,93.8 138.93,93.8 139.49,94.36 140.86,94.36 141.93,93.28 145.8,93.28 147.35,94.83 147.35,95.23 148.52,96.41 149.5,96.41 150.36,97.27 150.36,103.9 148.36,105.9 147.36,105.9 146.84,106.42 141.71,106.42 139.96,104.67 v1(139.96,102.99)
DDR4_DDIMM_C0: length 61.3
  L03_SIG1 w0.081: v1(114.86,92.56) 114.63,92.79 114.63,94.83 114.26,95.2 114.26,98.54 114.56,98.84 114.56,101.07 113.46,102.17 113.46,102.73 112.6,103.59 v1(112.6,104.76)
  L07_SIG3 w0.089: v1(126.07,82.32) 126.07,82.32 127.06,81.34 127.06,72.04 126.82,71.81 v1(124.29,71.81)
  L14_SIG5 w0.081: v1(126.07,82.32) 126.07,82.82 125.04,83.84 125.04,86.64 124.96,86.72 124.45,86.72 124.37,86.8 124.37,86.98 124.45,87.06 124.96,87.06 125.04,87.14 125.04,87.62 123.28,89.38 117.46,89.38 115.03,91.81 112.11,91.81 112.03,91.89 112.03,92.83 111.91,92.96 108.74,92.96 108.66,93.04 108.66,93.63 108.75,93.72 110.2,93.72 110.6,93.33 111.07,93.33 111.46,93.72 111.72,93.72 111.73,93.72 111.8,93.72 112.51,93 112.51,92.4 112.77,92.15 114.49,92.15 114.86,92.53 v1(114.86,92.56)
DDR4_DDIMM_C0_CS_N2: length 1.6
  BOTTOM w0.149: v1(112.48,106.44) 112.6,106.32 R1070.2 111.81,105.65 R1072.2
DDR4_DDIMM_C1: length 64
  TOP w0.149: v1(126.79,82.76) 125.59,82.76 125.08,82.25 v1(123.44,82.25)
  L03_SIG1 w0.081: v1(113.22,103.74) 113.22,103.49 113.96,102.75 113.96,102.15 114.93,101.18 114.93,98.61 114.6,98.28 114.6,95.33 115.14,94.79 115.14,94.04 115.51,93.67 v1(115.51,91.94)
  L07_SIG3 w0.089: v1(125.09,71.35) 127.56,71.35 127.85,71.64 127.85,81.22 126.79,82.28 v1(126.79,82.76)
  L14_SIG5 w0.081: v1(126.79,82.76) 126.43,83.11 126.43,83.11 125.4,84.14 125.4,87.73 123.39,89.74 117.71,89.74 116.21,91.24 116.21,93.51 115.79,93.92 113.28,93.92 112.95,94.26 112.95,94.53 112.67,94.81 110.84,94.81 110.44,94.4 110.44,93.96 110.65,93.75 110.99,93.75 111.31,94.08 112.23,94.08 112.35,93.97 112.45,93.97 113.48,92.93 115.43,92.93 115.51,92.85 v1(115.51,91.94)
  BOTTOM w0.149: R1071.1 113.28,103.34 113.22,103.4 v1(113.22,103.74)
DDR4_DDIMM_C1_CS_N3: length 2
  BOTTOM w0.149: R1071.2 112.5,102.14 R1073.2 v1(112.49,100.97)
DDR4_DDIMM_CK_N0: length 72.3
  L05_SIG2 w0.076: 128.34,79.17 128.36,79.15 128.36,79.15 128.65,78.87 128.65,78.63 arc(128.63,78.58) 128.6,78.53 arc(128.52,78.25) 128.6,77.98 128.6,77.97 arc(128.65,77.79) 128.6,77.6 128.59,77.6 arc(128.52,77.33) 128.6,77.06 arc(128.65,76.88) 128.6,76.7 128.59,76.67 arc(128.52,76.4) 128.6,76.13 arc(128.65,75.95) 128.6,75.77 128.6,75.76 arc(128.52,75.49) 128.59,75.22 128.6,75.21 arc(128.65,75.03) 128.6,74.85 128.59,74.83 arc(128.52,74.56) 128.6,74.29 arc(128.6,73.93) 128.28,73.74 128.27,73.74 arc(127.8,73.47) 127.79,72.92 127.8,72.91 arc(127.85,72.73) 127.8,72.54 127.79,72.54 arc(127.66,72.41) 127.48,72.36 127.47,72.36 arc(127.29,72.41) 127.16,72.54 arc(126.96,72.74) 126.69,72.82 126.68,72.82 arc(126.44,72.77) 126.23,72.63 arc(126.21,72.6) 126.19,72.57 arc(126.13,72.5) 126.06,72.44 arc(126,72.39) 125.94,72.34 125.79,72.19 arc(125.47,71.97) 125.09,71.9 arc(124.91,71.94) 124.77,72.07 124.76,72.1 arc(124.56,72.29) 124.29,72.36 124.28,72.36 arc(124.1,72.41) 123.97,72.54 arc(123.77,72.74) 123.51,72.82 123.49,72.82 arc(123.31,72.86) 123.18,72.99 123.16,73.02 arc(123.12,73.2) 123.17,73.37 arc(123.24,73.61) 123.21,73.85 arc(123.2,73.86) 123.2,73.87 123.22,73.95 v1(123.49,74.11)
  L05_SIG2 w0.081: 128.34,79.17 127.85,79.66 127.85,80.96 127.22,82.49 127.22,83.8 126.89,84.14 126.89,90.08 129.94,93.13 129.94,97.71 129.62,98.03 129.62,102.82 129.87,103.07 132.83,103.07 133.34,103.59 136.69,103.59 136.88,103.4 136.88,102.73 136.96,102.65 137.14,102.65 137.22,102.73 137.22,103.4 137.41,103.59 137.73,103.59 137.92,103.4 137.92,102.73 138,102.65 138.17,102.65 138.25,102.73 138.25,103.4 138.44,103.59 138.77,103.59 138.96,103.4 138.96,102.73 139.04,102.65 139.21,102.65 139.29,102.73 139.29,103.4 139.48,103.59 140.92,103.59 141.01,103.68 141.01,104.41 140.93,104.5 139.45,104.5 139.26,104.68 139.26,105.11 139.18,105.19 139.01,105.19 138.93,105.11 138.93,104.68 138.74,104.5 138.41,104.5 138.23,104.68 138.23,105.11 138.14,105.19 137.97,105.19 137.89,105.11 137.89,104.68 137.7,104.5 137.38,104.5 137.19,104.68 137.19,105.11 137.11,105.19 136.94,105.19 136.85,105.11 136.85,104.68 136.67,104.5 136.34,104.5 136.15,104.68 136.15,105.11 136.07,105.19 135.9,105.19 135.82,105.11 135.82,104.68 135.48,104.35 135.01,104.35 134.83,104.18 134.71,104.18 134.53,104.35 134.34,104.35 134.18,104.19 134.02,104.19 133.86,104.35 133.7,104.35 133.23,104.83 133.23,105.28 133.05,105.46 133.05,105.58 133.23,105.76 133.23,105.95 133.05,106.13 133.05,106.25 133.23,106.43 133.23,106.71 132.98,106.96 v1(132.89,106.96)
DDR4_DDIMM_CK_N1: length 69.4
  L05_SIG2 w0.076: v1(127.47,69.99) 127.72,70.14 127.72,70.31 arc(127.71,70.38) 127.71,70.45 arc(127.73,70.6) 127.78,70.74 arc(127.89,70.89) 128.02,71.03 arc(128.42,71.29) 128.88,71.39 129.03,71.4 arc(129.13,71.42) 129.22,71.47 arc(129.24,71.48) 129.25,71.49 arc(129.35,71.57) 129.41,71.67 arc(129.42,71.68) 129.43,71.69 arc(129.5,71.77) 129.59,71.83 arc(129.66,71.86) 129.74,71.88 arc(129.75,71.88) 129.76,71.88 arc(129.81,71.89) 129.85,71.89 arc(129.91,71.89) 129.98,71.88 arc(130.08,71.9) 130.15,71.98 arc(130.18,72.05) 130.22,72.12 arc(130.22,72.12) 130.22,72.12 arc(130.22,72.12) 130.22,72.13 arc(130.41,72.29) 130.65,72.36 arc(130.73,72.36) 130.8,72.39 130.81,72.39 arc(131,72.57) 131.02,72.84 131.01,72.85 arc(131.01,72.86) 131.01,72.87 arc(131,72.89) 130.98,72.92 arc(130.92,73.13) 130.94,73.35 arc(130.96,73.41) 130.99,73.46 arc(131.04,73.65) 130.99,73.83 130.99,73.83 arc(130.91,74.11) 130.99,74.38 130.99,74.39 arc(131.04,74.57) 130.99,74.75 130.98,74.76 arc(130.91,75.03) 130.99,75.3 arc(131.04,75.49) 130.99,75.67 130.98,75.68 arc(130.91,75.95) 130.99,76.22 130.99,76.23 arc(131.04,76.41) 130.99,76.59 arc(130.91,76.86) 130.98,77.13 130.99,77.14 arc(131.04,77.33) 130.99,77.51 130.99,77.52 arc(130.91,77.79) 130.99,78.06 arc(131.04,78.25) 130.99,78.43 arc(130.93,78.57) 130.91,78.71 130.91,78.95 130.41,79.46 130.4,79.46 130.39,79.47
  L05_SIG2 w0.081: 130.39,79.47 130.09,79.77 130.09,83.23 129.31,84.02 129.31,86.54 129.6,86.83 129.6,90.33 132.27,93 132.27,96.38 132.48,96.58 132.48,98.29 132.75,98.56 133.49,98.56 133.7,98.36 133.7,95.78 133.8,95.67 133.95,95.67 134.03,95.76 134.03,96.71 134.22,96.89 135.38,96.89 135.46,96.98 135.46,97.15 135.38,97.23 134.22,97.23 134.03,97.42 134.03,98.02 134.22,98.21 135.28,98.21 136.04,98.97 137.84,98.97 138.03,98.79 138.03,98.07 138.11,97.99 138.29,97.99 138.37,98.07 138.37,98.79 138.56,98.97 141.98,98.97 142,98.99 142.48,98.99 142.5,98.97 144.3,98.97 144.57,99.24 144.57,99.62 144.38,99.8 137.67,99.8 137.59,99.72 137.59,99.53 137.4,99.34 137.07,99.34 136.89,99.53 136.89,99.72 136.8,99.8 136.63,99.8 136.55,99.72 136.55,99.53 136.36,99.34 136.04,99.34 135.85,99.53 135.85,99.72 135.77,99.8 135.6,99.8 135.51,99.72 135.51,99.53 135.33,99.34 135,99.34 134.81,99.53 134.81,99.72 134.73,99.8 133.58,99.8 133.23,100.16 133.23,100.63 v1(132.89,100.96)
DDR4_DDIMM_CK_P0: length 72.1
  L05_SIG2 w0.076: 128.47,79.3 128.52,79.24 128.52,79.24 128.82,78.94 128.82,78.61 arc(128.79,78.52) 128.75,78.44 arc(128.7,78.25) 128.75,78.06 128.75,78.06 arc(128.82,77.79) 128.75,77.52 128.75,77.51 arc(128.7,77.33) 128.75,77.14 arc(128.82,76.88) 128.76,76.61 128.74,76.59 arc(128.7,76.4) 128.75,76.22 arc(128.82,75.95) 128.75,75.68 128.75,75.67 arc(128.7,75.49) 128.75,75.31 128.75,75.3 arc(128.82,75.03) 128.75,74.76 128.74,74.75 arc(128.7,74.56) 128.75,74.38 arc(128.75,73.84) 128.28,73.56 128.27,73.56 arc(127.95,73.38) 127.95,73.01 127.96,73 arc(128.03,72.73) 127.95,72.45 127.95,72.45 arc(127.75,72.25) 127.48,72.18 127.46,72.18 arc(127.2,72.26) 127,72.45 arc(126.87,72.59) 126.69,72.64 126.68,72.64 arc(126.51,72.61) 126.36,72.51 arc(126.35,72.5) 126.34,72.49 arc(126.26,72.37) 126.16,72.29 arc(126.11,72.25) 126.06,72.21 125.92,72.06 arc(125.54,71.81) 125.09,71.72 arc(124.82,71.79) 124.62,71.98 124.6,72.01 arc(124.47,72.13) 124.29,72.18 124.27,72.18 arc(124.01,72.26) 123.81,72.45 arc(123.68,72.59) 123.5,72.64 123.49,72.64 arc(123.22,72.71) 123.03,72.9 123.01,72.93 arc(122.94,73.2) 123.02,73.46 arc(123.07,73.62) 123.04,73.78 122.97,73.8 v1(122.7,73.65)
  L05_SIG2 w0.081: 128.47,79.3 128.03,79.73 128.03,80.99 127.41,82.53 127.41,83.88 127.08,84.21 127.08,90.01 130.12,93.05 130.12,97.79 129.8,98.11 129.8,102.74 129.95,102.89 132.9,102.89 133.42,103.4 136.62,103.4 136.7,103.32 136.7,102.66 136.89,102.47 137.21,102.47 137.4,102.66 137.4,103.32 137.48,103.4 137.66,103.4 137.74,103.32 137.74,102.66 137.93,102.47 138.25,102.47 138.44,102.66 138.44,103.32 138.52,103.4 138.69,103.4 138.77,103.32 138.77,102.66 138.96,102.47 139.29,102.47 139.47,102.66 139.47,103.32 139.56,103.4 140.99,103.4 141.19,103.6 141.19,104.49 141,104.68 139.53,104.68 139.44,104.76 139.44,105.18 139.26,105.37 138.93,105.37 138.74,105.18 138.74,104.76 138.66,104.68 138.49,104.68 138.41,104.76 138.41,105.18 138.22,105.37 137.9,105.37 137.71,105.18 137.71,104.76 137.63,104.68 137.45,104.68 137.37,104.76 137.37,105.18 137.18,105.37 136.86,105.37 136.67,105.18 136.67,104.76 136.59,104.68 136.42,104.68 136.34,104.76 136.34,105.18 136.15,105.37 135.82,105.37 135.63,105.18 135.63,104.76 135.41,104.53 133.78,104.53 133.41,104.91 133.41,106.63 v1(133.74,106.96)
DDR4_DDIMM_CK_P1: length 69.4
  L05_SIG2 w0.076: v1(128.27,70.45) 128,70.3 arc(127.99,70.29) 127.98,70.29 127.92,70.31 127.91,70.33 arc(127.89,70.39) 127.89,70.45 arc(127.9,70.55) 127.94,70.65 arc(128.03,70.78) 128.14,70.9 arc(128.49,71.12) 128.89,71.21 129.04,71.22 arc(129.19,71.25) 129.33,71.32 arc(129.33,71.33) 129.34,71.33 arc(129.47,71.44) 129.56,71.58 arc(129.57,71.58) 129.58,71.59 arc(129.66,71.67) 129.76,71.7 arc(129.78,71.71) 129.8,71.71 arc(129.83,71.71) 129.86,71.72 arc(129.9,71.72) 129.94,71.71 arc(130.17,71.75) 130.32,71.93 arc(130.34,71.97) 130.36,72.02 130.36,72.02 arc(130.36,72.02) 130.37,72.02 arc(130.49,72.14) 130.66,72.18 arc(130.77,72.19) 130.87,72.22 130.87,72.23 arc(131.16,72.5) 131.18,72.9 131.18,72.9 arc(131.18,72.91) 131.17,72.93 arc(131.16,72.97) 131.14,73.01 arc(131.14,73.01) 131.14,73.01 arc(131.1,73.1) 131.09,73.19 arc(131.09,73.24) 131.11,73.3 arc(131.12,73.34) 131.14,73.37 arc(131.21,73.65) 131.14,73.92 131.14,73.92 arc(131.09,74.11) 131.14,74.29 131.14,74.3 arc(131.21,74.57) 131.14,74.84 131.14,74.85 arc(131.09,75.03) 131.14,75.21 arc(131.21,75.48) 131.14,75.76 131.14,75.77 arc(131.09,75.95) 131.14,76.13 131.14,76.14 arc(131.21,76.41) 131.14,76.68 arc(131.09,76.86) 131.13,77.04 131.14,77.05 arc(131.21,77.33) 131.14,77.6 131.14,77.6 arc(131.09,77.79) 131.14,77.97 131.14,77.98 arc(131.21,78.25) 131.14,78.52 arc(131.1,78.61) 131.09,78.71 131.09,79.03 130.53,79.59 130.53,79.59 130.52,79.6
  L05_SIG2 w0.081: 130.52,79.6 130.27,79.85 130.27,83.31 129.49,84.09 129.49,86.46 129.78,86.76 129.78,90.25 132.45,92.93 132.45,96.3 132.66,96.51 132.66,98.21 132.83,98.38 133.42,98.38 133.51,98.28 133.51,95.71 133.73,95.49 134.03,95.49 134.21,95.68 134.21,96.63 134.3,96.71 135.45,96.71 135.64,96.9 135.64,97.22 135.45,97.41 134.3,97.41 134.21,97.49 134.21,97.95 134.3,98.03 135.35,98.03 136.12,98.79 137.77,98.79 137.85,98.71 137.85,98 138.04,97.81 138.36,97.81 138.55,98 138.55,98.71 138.63,98.79 142.06,98.79 142.08,98.81 142.41,98.81 142.43,98.79 144.38,98.79 144.75,99.16 144.75,99.69 144.46,99.98 137.59,99.98 137.4,99.8 137.4,99.6 137.32,99.52 137.15,99.52 137.07,99.6 137.07,99.8 136.88,99.98 136.56,99.98 136.37,99.8 136.37,99.6 136.29,99.52 136.11,99.52 136.03,99.6 136.03,99.8 135.84,99.98 135.52,99.98 135.33,99.8 135.33,99.6 135.25,99.52 135.08,99.52 135,99.6 135,99.8 134.81,99.98 133.66,99.98 133.41,100.23 133.41,100.63 v1(133.74,100.96)
DDR4_DDIMM_CKE0: length 73.9
  L03_SIG1 w0.081: v1(121.9,72.27) 121.9,72.46 122.72,73.28 122.85,73.28 122.85,73.28 123.11,73.28 123.49,73.66 123.6,73.74 123.65,73.74 123.78,73.88 124.22,74.2 124.44,74.2 124.66,74.42 124.66,74.42 124.98,74.66 125.35,74.66 126.02,75.16 126.26,75.39 126.26,81.16 125.67,81.75 125.67,82.49 126.16,82.98 126.16,83.8 126.29,83.93 126.29,85.94 126.37,86.02 126.73,86.02 126.81,86.11 126.81,86.28 126.73,86.36 126.37,86.36 126.29,86.44 126.29,87.23 126.43,87.37 126.55,87.37 127.14,86.78 127.29,86.78 127.41,86.9 127.41,87.02 126.86,87.58 126.86,87.79 126.96,87.9 127.08,87.9 127.64,87.34 127.79,87.34 127.91,87.46 127.91,87.58 127.33,88.15 127.33,88.27 127.45,88.39 127.57,88.39 128.02,87.94 128.13,87.94 128.25,88.06 128.25,88.18 127.8,88.63 127.8,88.74 133.37,94.31 133.37,94.82 134.26,95.71 134.73,95.71 134.75,95.69 135.02,95.69 135.1,95.61 135.1,95.24 135.18,95.15 135.35,95.15 135.43,95.24 135.43,95.61 135.51,95.69 136.1,95.69 136.12,95.71 136.6,95.71 136.68,95.63 136.68,95.21 136.76,95.13 136.94,95.13 137.02,95.21 137.02,95.63 137.1,95.71 137.27,95.71 137.35,95.63 137.35,95.21 137.43,95.13 137.61,95.13 137.69,95.21 137.69,95.63 137.77,95.71 137.94,95.71 138.02,95.63 138.02,95.21 138.1,95.13 138.28,95.13 138.36,95.21 138.36,95.63 138.44,95.71 139.13,95.71 139.21,95.63 139.21,95.19 139.29,95.11 139.46,95.11 139.54,95.19 139.54,95.63 139.63,95.71 139.8,95.71 139.88,95.63 139.88,95.19 139.96,95.11 140.13,95.11 140.21,95.19 140.21,95.63 140.3,95.71 140.97,95.71 145.28,100.02 145.28,100.56 146.09,101.37 146.09,102.75 146.17,102.84 147.89,102.84 147.97,102.92 147.97,103.09 147.89,103.17 146.17,103.17 146.09,103.25 146.09,103.42 146.17,103.51 147.89,103.51 147.97,103.59 147.97,103.76 147.89,103.84 147.38,103.84 147.3,103.92 147.3,106.34 147.22,106.42 147.04,106.42 146.96,106.34 146.96,103.92 146.88,103.84 146.17,103.84 146.09,103.92 146.09,106.44 v1(145.57,106.96)
DDR4_DDIMM_CKE1: length 75.4
  L03_SIG1 w0.081: v1(121.1,72.73) 121.1,72.54 121.75,71.9 122.31,71.9 122.56,72.14 122.65,72.14 123.14,72.64 123.68,72.64 124.31,73.27 124.7,73.27 124.95,73.52 125.23,73.52 125.91,74.2 126.04,74.2 126.5,74.66 126.83,74.66 127.05,74.88 127.05,80.7 126.85,80.9 126.85,81.43 126.77,81.51 126.29,81.51 126.21,81.59 126.21,81.77 126.29,81.85 126.77,81.85 126.85,81.93 126.85,82.13 126.39,82.59 126.39,83.7 126.52,83.83 126.52,85.39 128.7,87.57 128.7,89.08 129.26,89.64 129.38,89.64 130.06,88.96 130.18,88.96 130.3,89.08 130.3,89.2 129.61,89.88 129.61,90 129.74,90.12 129.85,90.12 130.54,89.43 130.65,89.43 130.77,89.56 130.77,89.67 130.09,90.35 130.09,90.47 130.21,90.59 130.33,90.59 131.01,89.91 131.12,89.91 131.25,90.03 131.25,90.15 130.56,90.83 130.56,90.94 130.69,91.07 130.8,91.07 131.48,90.38 131.6,90.38 131.72,90.5 131.72,90.62 131.04,91.3 131.04,91.42 131.16,91.54 131.27,91.54 131.96,90.86 132.07,90.86 132.19,90.98 132.19,91.09 131.51,91.78 131.51,91.89 131.63,92.01 131.75,92.01 132.43,91.33 132.55,91.33 132.67,91.45 132.67,91.57 131.99,92.25 131.99,92.37 132.11,92.49 132.22,92.49 132.91,91.81 133.02,91.81 133.14,91.93 133.14,92.04 132.46,92.73 132.46,92.84 132.58,92.96 132.7,92.96 133.38,92.28 133.49,92.28 133.62,92.4 133.62,92.52 132.93,93.2 132.93,93.31 133.06,93.44 133.17,93.44 133.85,92.75 133.97,92.75 134.09,92.88 134.09,92.99 133.41,93.67 133.41,93.79 133.66,94.04 133.78,94.04 134.2,93.62 134.31,93.62 134.44,93.74 134.44,93.86 134.01,94.28 134.01,94.39 134.2,94.58 134.2,94.59 134.43,94.82 136.79,94.82 136.87,94.74 136.87,94.62 136.95,94.54 137.12,94.54 137.2,94.62 137.2,94.74 137.29,94.82 140.53,94.82 141,95.3 141.46,95.3 143.2,97.04 143.2,97.53 143.58,97.91 143.84,97.91 143.91,97.84 144.02,97.84 144.15,97.96 144.15,98.08 144,98.22 144,98.34 144.73,99.07 144.84,99.07 145.37,98.54 145.49,98.54 145.61,98.66 145.61,98.77 145.08,99.3 145.08,99.42 145.42,99.76 145.86,99.76 146.2,99.43 146.42,99.43 146.95,99.96 146.95,102.29 146.87,102.37 146.6,102.37 146.49,102.27 v1(146.49,100.96)
  BOTTOM w0.149: R104.2 146.57,101.04 v1(146.49,100.96)
DDR4_DDIMM_CS_N0: length 71.2
  L03_SIG1 w0.081: v1(120.14,106.41) 120.14,105.22 120.06,105.14 118.63,105.14 118.55,105.06 118.55,104.89 118.64,104.81 120.06,104.81 120.14,104.73 120.14,104.55 120.06,104.47 118.63,104.47 118.55,104.39 118.55,104.22 118.64,104.14 120.06,104.14 120.14,104.06 120.14,103.88 120.06,103.8 118.85,103.8 118.77,103.72 118.77,103.55 118.86,103.47 120.06,103.47 120.14,103.39 120.14,103.21 120.06,103.13 119.19,103.13 119.11,103.05 119.11,102.88 119.19,102.8 120.06,102.8 120.14,102.72 120.14,101.97 119.03,100.86 119.03,99.03 117.82,97.81 117.82,96.26 118.9,95.18 118.9,94.26 119.03,94.12 119.03,92.61 118.33,91.91 118.33,91.71 118.41,91.63 119.33,91.63 119.41,91.55 119.41,91.37 119.33,91.29 117.49,91.29 117.4,91.2 117.4,91.04 117.48,90.96 119.33,90.96 119.41,90.88 119.41,90.7 119.33,90.62 118.07,90.62 117.99,90.54 117.99,90.37 118.08,90.29 119.33,90.29 119.41,90.2 119.41,90.03 119.33,89.95 118.41,89.95 118.33,89.87 118.33,89.7 118.41,89.62 119.33,89.62 119.41,89.53 119.41,89.36 119.33,89.28 118.41,89.28 118.33,89.2 118.33,89.03 118.41,88.94 119.33,88.94 119.41,88.86 119.41,88.69 119.33,88.61 118.41,88.61 118.33,88.53 118.33,88.36 118.41,88.27 119.33,88.27 119.41,88.19 119.41,88.02 119.33,87.94 118.02,87.94 117.94,87.86 117.94,87.7 118.03,87.6 119.33,87.6 119.41,87.52 119.41,87.35 119.33,87.27 118.02,87.27 117.94,87.19 117.94,87.03 118.03,86.93 119.33,86.93 119.41,86.85 119.41,86.68 119.33,86.6 118.41,86.6 118.33,86.52 118.33,84.71 118.41,84.63 119.26,84.63 119.34,84.55 119.34,84.38 119.26,84.3 118.44,84.3 118.36,84.21 118.36,83.24 117.49,82.38 117.49,74.88 117.49,74.87 117.49,72.59 117.93,72.14 118.31,72.14 118.56,71.9 118.87,71.9 119.11,72.14 120.18,72.14 v1(120.31,72.27)
DDR4_DDIMM_CS_N1: length 72.2
  L05_SIG2 w0.081: v1(123.49,72.27) 122.68,72.27 arc(122.46,72.33) 122.3,72.5 122.16,72.57 121.9,72.73 arc(121.68,72.79) 121.51,72.95 121.49,72.97 arc(121.33,73.13) 121.1,73.19 121.1,73.19 arc(120.87,73.25) 120.7,73.42 arc(120.54,73.59) 120.31,73.65 120.31,73.65 arc(120.08,73.71) 119.91,73.87 119.91,73.88 arc(119.74,74.05) 119.51,74.11 119.49,74.11 arc(119.32,74.08) 119.17,73.98 118.95,73.75 arc(118.72,73.66) 118.48,73.75 118.27,73.96 arc(118.11,74.07) 117.92,74.11 117.9,74.11 arc(117.68,74.18) 117.52,74.34 arc(117.36,74.5) 117.14,74.57 117.11,74.57 arc(116.89,74.63) 116.72,74.8 arc(116.55,74.97) 116.33,75.03 116.32,75.03 arc(116.09,75.09) 115.93,75.25 115.92,75.27 arc(115.75,75.43) 115.52,75.49 arc(115.3,75.55) 115.14,75.7 115.12,75.74 arc(114.95,75.89) 114.73,75.95 114.71,75.95 arc(114.49,76.02) 114.33,76.18 114.29,76.21 114.29,76.71 114.3,76.72 114.3,77.02 114.29,77.03 114.29,77.42 114.58,77.7 114.83,77.7 115.1,77.97 115.1,78.4 115.06,78.44 115.06,80.94 114.82,81.18 114.82,82.83 114.24,83.41 114.24,86.37 114.65,86.78 115.44,86.78 116.35,87.69 116.35,89.99 115.68,90.66 114.57,90.66 114.22,91.01 111.47,91.01 110.34,92.14 110.34,93.56 109.75,94.15 109.75,96.98 109.96,97.2 111.47,97.2 111.83,96.84 112.17,96.84 112.25,96.92 112.25,97.58 111.96,97.87 111.48,97.87 111.24,98.11 105.58,98.11 105.27,98.42 104.6,98.42 103.19,99.82 103.19,100.86 103.51,101.18 103.51,106.79 104.17,107.45 115.4,107.45 v1(115.89,106.96)
DDR4_DDIMM_CS_N2: length 64.2
  L03_SIG1 w0.081: v1(117.27,92.52) 117.27,92.53 117.27,93.39 116.9,93.75 116.9,93.87 117.19,94.15 117.19,94.27 117.07,94.39 116.95,94.39 116.66,94.1 116.55,94.1 116.35,94.31 116.35,94.65 116.43,94.73 117.11,94.73 117.19,94.81 117.19,94.99 117.11,95.07 116.43,95.07 116.35,95.15 116.35,95.32 116.43,95.4 117.11,95.4 117.19,95.48 117.19,95.66 117.11,95.74 116.43,95.74 116.35,95.82 116.35,96.3 116.43,96.38 116.82,96.38 116.9,96.47 116.9,96.64 116.82,96.72 116.43,96.72 116.35,96.8 116.35,96.97 116.43,97.06 116.82,97.06 116.9,97.14 116.9,97.31 116.82,97.39 116.43,97.39 116.35,97.47 116.35,98.66 116.49,98.8 116.81,98.8 116.89,98.88 116.89,99.06 116.81,99.14 116.49,99.14 116.41,99.22 116.41,99.39 116.49,99.47 116.81,99.47 116.89,99.56 116.89,99.73 116.81,99.81 116.49,99.81 116.41,99.89 116.41,100.06 116.49,100.14 116.81,100.14 116.89,100.23 116.89,100.4 116.81,100.48 116.49,100.48 116.41,100.56 116.41,100.78 116.37,100.81 116.37,101.36 116.45,101.44 116.81,101.44 116.89,101.52 116.89,101.69 116.81,101.77 116.45,101.77 116.37,101.86 116.37,102.03 116.45,102.11 116.81,102.11 116.89,102.19 116.89,102.36 116.81,102.44 116.27,102.44 116.07,102.65 116.07,102.99 116.63,103.55 116.63,103.67 116.51,103.79 116.39,103.79 115.84,103.23 115.72,103.23 115.6,103.35 115.6,103.47 116.16,104.03 116.16,104.14 116.03,104.26 115.92,104.26 115.36,103.71 115.25,103.71 115.12,103.83 115.12,103.94 115.68,104.5 115.68,104.62 115.56,104.74 115.45,104.74 114.89,104.18 114.34,104.18 113.86,104.66 113.86,104.89 113.54,105.21 112.83,105.21 112.68,105.36 112.08,105.36 111.8,105.09 v1(111.8,104.76)
  L14_SIG5 w0.081: v1(125.02,89.37) 123.68,90.71 119.12,90.71 117.32,92.52 117.27,92.52 117.27,92.52 v1(117.27,92.52)
  BOTTOM w0.149: v1(126.68,70.43) 126.32,70.78 126.32,72.07 126.14,72.26 126.14,72.43 126.28,72.57 126.28,72.89 126.14,73.03 126.14,73.35 126.28,73.49 126.28,73.81 126.14,73.95 126.14,74.27 126.28,74.41 126.28,74.73 126.14,74.87 126.14,75.17 126.29,75.32 126.29,75.66 126.16,75.79 126.16,76.13 126.28,76.25 126.28,76.57 126.16,76.69 126.16,77.05 126.28,77.17 126.28,77.49 126.16,77.61 126.16,77.97 126.28,78.09 126.28,78.48 126.21,78.54 126.21,78.85 126.35,78.99 126.35,79.32 126.22,79.45 126.22,79.86 126.33,79.96 126.33,80.22 126.23,80.32 126.23,80.78 126.33,80.89 126.33,81.31 126.07,81.57 125.52,81.57 125.27,81.82 125.27,83.5 124.89,83.88 123.46,83.88 123.31,84.03 123.31,86.08 125.02,87.79 v1(125.02,89.37)
DDR4_DDIMM_CS_N3: length 51.7
  TOP w0.149: v1(126.82,83.58) 123.9,83.58 v1(122.61,82.29)
  L03_SIG1 w0.081: v1(116.83,92.03) 116.83,92.03 116.28,91.48 116.21,91.48 116.17,91.45 114.67,91.45 113.8,92.32 113.8,94.53 113.74,94.59 113.74,97.96 113.74,97.96 113.74,98.29 113.74,98.3 113.74,101.25 113,101.98 113,102.53 v1(112.49,103.04)
  L07_SIG3 w0.089: v1(126.82,83.58) 127.35,83.05 127.35,83.03 127.82,82.57 arc(127.84,82.53) 127.85,82.49 127.85,82.34 arc(127.86,82.29) 127.89,82.26 128.62,81.53 arc(128.64,81.49) 128.65,81.45 128.65,71.62 arc(128.64,71.58) 128.62,71.54 127.66,70.59 arc(127.62,70.56) 127.58,70.55 127.13,70.55 arc(127.09,70.56) 127.05,70.59 126.87,70.77 arc(126.83,70.79) 126.79,70.8 126.57,70.8 arc(126.53,70.79) 126.49,70.77 125.92,70.2 arc(125.88,70.13) 125.86,70.06 v1(125.86,70)
  L14_SIG5 w0.081: v1(126.82,83.58) 126.62,83.58 126.37,83.83 126.37,87.42 123.58,90.21 118.66,90.21 v1(116.83,92.03)
DDR4_DDIMM_DBI_N0: length 101.6
  L03_SIG1 w0.081: v2(137.02,77.32) 136.79,77.19 136.66,77.22 136.43,77.45 136.04,77.45 135.65,77.05 135.65,76.64 136.25,76.03 136.67,76.03 137.19,75.5 137.7,75.5 138.12,75.08 138.45,75.08 138.76,74.78 138.76,74.68 138.99,74.45 139.4,74.45 139.76,74.08 140.28,74.08 140.69,74.5 141.12,74.5 141.57,74.05 142.05,74.05 142.48,74.48 142.84,74.48 143.36,73.97 143.67,73.97 143.92,73.72 160.6,73.72 161.51,74.63 161.51,74.89 160.8,75.6 160.8,75.72 160.92,75.84 161.03,75.84 161.74,75.13 162.01,75.13 162.24,75.36 162.24,75.63 161.53,76.34 161.53,76.45 161.65,76.57 161.77,76.57 162.48,75.86 162.74,75.86 162.97,76.09 162.97,76.36 162.26,77.07 162.26,77.18 162.38,77.31 162.5,77.31 163.21,76.6 163.47,76.6 163.7,76.83 163.7,77.09 163,77.8 163,77.92 163.12,78.04 163.23,78.04 163.94,77.33 164.21,77.33 167.23,80.35 168.65,80.35 169,80.71 169,81.16 168.74,81.42 168.14,81.42 168.06,81.5 168.06,81.67 168.14,81.75 168.39,81.75 168.58,81.94 168.58,82.26 168.39,82.45 168.14,82.45 168.06,82.53 168.06,82.71 168.14,82.79 168.39,82.79 168.58,82.98 168.58,85.03 171.08,87.53 171.19,87.53 171.68,87.04 171.94,87.04 172.17,87.27 172.17,87.54 171.59,88.12 171.59,88.64 172.97,90.01 175.48,90.01 175.63,89.85 175.63,88.85 175.82,88.66 176.14,88.66 176.33,88.85 176.33,89.48 176.41,89.57 176.59,89.57 176.67,89.48 176.67,88.85 176.86,88.66 177.34,88.66 177.89,89.21 177.89,91.23 179.46,92.79 180.85,92.79 181.2,93.15 181.2,94.03 181.01,94.22 181.01,94.86 181.8,95.65 182.9,95.65 183.51,96.26 183.83,96.26 183.92,96.18 183.92,95.84 184.1,95.65 184.43,95.65 184.62,95.84 184.62,96.18 184.7,96.26 187.21,96.26 187.29,96.18 187.29,95.77 187.48,95.58 187.8,95.58 187.99,95.77 187.99,96.18 188.07,96.26 189.58,96.26 190.9,97.59 190.9,98.72 191.77,99.59 191.77,100.15 191.4,100.51 191.4,101.84 190.36,102.89 190.36,105.23 v1(190.69,105.57)
DDR4_DDIMM_DBI_N1: length 75.8
  L05_SIG2 w0.081: v1(181.34,105.57) 181.01,105.23 181.01,104.92 181.16,104.77 181.16,104.58 181.01,104.43 181.01,104.25 181.16,104.1 181.16,103.91 181.01,103.76 181.01,102.98 180.8,102.77 180.8,101.57 181.14,101.23 181.14,99.15 178.25,96.26 177.37,96.26 176.95,95.83 173.67,95.83 173.51,96 173.2,96 173.03,95.83 171.97,95.83 171.36,95.22 163.68,95.22 158.9,90.44 157.24,90.44 157.05,90.63 157.05,91.64 156.97,91.72 156.8,91.72 156.72,91.64 156.72,90.63 156.53,90.44 156.2,90.44 156.01,90.63 156.01,91.64 155.93,91.72 155.76,91.72 155.68,91.64 155.68,90.63 155.49,90.44 155.17,90.44 154.98,90.63 154.98,91.64 154.9,91.72 154.72,91.72 154.64,91.64 154.64,90.63 154.45,90.44 136.26,90.44 arc(135.74,90.34) 135.3,90.04 134.39,89.13 arc(134.09,88.69) 133.99,88.17 133.99,84.6 arc(134,84.56) 134.02,84.53 134.38,83.99 arc(134.4,83.94) 134.43,83.9 134.56,83.62 arc(134.68,83.34) 134.72,83.03 134.72,82.67 arc(134.77,82.45) 134.89,82.27 134.97,82.19 arc(135.04,82.08) 135.07,81.95 135.07,80.99 arc(135.07,80.95) 135.08,80.91 arc(135.1,80.84) 135.12,80.78 arc(135.14,80.74) 135.16,80.69 arc(135.16,80.67) 135.17,80.65 arc(135.19,80.38) 135.06,80.14 arc(134.9,80.03) 134.72,80 134.65,80 arc(134.55,79.98) 134.46,79.95 arc(134.42,79.92) 134.38,79.88 arc(134.35,79.85) 134.33,79.82 arc(134.29,79.76) 134.25,79.71 arc(134.22,79.66) 134.24,79.6 arc(134.26,79.56) 134.28,79.51 arc(134.29,79.52) 134.29,79.52 arc(134.34,79.48) 134.4,79.49 v1(134.65,79.63)
DDR4_DDIMM_DBI_N2: length 55.2
  L16_SIG6 w0.076: v1(141.82,77.33) 141.55,77.17 141.47,77.19 arc(141.45,77.36) 141.5,77.51 141.5,77.52 arc(141.63,77.65) 141.81,77.7 141.82,77.7 arc(142.09,77.77) 142.29,77.97 142.32,78.01 arc(142.39,78.27) 142.32,78.53 arc(142.3,78.57) 142.27,78.6 arc(142.09,78.75) 141.86,78.8 arc(141.75,78.82) 141.65,78.87 arc(141.64,78.88) 141.63,78.88 arc(141.59,78.92) 141.55,78.96 arc(141.54,78.97) 141.53,78.98 arc(141.51,79) 141.5,79.02 141.44,79.08 arc(141.4,79.18) 141.44,79.28 141.81,79.65
  L16_SIG6 w0.081: v1(171.99,105.57) 171.63,105.21 171.63,104.92 171.79,104.77 171.79,104.58 171.63,104.43 171.63,101.39 171.79,101.23 171.79,99.99 171.52,99.72 170.99,99.72 170.77,99.5 170.77,99 170.85,98.92 171.49,98.92 171.68,98.73 171.68,98.41 171.49,98.22 170.85,98.22 170.77,98.14 170.77,97.97 170.85,97.89 171.49,97.89 171.68,97.7 171.68,97.37 171.49,97.19 170.85,97.19 170.77,97.1 170.77,96.64 170.41,96.28 169.54,96.28 169.36,96.1 169.36,94.86 165.71,91.21 163.16,91.21 161.08,89.14 148.96,89.14 145.1,85.28 145.1,83.51 142.28,80.69 142.28,80.12 141.81,79.65
DDR4_DDIMM_DBI_N3: length 45.5
  L03_SIG1 w0.081: v1(162.64,105.57) 162.62,105.57 arc(162.42,105.48) 162.34,105.29 162.34,105.18 arc(162.22,104.91) 161.95,104.79 160.71,104.79 160.48,104.76 160.04,104.51 159.29,103.76 arc(159.14,103.53) 159.08,103.26 159.08,101.08 arc(159.06,100.91) 158.99,100.76 arc(158.92,100.6) 158.89,100.44 158.89,98.44 arc(158.91,98.39) 158.94,98.34 159.1,98.18 arc(159.38,97.76) 159.48,97.27 arc(159.47,97.22) 159.47,97.16 arc(159.21,96.16) 158.75,95.24 arc(158.48,94.79) 158.27,94.31 158.19,94.09 arc(158.14,93.99) 158.07,93.9 156.87,92.7 arc(156.7,92.58) 156.5,92.51 arc(156.3,92.44) 156.13,92.32 153.27,89.45 arc(152.72,89.08) 152.08,88.96 151.07,88.96 150.88,89.14 150.88,89.37 150.8,89.45 150.63,89.45 150.55,89.37 150.55,89.14 150.36,88.96 150.04,88.96 149.85,89.14 149.85,89.37 149.77,89.45 149.59,89.45 149.51,89.37 149.51,89.14 149.32,88.96 149,88.96 148.81,89.14 148.81,89.37 148.73,89.45 148.56,89.45 148.48,89.37 148.48,89.14 148.29,88.96 147.54,88.96 arc(147.5,88.95) 147.46,88.93 arc(147.43,88.91) 147.4,88.88 144.76,86.24 arc(144.61,86.01) 144.55,85.74 144.55,84.61 arc(144.52,84.42) 144.41,84.26 143.55,83.4 arc(143,83.03) 142.36,82.91 140.46,82.91 arc(139.55,82.75) 138.75,82.28 arc(138.6,82.18) 138.43,82.12 arc(138.23,82) 138.11,81.79 arc(138.11,81.75) 138.1,81.71 138.1,80.21 arc(138.12,80.15) 138.15,80.1 138.42,79.83 138.76,79.83 138.98,79.64 138.98,79.64 139.03,79.6 139.04,79.57 139.07,79.52 arc(139.07,79.52) 139.07,79.51 arc(139.12,79.48) 139.18,79.49 v2(139.43,79.63)
DDR4_DDIMM_DBI_N4: length 68.3
  L14_SIG5 w0.076: 133.26,82.04 133.24,82.03 133.24,82.03 133.18,81.98 arc(133.02,81.73) 132.96,81.43 132.96,81.14 arc(132.95,81.04) 132.91,80.94 132.76,80.77 arc(132.68,80.6) 132.7,80.41 132.79,80.24 arc(132.81,80.16) 132.82,80.08 arc(132.81,80.02) 132.8,79.97 arc(132.79,79.91) 132.76,79.86 132.72,79.81 arc(132.7,79.76) 132.68,79.71 132.68,79.65 arc(132.68,79.64) 132.68,79.63 132.69,79.53 arc(132.7,79.52) 132.7,79.51 132.75,79.42 132.75,79.41 arc(132.81,79.17) 132.75,78.92 132.72,78.88 arc(132.68,78.7) 132.73,78.52 arc(132.74,77.99) 132.28,77.7 132.24,77.7 arc(132.07,77.66) 131.95,77.53 131.94,77.52 arc(131.89,77.36) 131.91,77.19 131.99,77.17 v1(132.26,77.33)
  L14_SIG5 w0.081: 133.26,82.04 133.36,82.15 133.46,82.31 133.46,89.36 129.08,93.74 129.08,98.16 122.08,105.16 121.42,105.16 121.23,104.97 121.23,103.83 121.15,103.74 120.98,103.74 120.9,103.83 120.9,105.18 120.68,105.4 120.35,105.4 120.19,105.24 120.19,103.83 120.11,103.74 119.94,103.74 119.86,103.83 119.86,105.18 119.64,105.4 119.32,105.4 119.16,105.24 119.16,103.83 119.08,103.74 118.9,103.74 118.82,103.83 118.82,105.18 118.6,105.4 116.36,105.4 116.17,105.21 116.17,103.99 116.09,103.9 115.92,103.9 115.84,103.99 115.84,105.21 115.65,105.4 115.33,105.4 115.14,105.21 115.14,103.99 115.06,103.9 114.88,103.9 114.8,103.99 114.8,105.21 114.61,105.4 112.41,105.4 112.32,105.48 112.32,105.91 112.13,106.1 111.81,106.1 111.62,105.91 111.62,105.48 111.54,105.4 111.37,105.4 111.29,105.48 111.29,105.91 111.1,106.1 110.77,106.1 110.59,105.91 110.59,105.48 110.5,105.4 110.33,105.4 110.25,105.48 110.25,105.91 110.06,106.1 109.74,106.1 109.55,105.91 109.55,105.48 109.27,105.2 108.01,105.2 107.9,105.31 107.65,105.31 107.54,105.2 107.33,105.2 107.05,105.48 107.05,106.03 107.18,106.16 107.18,106.36 107.05,106.5 107.05,106.62 v1(107.39,106.96)
DDR4_DDIMM_DBI_N5: length 69.1
  L14_SIG5 w0.076: 125.92,81.65 125.94,81.65 125.94,81.65 126.17,81.65 arc(126.26,81.63) 126.34,81.6 arc(126.42,81.52) 126.47,81.42 126.49,81.34 arc(126.5,81.25) 126.51,81.16 arc(126.51,81.15) 126.51,81.15 arc(126.47,80.95) 126.38,80.76 arc(126.35,80.72) 126.33,80.68 arc(126.32,80.67) 126.32,80.66 arc(126.32,80.65) 126.31,80.65 126.3,80.59 arc(126.29,80.47) 126.34,80.35 arc(126.43,80.1) 126.37,79.84 126.35,79.8 arc(126.31,79.63) 126.35,79.46 126.38,79.42 126.4,79.36 arc(126.42,79.3) 126.43,79.24 126.43,78.99 126.4,78.97 arc(126.38,78.9) 126.34,78.85 126.34,78.57 126.36,78.55 126.36,78.53 126.36,78.52 arc(126.43,78.25) 126.36,77.98 arc(126.31,77.79) 126.36,77.6 126.37,77.59 arc(126.5,77.46) 126.68,77.42 126.7,77.42 arc(126.93,77.36) 127.11,77.21 arc(127.12,77.21) 127.12,77.2 127.21,77.17 v1(127.48,77.33)
  L14_SIG5 w0.081: v1(98.03,105.59) 97.71,105.27 97.71,104.97 97.85,104.83 97.85,104.63 97.71,104.49 97.71,104.3 97.81,104.2 97.81,103.93 97.71,103.82 97.71,102.9 97.39,102.58 96.35,102.58 96.15,102.39 96.15,101.51 95.94,101.29 95.94,99.92 96.94,98.92 96.94,97.63 98.74,95.84 98.74,91.92 99.32,91.34 99.97,91.34 100.06,91.43 100.06,92.31 100.25,92.49 100.57,92.49 100.76,92.31 100.76,91.45 100.87,91.34 101,91.34 101.09,91.43 101.09,92.31 101.28,92.49 101.61,92.49 101.79,92.31 101.79,91.45 101.91,91.34 103.07,91.34 103.17,91.43 103.17,92.31 103.35,92.49 103.68,92.49 103.87,92.31 103.87,91.45 103.98,91.34 104.11,91.34 104.2,91.43 104.2,92.31 104.39,92.49 104.72,92.49 104.9,92.31 104.9,91.45 105.02,91.34 105.15,91.34 105.24,91.43 105.24,92.31 105.43,92.49 105.75,92.49 105.94,92.31 105.94,91.45 106.05,91.34 107.9,91.34 107.98,91.42 107.98,92.28 108.2,92.49 108.51,92.49 108.7,92.31 108.7,91.45 108.81,91.34 109.28,91.34 110.09,92.14 111.06,92.14 111.85,91.35 114.84,91.35 117.28,88.91 123.1,88.91 123.84,88.16 123.84,84.37 125.24,82.98 125.24,82.19 125.78,81.65 125.92,81.65
DDR4_DDIMM_DBI_N6: length 84.9
  L16_SIG6 w0.076: 132.46,81.96 132.29,81.61 132.05,81.37 arc(132.01,81.32) 131.97,81.26 arc(131.9,81.13) 131.86,80.98 131.84,80.96 131.84,79.31 arc(131.84,79.27) 131.85,79.24 131.85,79.22 arc(131.88,79.12) 131.92,79.03 131.93,78.99 arc(131.95,78.96) 131.96,78.92 132.01,78.82 arc(132.03,78.74) 132.03,78.65 arc(132.02,78.62) 132.01,78.59 arc(131.99,78.52) 131.95,78.46 arc(131.93,78.43) 131.92,78.39 arc(131.89,78.23) 131.93,78.08 arc(132,77.79) 131.93,77.5 arc(131.89,77.31) 131.95,77.13 arc(132.02,76.91) 131.98,76.68 131.95,76.62 arc(131.9,76.41) 131.95,76.2 131.96,76.18 131.97,76.16 arc(131.96,75.65) 131.51,75.4 131.34,75.4 arc(131.3,75.39) 131.27,75.37 131.04,75.14 arc(131.02,75.1) 131.02,75.06 131.02,75.05 arc(131.03,75.03) 131.04,75.01 131.05,74.99 131.09,74.94 131.09,74.92 131.1,74.91 arc(131.15,74.87) 131.21,74.88 v1(131.46,75.03)
  L16_SIG6 w0.081: v1(88.69,105.64) 88.53,105.64 88.34,105.46 88.34,104.68 88.15,104.49 87.35,104.49 87.26,104.4 87.26,104.24 87.34,104.16 88.15,104.16 88.34,103.97 88.34,103.58 88.73,103.19 94.23,103.19 95.11,102.32 97.51,102.32 97.59,102.4 97.59,102.74 97.78,102.93 98.1,102.93 98.29,102.74 98.29,102.4 98.37,102.32 98.54,102.32 98.63,102.4 98.63,102.74 98.81,102.93 99.14,102.93 99.33,102.74 99.33,102.4 99.41,102.32 99.58,102.32 99.66,102.4 99.66,102.74 99.85,102.93 100.17,102.93 100.36,102.74 100.36,102.4 100.44,102.32 100.62,102.32 100.7,102.4 100.7,102.74 100.89,102.93 101.21,102.93 101.4,102.74 101.4,102.4 101.48,102.32 101.65,102.32 101.73,102.4 101.73,102.54 101.92,102.73 102.25,102.73 102.44,102.54 102.44,102.4 102.52,102.32 106.54,102.32 107.06,101.8 107.06,101.59 108.19,100.46 108.19,100.2 107.66,99.67 107.66,99.55 107.78,99.43 107.9,99.43 108.42,99.96 108.69,99.96 108.83,99.82 109.37,99.82 110.46,98.73 110.46,97.98 111.22,97.22 111.22,96.96 110.75,96.48 110.75,96.37 110.87,96.24 110.98,96.24 111.46,96.72 111.72,96.72 111.88,96.57 116.81,96.57 117,96.38 117,95.86 117.09,95.77 117.25,95.77 117.33,95.85 117.33,96.38 117.52,96.57 117.85,96.57 118.04,96.38 118.04,95.73 118.11,95.65 118.3,95.65 118.37,95.72 118.37,96.38 118.56,96.57 118.88,96.57 119.07,96.38 119.07,95.97 119.15,95.89 119.33,95.89 119.41,95.97 119.41,96.38 119.6,96.57 120.15,96.57 120.97,95.75 120.97,94.5 124.04,91.43 128.53,91.43 131.34,88.61 131.34,88.35 130.87,87.87 130.87,87.76 130.99,87.64 131.11,87.64 131.58,88.11 131.85,88.11 132.07,87.88 132.07,87.61 131.6,87.14 131.6,87.03 131.72,86.9 131.84,86.9 132.31,87.38 132.58,87.38 132.86,87.1 132.86,84.47 132.68,84.3 132.68,84.29 132.55,84.16 arc(132.53,84.12) 132.52,84.09 132.52,82.19 132.52,82.19 132.46,81.96
DDR4_DDIMM_DBI_N7: length 77.7
  L16_SIG6 w0.076: v1(126.68,75.03) 126.43,74.88 arc(126.37,74.87) 126.32,74.91 126.29,74.97 arc(126.27,75) 126.24,75.03 arc(126.09,75.12) 125.93,75.15 125.89,75.15 arc(125.71,75.11) 125.55,75.01 125.25,74.71 arc(125.08,74.64) 124.91,74.71 124.61,75.01 arc(124.45,75.11) 124.27,75.15 arc(124.17,75.17) 124.08,75.23 123.9,75.41 arc(123.71,75.54) 123.49,75.58 123.37,75.58 arc(123.35,75.58) 123.32,75.59 123.01,75.9 arc(122.89,75.98) 122.74,76.01 122.73,76.01 arc(122.69,76.01) 122.65,76.02 arc(122.62,76.03) 122.58,76.04 arc(122.58,76.04) 122.58,76.04 arc(122.5,76.08) 122.43,76.15 122.35,76.25 arc(122.33,76.29) 122.32,76.34 arc(122.32,76.37) 122.32,76.4 arc(122.32,76.45) 122.33,76.49 arc(122.34,76.53) 122.36,76.57 122.42,76.68 arc(122.47,76.89) 122.41,77.1 122.34,77.2 arc(122.31,77.32) 122.33,77.44 arc(122.34,77.44) 122.34,77.45 arc(122.36,77.48) 122.37,77.5 arc(122.38,77.52) 122.4,77.55 arc(122.42,77.57) 122.44,77.59 arc(122.45,77.6) 122.46,77.61 arc(122.48,77.64) 122.5,77.68 arc(122.52,77.84) 122.45,77.98 arc(122.35,78.13) 122.33,78.31 arc(122.34,78.33) 122.34,78.35 arc(122.35,78.39) 122.37,78.43 arc(122.44,78.65) 122.42,78.88 arc(122.41,78.9) 122.41,78.92 arc(122.39,78.96) 122.38,78.99 122.38,78.99 arc(122.33,79.18) 122.38,79.36 arc(122.45,79.63) 122.37,79.91 arc(122.35,79.95) 122.35,80 122.35,80.18 arc(122.35,80.23) 122.37,80.27 arc(122.4,80.33) 122.43,80.39 arc(122.45,80.52) 122.44,80.65 arc(122.43,80.72) 122.4,80.79 122.36,80.85 arc(122.34,80.88) 122.31,80.91 122.26,80.97 arc(122.21,81.04) 122.19,81.12 122.19,81.52
  L16_SIG6 w0.081: 122.19,81.52 122.19,81.78 arc(122.12,82.14) 121.91,82.45 121.88,82.49 arc(121.47,82.76) 120.99,82.86 109.03,82.86 108.71,83.19 105.73,83.19 arc(105.13,83.31) 104.62,83.65 95.48,92.78 85.07,92.78 arc(84.33,92.93) 83.7,93.35 83.27,93.78 arc(83.01,93.99) 82.7,94.12 arc(82.65,94.14) 82.6,94.16 82,94.41 arc(81.96,94.43) 81.93,94.45 81.77,94.61 arc(81.73,94.64) 81.69,94.68 arc(81.47,94.8) 81.24,94.87 arc(81.18,94.87) 81.13,94.88 arc(80.66,94.98) 80.26,95.25 75.38,100.13 arc(75.35,100.16) 75.33,100.19 arc(75.15,100.5) 75.07,100.84 arc(74.96,101.38) 74.66,101.84 74.51,101.98 arc(74.08,102.64) 73.92,103.42 73.92,105.43 arc(73.92,105.47) 73.91,105.51 arc(73.93,105.68) 74.02,105.82 arc(74.06,105.85) 74.09,105.88 arc(74.11,105.9) 74.12,105.92 74.27,106.07 arc(74.74,106.38) 75.29,106.49 76.01,106.49 arc(76.63,106.36) 77.16,106.01 77.44,105.74 77.56,105.64 77.59,105.62 77.62,105.59 77.66,105.58 77.69,105.57 77.76,105.55 78.49,105.55 arc(78.67,105.59) 78.81,105.68 78.9,105.77 arc(78.96,105.86) 78.98,105.96 78.98,106.08 79.16,106.26 v1(79.34,106.26)
DDR4_DDIMM_DBI_N8: length 45.6
  L03_SIG1 w0.076: 131.47,82.17 131.46,82.16 131.46,82.16 130.92,81.63 130.68,81.63 130.32,81.26 130.32,80.87 130.41,80.78 130.41,80.5 arc(130.41,80.44) 130.4,80.38 arc(130.37,80.31) 130.34,80.25 arc(130.3,80.19) 130.25,80.14 130.19,80.1 arc(130.15,80.07) 130.11,80.04 arc(130.09,80.03) 130.06,80.02 arc(130.02,80.02) 129.99,80.01 129.81,80.01 arc(129.72,80) 129.63,79.98 arc(129.59,79.96) 129.56,79.95 arc(129.52,79.93) 129.5,79.9 arc(129.45,79.82) 129.43,79.73 arc(129.43,79.69) 129.44,79.65 129.48,79.58 arc(129.5,79.54) 129.51,79.49 arc(129.58,79.46) 129.64,79.48 v2(129.89,79.62)
  L03_SIG1 w0.081: 131.47,82.17 131.53,82.23 131.53,83.48 133.06,85.01 133.06,87.83 134.65,89.43 135.28,89.43 136.33,90.47 142.11,90.47 142.11,90.47 143.06,90.47 150.01,97.42 150.4,97.42 151.12,98.14 151.12,98.63 151.44,98.95 151.64,98.95 153.09,100.4 153.09,101.25 152.84,101.5 152.84,102.51 152.66,102.7 151.99,102.7 151.91,102.78 151.91,102.95 151.99,103.03 152.93,103.03 153.12,103.22 153.12,103.54 152.93,103.73 151.97,103.73 151.88,103.81 151.88,103.99 151.97,104.07 152.66,104.07 152.91,104.32 152.91,105.44 153.03,105.57 v1(153.29,105.57)
DDR4_DDIMM_DQ0: length 98.8
  TOP w0.149: v1(192,104.81) 192.22,104.81 192.39,104.98 J2.5
  L03_SIG1 w0.081: v1(192,104.81) 192.63,104.81 192.8,104.98 192.8,105.28 192.69,105.4 192.09,105.4 192,105.49 192,105.79 192.05,105.84 193.57,105.84 193.65,105.93 193.65,106.44 193.51,106.58 191.39,106.58 191.21,106.4 191.21,105.17 191.52,104.86 191.52,103.1 192.22,102.39 192.22,101.76 192.76,101.21 192.76,97.81 191.41,96.46 190.9,96.46 189.21,94.76 187.01,94.76 186.59,95.18 186.13,95.18 185.74,94.8 183.07,94.8 182.24,93.96 182.24,91.17 181.99,90.92 179.57,90.92 179.24,90.59 179.24,89.37 177.62,87.75 176.34,87.75 176.14,87.55 176.14,84.61 176.29,84.46 176.29,81.28 173.75,78.74 166.76,78.74 160.91,72.89 150.7,72.89 150.69,72.88 144.93,72.88 144.19,72.14 143.21,72.14 142.79,72.57 142.48,72.57 arc(142.34,72.48) 142.23,72.35 142.23,72.35 arc(142.05,72.17) 141.8,72.1 141.79,72.1 arc(141.55,72.17) 141.36,72.35 arc(141.18,72.53) 140.93,72.6 140.93,72.6 arc(140.68,72.53) 140.5,72.35 140.5,72.35 arc(140.06,72.1) 139.63,72.35 139.63,72.35 arc(139.45,72.53) 139.2,72.6 139.19,72.6 arc(138.95,72.67) 138.77,72.85 138.76,72.85 arc(138.58,73.03) 138.33,73.1 arc(138.08,73.17) 137.9,73.35 137.9,73.35 arc(137.71,73.53) 137.47,73.6 137.46,73.6 arc(137.22,73.67) 137.03,73.85 137.03,73.86 arc(136.85,74.03) 136.6,74.1 arc(136.35,74.16) 136.17,74.34 136.17,74.35 arc(135.99,74.53) 135.74,74.6 135.73,74.6 arc(135.49,74.67) 135.3,74.85 135.3,74.85 arc(135.12,75.03) 134.87,75.1 134.86,75.1 arc(134.62,75.17) 134.44,75.35 134.42,75.62 134.42,76.39 134.15,76.66 134.15,76.99 134.46,77.31 135.37,77.31 v2(135.41,77.35)
DDR4_DDIMM_DQ1: length 98.8
  L03_SIG1 w0.081: v2(134.65,76.87) 135.14,76.38 135.14,76 135.49,75.64 135.73,75.56 135.93,75.56 arc(136.07,75.47) 136.17,75.35 arc(136.35,75.17) 136.6,75.1 136.61,75.1 arc(136.85,75.03) 137.03,74.85 137.04,74.85 arc(137.22,74.67) 137.47,74.6 137.47,74.6 arc(137.72,74.53) 137.9,74.35 137.9,74.34 arc(138.08,74.16) 138.33,74.1 arc(138.58,74.03) 138.76,73.86 138.77,73.85 arc(138.95,73.67) 139.2,73.6 139.2,73.6 arc(139.45,73.53) 139.63,73.35 139.63,73.34 arc(140.06,73.1) 140.5,73.34 140.5,73.35 arc(140.93,73.6) 141.36,73.35 141.37,73.35 arc(141.55,73.17) 141.8,73.1 arc(142.04,73.16) 142.23,73.34 142.23,73.35 arc(142.41,73.53) 142.66,73.6 142.82,73.6 143.28,73.14 144.71,73.14 144.79,73.22 150.55,73.22 150.56,73.23 160.77,73.23 166.64,79.09 167.58,79.09 167.66,79.17 167.66,79.77 167.74,79.86 167.92,79.86 168,79.77 168,79.17 168.08,79.09 168.25,79.09 168.33,79.17 168.33,79.77 168.42,79.86 168.59,79.86 168.67,79.77 168.67,79.17 168.75,79.09 168.92,79.09 169,79.17 169,79.77 169.09,79.86 169.26,79.86 169.34,79.77 169.34,79.17 169.42,79.09 169.59,79.09 169.67,79.17 169.67,79.77 169.76,79.86 169.93,79.86 170.01,79.77 170.01,79.17 170.09,79.09 170.26,79.09 170.35,79.17 170.35,79.77 170.43,79.86 170.6,79.86 170.68,79.77 170.68,79.17 170.76,79.09 170.93,79.09 171.02,79.17 171.02,79.77 171.1,79.86 171.27,79.86 171.35,79.77 171.35,79.17 171.43,79.09 171.61,79.09 171.69,79.17 171.69,79.77 171.77,79.86 171.94,79.86 172.02,79.77 172.02,79.17 172.1,79.09 172.28,79.09 172.36,79.17 172.36,79.77 172.44,79.86 172.61,79.86 172.69,79.77 172.69,79.17 172.77,79.09 172.95,79.09 173.03,79.17 173.03,79.77 173.11,79.86 173.28,79.86 173.36,79.77 173.36,79.33 173.44,79.25 173.75,79.25 174.01,79.5 174.01,80.63 174.25,80.88 175.12,80.88 175.24,81 175.24,87.64 175.72,88.12 177.46,88.12 178.7,89.36 178.7,91.05 178.94,91.3 179.6,91.3 179.68,91.38 179.68,92.06 179.77,92.14 179.94,92.14 180.02,92.06 180.02,91.38 180.1,91.3 180.27,91.3 180.35,91.38 180.35,92.06 180.44,92.14 180.61,92.14 180.69,92.06 180.69,91.38 180.77,91.3 180.94,91.3 181.03,91.38 181.03,92.06 181.11,92.14 181.28,92.14 181.36,92.06 181.36,91.38 181.44,91.3 181.7,91.3 181.9,91.5 181.9,94.1 182.94,95.13 185.61,95.13 185.99,95.52 186.73,95.52 187.15,95.1 189.07,95.1 190.8,96.83 191.31,96.83 191.9,97.42 191.9,98.67 192.23,99 192.23,100.45 191.87,100.82 191.87,102.04 v1(191.57,102.33)
DDR4_DDIMM_DQ2: length 101.9
  TOP w0.149: v1(192.54,104.32) 192.31,104.08 187.39,104.08 186.44,105.03 J2.12
  L03_SIG1 w0.081: v2(135.45,78.25) 135.05,78.94 arc(134.88,79.1) 134.66,79.17 134.65,79.17 arc(134.43,79.11) 134.26,78.95 134.24,78.93 arc(134.08,78.77) 133.85,78.71 133.84,78.71 arc(133.62,78.64) 133.45,78.48 arc(133.29,78.32) 133.07,78.25 133.05,78.25 arc(132.83,78.19) 132.66,78.03 132.66,78.02 arc(132.6,77.79) 132.66,77.56 132.66,77.56 arc(132.72,77.33) 132.66,77.1 132.65,77.08 arc(132.59,76.86) 132.66,76.64 132.66,76.64 arc(132.72,76.41) 132.66,76.18 arc(132.59,75.95) 132.65,75.72 132.66,75.72 arc(132.72,75.49) 132.66,75.26 arc(132.59,75.03) 132.65,74.8 132.66,74.8 arc(132.82,74.63) 133.05,74.57 133.06,74.57 arc(133.29,74.51) 133.45,74.34 133.57,73.85 arc(133.75,73.67) 134,73.6 134,73.6 arc(134.25,73.53) 134.43,73.35 134.44,73.35 arc(134.62,73.17) 134.87,73.1 134.87,73.1 arc(135.12,73.03) 135.3,72.85 arc(135.48,72.67) 135.73,72.6 135.74,72.6 arc(135.99,72.53) 136.17,72.35 136.17,72.35 arc(136.35,72.17) 136.6,72.1 136.61,72.1 arc(136.85,72.03) 137.03,71.85 arc(137.22,71.67) 137.46,71.6 137.47,71.6 arc(137.71,71.53) 137.9,71.35 137.9,71.35 arc(138.08,71.17) 138.33,71.1 arc(138.58,71.03) 138.76,70.85 138.77,70.85 arc(138.95,70.67) 139.2,70.6 139.2,70.6 arc(139.45,70.53) 139.63,70.35 arc(139.81,70.17) 140.06,70.1 arc(140.31,70.16) 140.5,70.34 140.5,70.35 arc(140.93,70.6) 141.36,70.35 141.36,70.35 arc(141.55,70.17) 141.8,70.1 arc(142.04,70.16) 142.23,70.34 142.23,70.35 arc(142.41,70.53) 142.66,70.6 142.86,70.6 143.29,70.16 146.07,70.16 147.11,71.2 156.44,71.2 157.45,72.22 163.21,72.22 169.04,78.06 172.64,78.06 172.65,78.06 174.04,78.06 177.45,81.47 177.85,81.47 178.09,81.71 arc(178.1,81.72) 178.1,81.73 178.1,84 177.99,84.11 177.99,86.43 178.32,86.76 178.57,86.76 179.04,87.22 179.04,87.79 181.12,89.88 184.23,89.88 184.25,89.85 186.47,89.85 186.5,89.88 186.89,89.88 187.88,90.87 187.95,90.87 188.19,91.1 188.19,91.17 190.24,93.22 190.24,93.88 192.87,96.52 192.87,96.52 194.43,98.08 194.43,99.09 194.49,99.15 194.49,99.61 193.61,100.5 193.61,101.32 192.89,102.03 192.89,102.55 193.2,102.86 193.2,103.66 v1(192.54,104.32)
DDR4_DDIMM_DQ3: length 101.6
  TOP w0.149: v1(192.17,103.23) 191.9,103.5 186.32,103.5 185.59,102.77 J2.157
  L03_SIG1 w0.081: v2(134.65,78.71) 134.25,78.02 134.24,78.01 arc(134.08,77.85) 133.85,77.79 133.84,77.79 arc(133.61,77.72) 133.45,77.56 arc(133.39,77.33) 133.45,77.1 arc(133.52,76.87) 133.46,76.64 133.45,76.64 arc(133.39,76.41) 133.45,76.18 arc(133.52,75.95) 133.45,75.72 arc(133.39,75.49) 133.45,75.26 133.64,74.94 133.93,74.65 134,74.6 134.01,74.6 arc(134.25,74.53) 134.44,74.35 arc(134.62,74.17) 134.87,74.1 arc(135.12,74.03) 135.3,73.85 135.3,73.85 arc(135.48,73.67) 135.73,73.6 135.73,73.6 arc(135.98,73.53) 136.17,73.35 136.17,73.34 arc(136.35,73.16) 136.6,73.1 arc(136.85,73.03) 137.03,72.85 137.03,72.85 arc(137.21,72.67) 137.46,72.6 137.47,72.6 arc(137.72,72.53) 137.9,72.35 arc(138.08,72.17) 138.33,72.1 138.34,72.1 arc(138.59,72.03) 138.77,71.85 arc(138.95,71.67) 139.2,71.6 139.2,71.6 arc(139.45,71.53) 139.63,71.35 139.63,71.34 arc(140.06,71.1) 140.5,71.34 140.5,71.35 arc(140.93,71.6) 141.36,71.35 141.37,71.35 arc(141.73,71.1) 142.14,71.24 142.41,71.37 142.51,71.47 142.94,71.47 143.21,71.2 146.63,71.2 146.97,71.54 156.3,71.54 157.32,72.55 163.07,72.55 163.63,73.12 163.63,73.23 163.53,73.33 163.53,73.45 163.66,73.57 163.77,73.57 163.87,73.47 163.99,73.47 164.11,73.59 164.11,73.71 163.6,74.22 163.6,74.33 163.72,74.46 163.83,74.46 164.34,73.95 164.46,73.95 164.58,74.07 164.58,74.18 164.07,74.69 164.07,74.81 164.19,74.93 164.31,74.93 164.82,74.42 164.93,74.42 165.06,74.54 165.06,74.66 164.54,75.17 164.54,75.28 164.67,75.4 164.78,75.4 165.29,74.89 165.41,74.89 168.91,78.4 173.88,78.4 177.18,81.7 177.18,84.04 176.98,84.24 176.98,86.45 177.37,86.84 177.82,86.84 178,87.01 178,87.49 180.78,90.27 182.38,90.27 182.65,90.54 182.65,93.6 183.47,94.43 189.37,94.43 190.99,96.05 191.47,96.05 193.5,98.07 193.5,99.02 193.23,99.29 193.23,101.22 192.56,101.89 192.56,102.84 v1(192.17,103.23)
DDR4_DDIMM_DQ4: length 101.3
  L03_SIG1 w0.081: v2(138.63,78.25) 139.44,78.25 arc(139.66,78.19) 139.83,78.02 arc(139.99,77.85) 140.22,77.79 140.39,77.79 140.88,77.3 141.27,77.3 141.61,76.96 141.97,76.96 142.43,77.42 142.77,77.42 143.21,77.86 144.34,77.86 144.72,77.48 155.14,77.48 156.16,78.5 156.16,87 163.01,93.85 165.14,93.85 165.66,94.37 165.66,96.12 165.81,96.28 166.01,96.28 166.09,96.36 166.09,97.03 166.17,97.11 166.35,97.11 166.43,97.03 166.43,96.36 166.51,96.28 166.68,96.28 166.76,96.36 166.76,97.03 166.84,97.11 167.02,97.11 167.1,97.03 167.1,96.36 167.18,96.28 167.35,96.28 167.43,96.36 167.43,97.03 167.52,97.11 167.69,97.11 167.77,97.03 167.77,96.36 167.85,96.28 168.02,96.28 168.1,96.36 168.1,97.03 168.19,97.11 168.36,97.11 168.44,97.03 168.44,96.36 168.52,96.28 168.69,96.28 168.78,96.36 168.78,97.03 168.86,97.11 169.03,97.11 169.11,97.03 169.11,96.36 169.19,96.28 169.36,96.28 169.45,96.36 169.45,97.03 169.53,97.11 169.7,97.11 169.78,97.03 169.78,96.36 169.86,96.28 170.04,96.28 170.12,96.36 170.12,97.03 170.2,97.11 170.37,97.11 170.45,97.03 170.45,96.36 170.53,96.28 170.71,96.28 170.79,96.36 170.79,97.03 170.87,97.11 171.04,97.11 171.12,97.03 171.12,96.36 171.2,96.28 171.38,96.28 171.46,96.36 171.46,97.03 171.54,97.11 171.71,97.11 171.79,97.03 171.79,96.36 171.87,96.28 172.05,96.28 172.13,96.36 172.13,97.03 172.21,97.11 172.38,97.11 172.46,97.03 172.46,96.36 172.54,96.28 172.72,96.28 172.8,96.36 172.8,97.03 172.88,97.11 173.05,97.11 173.13,97.03 173.13,96.36 173.22,96.28 173.39,96.28 173.47,96.36 173.47,97.03 173.55,97.11 173.72,97.11 173.8,97.03 173.8,96.36 173.89,96.28 174.06,96.28 174.14,96.36 174.14,97.03 174.22,97.11 174.39,97.11 174.47,97.03 174.47,96.36 174.56,96.28 175.25,96.28 175.34,96.36 175.34,97.09 175.42,97.17 175.59,97.17 175.67,97.09 175.67,96.36 175.75,96.28 175.93,96.28 176.01,96.36 176.01,97.09 176.09,97.17 176.26,97.17 176.34,97.09 176.34,96.36 176.42,96.28 176.6,96.28 176.68,96.36 176.68,97.09 176.76,97.17 176.93,97.17 177.01,97.09 177.01,96.36 177.09,96.28 177.27,96.28 177.35,96.36 177.35,96.45 177.43,96.54 177.6,96.54 177.68,96.45 177.68,96.36 177.76,96.28 179.43,96.28 179.99,96.84 179.99,98.08 180.43,98.52 180.43,99.06 184.15,102.78 184.15,105 186.07,106.91 193.68,106.91 193.81,106.78 v1(194.01,106.78)
