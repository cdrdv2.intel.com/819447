# Allegro board FM85_AGILEX_PCIE_DK_CMC_ADI_REVC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CXL_TX_N1: length 87.4
  L03_SIG1 w0.085: v2(137.47,45.1) 137.72,45 arc(137.79,44.98) 137.86,45 arc(137.98,45.19) 138.2,45.26 138.41,45.26 arc(138.52,45.28) 138.61,45.34 138.84,45.57 arc(138.98,45.67) 139.14,45.7 139.21,45.7 arc(139.34,45.73) 139.43,45.82 139.51,45.96 arc(139.73,46.18) 140.03,46.26 140.09,46.26 arc(140.23,46.3) 140.34,46.4 arc(140.6,46.66) 140.96,46.76 140.98,46.76 arc(141.07,46.78) 141.14,46.83 141.34,47.02 arc(141.52,47.14) 141.73,47.18 arc(141.93,47.15) 142.11,47.05 arc(142.15,47.01) 142.2,46.96 arc(142.3,46.87) 142.41,46.8 142.66,46.68 arc(142.72,46.66) 142.77,46.64 arc(142.95,46.57) 143.08,46.44 143.2,46.27 arc(143.35,46.17) 143.52,46.14 143.61,46.14 arc(143.8,46.1) 143.96,45.99 144.16,45.79 arc(144.26,45.72) 144.37,45.7 144.52,45.7 arc(144.71,45.66) 144.88,45.55 147.18,43.25 arc(148.53,42.31) 150.12,41.91 arc(152.69,41.21) 154.77,39.56 155.32,38.92 arc(155.64,38.6) 156.01,38.32 arc(157.18,37.69) 158.4,37.18 162.43,35.75 163.73,35.28 arc(165.63,34.66) 167.53,34.06 arc(167.92,33.86) 168.24,33.55 arc(168.64,33.03) 169.09,32.55 171.14,30.5 arc(172.09,29.87) 173.22,29.64 183.49,29.64 arc(184.18,29.57) 184.85,29.37 186.22,28.8 arc(186.62,28.61) 187,28.38 187,28.38 arc(187.22,28.24) 187.44,28.12 arc(187.48,28.1) 187.52,28.09 187.68,28.05 arc(187.7,28.05) 187.72,28.05 189.55,28.05 arc(190.11,27.94) 190.58,27.62 arc(190.94,27.38) 191.36,27.3 193.37,27.3 arc(194.84,27.01) 196.09,26.18 197.06,25.2 arc(197.67,24.72) 198.38,24.37 arc(198.42,24.36) 198.46,24.36 201.83,24.36 arc(202.46,24.44) 203.04,24.7 arc(203.73,25.01) 204.47,25.11 208.16,25.11 arc(209.08,24.93) 209.86,24.41 210.39,23.88 arc(210.97,23) 211.17,21.98 211.17,19.97 arc(211.35,19.56) 211.76,19.39 212.36,19.39 arc(212.36,19.39) 212.37,19.39 v2(212.59,19.61)
CXL_TX_N2: length 87.1
  L03_SIG1 w0.085: v2(134.87,45.6) 135.14,45.75 arc(135.18,45.81) 135.17,45.87 135.12,45.96 arc(135.06,46.16) 135.12,46.36 135.18,46.46 arc(135.4,46.68) 135.7,46.76 135.78,46.76 arc(135.91,46.79) 136.02,46.86 136.23,47.07 arc(136.37,47.17) 136.53,47.2 136.6,47.2 arc(136.84,47.13) 137.01,46.96 137.11,46.79 arc(137.22,46.68) 137.37,46.63 137.47,46.63 arc(137.74,46.56) 137.93,46.37 137.98,46.28 arc(138.09,46.17) 138.23,46.13 138.44,46.13 arc(138.58,46.17) 138.68,46.27 138.78,46.45 arc(138.96,46.63) 139.21,46.7 139.25,46.7 arc(139.33,46.72) 139.41,46.76 139.63,46.99 arc(139.79,47.1) 139.99,47.14 140.14,47.14 arc(140.3,47.18) 140.42,47.29 140.45,47.35 arc(140.66,47.56) 140.94,47.64 141.07,47.64 arc(141.18,47.67) 141.26,47.75 141.36,47.91 arc(141.53,48.09) 141.77,48.15 141.89,48.15 arc(142.07,48.12) 142.22,48.02 142.39,47.84 arc(142.48,47.78) 142.58,47.76 142.68,47.76 arc(142.99,47.68) 143.21,47.46 143.22,47.44 arc(143.35,47.31) 143.53,47.26 143.59,47.26 arc(143.8,47.21) 143.95,47.06 144.01,46.94 arc(144.19,46.76) 144.43,46.7 145.48,46.7 arc(145.68,46.66) 145.85,46.54 147.7,44.7 148.02,44.7 arc(148.39,44.59) 148.63,44.29 arc(148.98,43.87) 149.5,43.72 arc(149.98,43.63) 150.37,43.34 arc(150.39,43.32) 150.41,43.29 arc(150.41,43.29) 150.42,43.29 arc(151.31,42.71) 152.35,42.5 152.55,42.5 arc(153.51,42.31) 154.32,41.77 155.94,40.15 arc(158.25,38.49) 160.97,37.67 arc(164.29,36.88) 167.38,35.46 arc(168.32,34.86) 169.21,34.21 arc(170.04,33.41) 170.68,32.47 arc(171.03,31.91) 171.43,31.4 arc(171.47,31.37) 171.5,31.35 171.7,31.21 arc(171.74,31.19) 171.78,31.18 arc(172.32,31.08) 172.87,31.1 arc(172.91,31.11) 172.95,31.13 173.23,31.31 arc(173.27,31.33) 173.3,31.35 arc(173.88,31.55) 174.46,31.76 arc(175.19,31.85) 175.89,31.61 arc(176.21,31.47) 176.55,31.42 183.44,31.42 arc(184.23,31.26) 184.89,30.82 arc(185.42,30.47) 186.04,30.35 187.92,30.35 arc(189.36,30.06) 190.57,29.25 191.05,28.77 arc(191.63,28.39) 192.31,28.25 192.87,28.25 arc(195.16,27.8) 197.09,26.5 arc(197.83,26.01) 198.71,25.83 209.22,25.83 arc(209.58,25.76) 209.88,25.56 210.47,24.97 arc(210.64,24.86) 210.84,24.82 211.26,24.82 arc(211.42,24.88) 211.48,25.04 v2(211.48,25.05)
CXL_TX_N3: length 87
  L03_SIG1 w0.085: v2(137.47,47.1) 137.72,47 arc(137.82,46.99) 137.9,47.05 137.93,47.1 arc(138.04,47.21) 138.2,47.25 138.43,47.25 arc(138.47,47.26) 138.51,47.27 arc(138.56,47.3) 138.61,47.34 138.84,47.57 arc(138.98,47.67) 139.14,47.7 139.21,47.7 arc(139.34,47.73) 139.43,47.82 139.51,47.96 arc(139.73,48.18) 140.03,48.26 140.09,48.26 arc(140.23,48.3) 140.34,48.41 arc(140.6,48.67) 140.96,48.76 arc(141.05,48.78) 141.14,48.83 141.36,49.05 arc(141.53,49.16) 141.74,49.19 arc(142.02,49.13) 142.23,48.92 142.25,48.88 arc(142.37,48.77) 142.53,48.72 142.57,48.72 arc(142.88,48.64) 143.11,48.43 143.19,48.32 arc(143.34,48.19) 143.55,48.14 143.61,48.14 arc(143.8,48.1) 143.96,47.99 144.16,47.79 arc(144.26,47.72) 144.37,47.7 145.92,47.7 arc(146.26,47.63) 146.55,47.44 148.1,45.89 arc(148.27,45.78) 148.46,45.74 149.81,45.74 arc(150.3,45.64) 150.72,45.36 151.02,45.06 arc(151.88,44.49) 152.88,44.29 165.39,44.29 arc(166.39,43.88) 166.8,42.88 166.8,39.93 arc(167.11,38.36) 168,37.04 169.59,35.45 arc(170.19,35.05) 170.89,34.9 173.13,34.9 arc(173.92,34.75) 174.59,34.3 175.41,33.47 arc(176.12,33) 176.95,32.83 187.44,32.83 arc(188.83,32.56) 190,31.77 192.17,29.61 arc(192.41,29.41) 192.69,29.27 arc(192.74,29.25) 192.78,29.25 193.58,29.25 arc(194.67,29.05) 195.61,28.49 arc(197.06,27.63) 198.72,27.33 208.75,27.33 arc(209.2,27.27) 209.62,27.09 210.07,26.83 arc(210.13,26.8) 210.19,26.75 arc(210.31,26.68) 210.45,26.65 211.13,26.6 arc(211.49,26.58) 211.85,26.57 212.37,26.57 arc(212.53,26.64) 212.59,26.79 v2(212.59,26.81)
CXL_TX_N4: length 88.8
  L03_SIG1 w0.085: v2(210.61,28.61) 210.4,28.41 arc(210.37,28.38) 210.32,28.37 198.92,28.37 arc(197.25,28.71) 195.83,29.65 195.62,29.86 arc(195.15,30.18) 194.59,30.29 arc(194.46,30.31) 194.35,30.39 191.09,33.65 arc(190.54,34.02) 189.9,34.14 178.48,34.14 arc(178.24,34.1) 178.04,33.96 arc(177.98,33.92) 177.9,33.9 177.19,33.9 arc(176.52,33.99) 175.89,34.22 arc(175.85,34.24) 175.82,34.27 175.09,35 arc(173.93,35.77) 172.57,36.04 172.16,36.04 arc(170.65,36.34) 169.38,37.2 169.25,37.35 arc(168.8,38) 168.53,38.75 arc(168.17,40.82) 168.05,42.91 arc(168.05,43.13) 168.03,43.35 arc(168.01,43.42) 167.99,43.48 167.87,43.78 arc(167.81,43.89) 167.73,43.99 166.72,45.06 arc(166.66,45.1) 166.61,45.14 arc(166.31,45.32) 166,45.48 arc(165.93,45.5) 165.87,45.52 165.35,45.63 arc(165.31,45.63) 165.27,45.64 152.86,45.64 arc(152.09,45.79) 151.45,46.22 150.88,46.79 arc(150.08,47.32) 149.15,47.51 148.54,47.51 arc(148.31,47.55) 148.12,47.68 147.33,48.47 arc(147.08,48.64) 146.78,48.7 144.43,48.7 arc(144.2,48.76) 144.04,48.92 143.97,49.05 arc(143.81,49.2) 143.6,49.26 143.53,49.26 arc(143.36,49.31) 143.24,49.43 143.23,49.45 arc(143,49.68) 142.68,49.76 142.58,49.76 arc(142.48,49.78) 142.39,49.84 142.22,50.02 arc(142.07,50.12) 141.89,50.15 141.77,50.15 arc(141.53,50.09) 141.35,49.91 141.26,49.75 arc(141.18,49.67) 141.07,49.64 140.93,49.64 arc(140.66,49.56) 140.45,49.36 140.41,49.29 arc(140.3,49.18) 140.14,49.14 139.99,49.14 arc(139.79,49.1) 139.63,48.99 139.41,48.76 arc(139.33,48.72) 139.25,48.7 139.21,48.7 arc(138.96,48.63) 138.78,48.45 138.68,48.27 arc(138.58,48.17) 138.44,48.13 138.23,48.13 arc(138.09,48.17) 137.98,48.28 137.93,48.37 arc(137.74,48.57) 137.47,48.64 137.35,48.64 arc(137.21,48.68) 137.11,48.79 137.01,48.96 arc(136.84,49.13) 136.6,49.2 136.53,49.2 arc(136.37,49.17) 136.23,49.07 136.02,48.86 arc(135.91,48.79) 135.78,48.76 135.66,48.76 arc(135.51,48.74) 135.37,48.68 arc(135.29,48.61) 135.23,48.53 135.11,48.32 arc(135.06,48.15) 135.11,47.98 135.17,47.87 arc(135.18,47.81) 135.14,47.75 v2(134.87,47.6)
CXL_TX_N5: length 87.2
  L03_SIG1 w0.085: v2(212.59,30.41) 212.36,30.19 212.04,30.19 arc(210.08,30.57) 208.42,31.68 207.98,32.13 arc(206.51,33.11) 204.78,33.45 199.88,33.45 arc(199.75,33.43) 199.64,33.35 arc(199.41,33.2) 199.14,33.14 196.26,33.14 arc(195.79,33.24) 195.39,33.51 194.21,34.68 arc(193.41,35.22) 192.46,35.41 177.39,35.41 arc(175.8,35.72) 174.45,36.63 174.28,36.8 arc(174.16,36.98) 174.11,37.2 174.11,38.25 arc(174.14,38.43) 174.2,38.6 arc(174.3,38.86) 174.34,39.14 174.34,41.83 arc(174.29,42.08) 174.15,42.29 173.98,42.46 arc(173.9,42.57) 173.88,42.71 173.88,42.84 arc(173.23,44.41) 171.65,45.06 169.87,45.06 arc(168.52,45.33) 167.38,46.09 167.06,46.41 arc(166.09,47.06) 164.93,47.29 153.03,47.29 arc(152.5,47.4) 152.04,47.7 151.62,48.12 147.8,49.7 144.49,49.7 arc(144.27,49.74) 144.08,49.87 143.96,49.99 arc(143.8,50.1) 143.61,50.14 143.52,50.14 arc(143.3,50.19) 143.14,50.36 143.13,50.37 arc(142.93,50.56) 142.66,50.64 142.59,50.64 arc(142.42,50.68) 142.3,50.81 142.23,50.92 arc(142.04,51.11) 141.78,51.18 141.69,51.18 arc(141.51,51.15) 141.36,51.05 141.14,50.83 arc(141.07,50.78) 140.98,50.76 140.96,50.76 arc(140.6,50.67) 140.34,50.41 arc(140.23,50.3) 140.09,50.26 140.03,50.26 arc(139.73,50.18) 139.51,49.96 139.43,49.82 arc(139.34,49.73) 139.21,49.7 139.14,49.7 arc(138.98,49.67) 138.84,49.57 138.59,49.32 arc(138.52,49.27) 138.43,49.25 138.18,49.25 arc(138.08,49.24) 137.98,49.19 arc(137.9,49.1) 137.85,49 arc(137.8,48.98) 137.74,48.99 arc(137.7,49.01) 137.66,49.02 v2(137.47,49.1)
CXL_TX_N6: length 87.6
  L03_SIG1 w0.085: v2(210.61,35.81) 210.41,35.62 arc(210.38,35.59) 210.34,35.59 210.24,35.59 arc(209.83,35.5) 209.49,35.27 209.38,35.17 arc(209.2,35.05) 208.99,35.01 207.03,35.01 arc(206.84,35.05) 206.68,35.16 arc(206.38,35.35) 206.04,35.42 202.72,35.42 arc(202.51,35.38) 202.33,35.26 arc(201.52,34.71) 200.56,34.52 196.5,34.52 arc(196.22,34.58) 195.98,34.74 195.4,35.32 arc(193.9,36.32) 192.13,36.67 179.31,36.67 arc(178.37,36.86) 177.58,37.39 177.16,37.81 arc(176.71,38.48) 176.55,39.27 176.55,41.3 arc(176.54,41.43) 176.51,41.55 arc(176.39,41.79) 176.22,42 175.93,42.29 arc(175.71,42.62) 175.63,43.02 arc(175.43,44.02) 174.86,44.88 173.81,45.93 arc(173.36,46.23) 172.82,46.34 170.97,46.34 arc(169.92,46.55) 169.03,47.14 167.87,48.3 arc(166.58,49.16) 165.06,49.47 151.58,49.47 arc(150.55,49.67) 149.68,50.25 149.32,50.61 arc(149.23,50.68) 149.12,50.7 144.43,50.7 arc(144.19,50.76) 144.02,50.94 143.98,51 arc(143.79,51.19) 143.53,51.26 143.51,51.26 arc(143.33,51.31) 143.2,51.45 143.19,51.47 arc(142.99,51.68) 142.71,51.76 142.58,51.76 arc(142.48,51.78) 142.39,51.84 142.22,52.02 arc(142.07,52.12) 141.89,52.15 141.77,52.15 arc(141.53,52.09) 141.36,51.91 141.26,51.75 arc(141.18,51.67) 141.07,51.64 140.94,51.64 arc(140.66,51.56) 140.46,51.36 140.45,51.34 arc(140.3,51.19) 140.1,51.14 139.99,51.14 arc(139.79,51.1) 139.63,50.99 139.41,50.76 arc(139.33,50.72) 139.25,50.7 139.21,50.7 arc(138.96,50.63) 138.78,50.45 138.68,50.27 arc(138.58,50.17) 138.44,50.14 138.23,50.14 arc(138.09,50.17) 137.98,50.28 137.93,50.37 arc(137.74,50.57) 137.47,50.64 137.37,50.64 arc(137.22,50.68) 137.11,50.79 137.01,50.96 arc(136.84,51.13) 136.6,51.2 136.53,51.2 arc(136.37,51.17) 136.23,51.07 136.02,50.86 arc(135.91,50.79) 135.78,50.76 135.64,50.76 arc(135.39,50.7) 135.21,50.52 135.12,50.36 arc(135.06,50.16) 135.12,49.96 135.17,49.87 arc(135.18,49.81) 135.14,49.75 v2(134.87,49.6)
CXL_TX_N7: length 82.7
  L03_SIG1 w0.085: v2(212.59,37.61) 212.38,37.4 209.4,37.4 arc(209.15,37.35) 208.94,37.21 208.85,37.12 arc(208.51,36.89) 208.1,36.81 204.8,36.81 arc(203.34,37.27) 202.41,38.49 arc(202.11,39.12) 201.67,39.66 200.89,40.44 arc(200.4,40.77) 199.82,40.88 198.93,40.88 arc(197.82,41.11) 196.87,41.74 195.01,43.6 arc(194.26,44.1) 193.38,44.27 179.97,44.27 arc(179.66,44.4) 179.52,44.7 arc(179.51,44.76) 179.5,44.82 arc(179.26,45.28) 178.84,45.57 arc(178.77,45.6) 178.7,45.61 arc(177.46,46) 176.41,46.76 173.97,49.19 arc(173.59,49.45) 173.14,49.54 169.86,49.54 arc(169.1,49.69) 168.46,50.12 168.25,50.33 arc(167.64,50.74) 166.91,50.88 151.91,50.88 arc(151.27,50.98) 150.7,51.28 150.3,51.68 arc(150.03,51.86) 149.71,51.92 149.31,51.92 arc(149.17,51.89) 149.04,51.81 arc(148.92,51.73) 148.78,51.7 144.43,51.7 arc(144.28,51.73) 144.14,51.82 143.97,51.99 arc(143.81,52.1) 143.62,52.14 143.52,52.14 arc(143.3,52.19) 143.14,52.36 143.13,52.37 arc(142.93,52.56) 142.66,52.64 142.6,52.64 arc(142.42,52.68) 142.29,52.81 142.23,52.92 arc(142.04,53.11) 141.78,53.18 141.69,53.18 arc(141.51,53.15) 141.36,53.05 141.14,52.83 arc(141.07,52.78) 140.98,52.76 140.96,52.76 arc(140.6,52.67) 140.34,52.41 arc(140.23,52.3) 140.09,52.26 140.03,52.26 arc(139.73,52.18) 139.51,51.96 139.43,51.82 arc(139.34,51.73) 139.21,51.7 139.14,51.7 arc(138.98,51.67) 138.84,51.57 138.6,51.33 arc(138.57,51.3) 138.54,51.28 arc(138.5,51.26) 138.45,51.26 138.22,51.26 arc(138.05,51.21) 137.92,51.09 137.9,51.05 arc(137.82,50.99) 137.72,51 v2(137.47,51.1)
CXL_TX_N8: length 81.7
  L03_SIG1 w0.085: v2(134.87,51.6) 134.87,51.6 135.09,51.72 arc(135.12,51.75) 135.14,51.79 135.16,51.84 arc(135.16,51.88) 135.15,51.91 135.1,51.99 arc(135.06,52.16) 135.1,52.32 135.21,52.51 arc(135.28,52.61) 135.37,52.68 arc(135.51,52.74) 135.66,52.76 135.78,52.76 arc(135.91,52.79) 136.02,52.86 136.23,53.07 arc(136.37,53.17) 136.53,53.2 136.6,53.2 arc(136.84,53.13) 137.01,52.96 137.11,52.79 arc(137.21,52.68) 137.35,52.64 137.47,52.64 arc(137.74,52.57) 137.93,52.37 137.98,52.28 arc(138.09,52.17) 138.23,52.14 138.44,52.14 arc(138.58,52.17) 138.68,52.27 138.78,52.45 arc(138.96,52.63) 139.21,52.7 139.25,52.7 arc(139.33,52.72) 139.41,52.76 139.63,52.99 arc(139.79,53.1) 139.99,53.14 140.14,53.14 arc(140.3,53.18) 140.42,53.29 140.46,53.36 arc(140.66,53.56) 140.94,53.64 141.07,53.64 arc(141.18,53.67) 141.26,53.75 141.36,53.91 arc(141.53,54.09) 141.77,54.15 141.89,54.15 arc(142.07,54.12) 142.22,54.02 142.39,53.84 arc(142.48,53.78) 142.58,53.76 142.68,53.76 arc(143,53.68) 143.23,53.45 143.24,53.43 arc(143.36,53.31) 143.53,53.26 143.54,53.26 arc(143.81,53.19) 144,52.99 144.04,52.92 arc(144.2,52.76) 144.43,52.7 149.94,52.7 arc(150.6,52.57) 151.16,52.19 151.23,52.12 arc(151.57,51.89) 151.98,51.81 167.09,51.81 arc(168.35,51.56) 169.41,50.85 169.6,50.66 arc(169.84,50.5) 170.13,50.44 172.48,50.44 arc(173.66,50.21) 174.66,49.54 176.04,48.17 arc(177.49,47.19) 179.21,46.85 193.85,46.85 arc(194.4,46.93) 194.91,47.17 arc(195.41,47.41) 195.96,47.49 199.05,47.49 arc(199.62,47.59) 200.15,47.81 arc(200.85,48.1) 201.6,48.19 202.36,48.19 arc(202.61,48.16) 202.85,48.06 arc(202.99,48.01) 203.14,47.99 208.5,47.99 arc(208.56,47.99) 208.62,47.98 arc(209.28,47.63) 209.63,46.97 arc(209.64,46.92) 209.64,46.86 arc(209.83,46.45) 210.25,46.29 210.38,46.29 v2(210.61,46.52)
CXL_TX_N9: length 79.5
  L03_SIG1 w0.085: v2(212.59,48.32) 212.41,48.14 210.25,48.14 arc(209.99,48.19) 209.76,48.34 209.59,48.51 arc(208.82,49.02) 207.92,49.2 207.01,49.2 arc(206.81,49.16) 206.63,49.05 arc(206.21,48.77) 205.71,48.67 203.59,48.67 arc(203.45,48.69) 203.33,48.77 arc(203.01,48.99) 202.62,49.07 191.73,49.07 arc(191.64,49.06) 191.56,49.03 arc(191.35,48.92) 191.15,48.79 arc(190.14,48.28) 189.01,48.1 177.91,48.1 arc(177.3,48.22) 176.79,48.56 176.6,48.76 175.69,49.66 arc(173.97,50.81) 171.93,51.22 170.86,51.22 arc(170.53,51.29) 170.25,51.47 arc(168.86,52.4) 167.23,52.72 153.89,52.72 arc(153.52,52.8) 153.2,53.01 153.13,53.08 152.47,53.75 arc(151.81,54.18) 151.04,54.34 149.5,54.34 arc(149.43,54.34) 149.37,54.33 arc(149.13,54.25) 148.91,54.13 arc(148.86,54.1) 148.82,54.06 148.76,54.01 arc(148.4,53.78) 147.98,53.7 144.55,53.7 144.37,53.7 arc(144.26,53.72) 144.16,53.79 143.96,53.99 arc(143.8,54.1) 143.61,54.14 143.52,54.14 arc(143.3,54.2) 143.14,54.36 143.13,54.37 arc(142.93,54.56) 142.66,54.64 142.57,54.64 arc(142.42,54.68) 142.31,54.79 142.23,54.92 arc(142.04,55.11) 141.78,55.18 141.69,55.18 arc(141.51,55.15) 141.36,55.05 141.14,54.83 arc(141.07,54.78) 140.98,54.76 140.96,54.76 arc(140.6,54.67) 140.34,54.41 arc(140.23,54.3) 140.09,54.26 140.03,54.26 arc(139.73,54.18) 139.51,53.96 139.42,53.81 arc(139.33,53.72) 139.2,53.68 139.15,53.68 arc(138.97,53.65) 138.81,53.55 138.57,53.3 arc(138.53,53.27) 138.47,53.26 138.23,53.26 arc(138.05,53.21) 137.92,53.08 137.9,53.05 arc(137.82,52.99) 137.72,53 v2(137.47,53.1)
CXL_TX_N10: length 82.4
  L03_SIG1 w0.085: v2(210.61,53.72) 210.51,53.62 arc(210.48,53.59) 210.44,53.57 arc(210.36,53.53) 210.28,53.5 arc(210.23,53.49) 210.19,53.49 209.92,53.49 arc(208.45,53.78) 207.21,54.61 206.11,55.7 arc(205.18,56.36) 204.07,56.65 arc(204.02,56.66) 203.97,56.66 198.93,56.66 arc(198.62,56.62) 198.32,56.52 197.69,56.22 arc(197.38,56.05) 197.11,55.82 196.69,55.4 arc(193.38,53.19) 189.48,52.41 186.39,52.41 arc(185.86,52.31) 185.41,52.01 185.4,51.99 arc(184.84,51.62) 184.19,51.49 176.95,51.49 arc(176.78,51.48) 176.61,51.43 175.84,51.12 arc(175.66,51.07) 175.47,51.05 arc(175.25,51.1) 175.05,51.23 174.67,51.61 arc(174.21,51.92) 173.66,52.03 171.62,52.03 arc(171.04,52.15) 170.54,52.48 170.44,52.57 arc(169.13,53.45) 167.58,53.76 154.12,53.76 arc(153.59,53.87) 153.13,54.17 152.94,54.37 arc(152.49,54.73) 151.97,54.98 arc(151.89,55) 151.82,55.01 149.14,55.01 arc(149.07,55.01) 149.01,55 arc(148.82,54.94) 148.64,54.85 arc(148.37,54.75) 148.09,54.71 144.45,54.71 arc(144.28,54.74) 144.12,54.82 144.11,54.83 arc(144.08,54.86) 144.05,54.9 143.94,55.11 arc(143.82,55.22) 143.67,55.26 143.53,55.26 arc(143.36,55.31) 143.24,55.43 143.23,55.45 arc(143,55.68) 142.68,55.76 142.58,55.76 arc(142.48,55.78) 142.39,55.84 142.22,56.02 arc(142.07,56.12) 141.89,56.15 141.77,56.15 arc(141.53,56.09) 141.36,55.91 141.26,55.75 arc(141.18,55.67) 141.07,55.64 140.94,55.64 arc(140.66,55.56) 140.46,55.36 140.42,55.3 arc(140.3,55.18) 140.14,55.14 139.99,55.14 arc(139.79,55.1) 139.63,54.99 139.41,54.76 arc(139.33,54.72) 139.25,54.7 139.21,54.7 arc(138.96,54.63) 138.78,54.45 138.68,54.27 arc(138.58,54.17) 138.44,54.14 138.23,54.14 arc(138.09,54.17) 137.98,54.28 137.93,54.37 arc(137.74,54.57) 137.47,54.64 137.35,54.64 arc(137.22,54.67) 137.13,54.76 137.01,54.96 arc(136.84,55.13) 136.6,55.2 136.53,55.2 arc(136.37,55.17) 136.23,55.07 136.02,54.86 arc(135.91,54.79) 135.78,54.76 135.73,54.76 arc(135.41,54.68) 135.18,54.45 135.12,54.35 135.11,54.34 arc(135.07,54.15) 135.12,53.96 135.17,53.87 arc(135.18,53.81) 135.14,53.75 v2(134.87,53.6)
CXL_TX_N11: length 83
  L03_SIG1 w0.085: v2(137.47,55.1) 137.71,55 arc(137.75,55) 137.8,55.02 137.92,55.13 arc(138.11,55.28) 138.34,55.33 138.57,55.33 arc(138.6,55.34) 138.63,55.36 138.84,55.57 arc(138.98,55.67) 139.14,55.7 139.21,55.7 arc(139.34,55.73) 139.43,55.82 139.51,55.96 arc(139.73,56.18) 140.03,56.26 140.09,56.26 arc(140.23,56.3) 140.34,56.41 arc(140.6,56.67) 140.96,56.76 140.98,56.76 arc(141.07,56.78) 141.14,56.83 141.36,57.05 arc(141.51,57.15) 141.69,57.19 141.78,57.19 arc(142.04,57.11) 142.23,56.92 142.29,56.81 arc(142.42,56.68) 142.6,56.64 142.66,56.64 arc(142.93,56.56) 143.13,56.37 143.14,56.36 arc(143.3,56.2) 143.52,56.14 143.61,56.14 arc(143.8,56.1) 143.96,55.99 144.16,55.79 arc(144.26,55.72) 144.37,55.7 146.31,55.7 arc(146.31,55.7) 146.31,55.7 arc(146.34,55.7) 146.36,55.7 146.56,55.7 arc(146.73,55.73) 146.87,55.83 146.98,55.94 arc(147.45,56.25) 147.99,56.36 151.44,56.36 arc(153.01,56.67) 154.34,57.55 155.05,58.26 arc(155.4,58.5) 155.82,58.58 165.69,58.58 arc(166.51,58.24) 166.85,57.43 166.85,55.89 arc(167.17,55.12) 167.94,54.8 arc(169.1,54.57) 170.08,53.91 170.37,53.62 arc(171.27,53.02) 172.32,52.81 175.34,52.81 arc(175.54,52.79) 175.73,52.71 arc(175.77,52.69) 175.81,52.67 arc(175.91,52.63) 176,52.57 arc(176.06,52.53) 176.13,52.49 arc(176.17,52.45) 176.21,52.42 arc(176.38,52.32) 176.56,52.29 177.44,52.29 arc(177.49,52.29) 177.54,52.31 arc(177.65,52.34) 177.77,52.35 183.57,52.35 arc(183.62,52.35) 183.66,52.35 arc(184.27,52.51) 184.85,52.77 185.32,53.05 arc(186.01,53.34) 186.75,53.43 188.46,53.43 arc(192.61,54.24) 196.15,56.54 arc(196.35,56.72) 196.58,56.86 arc(197.21,57.17) 197.89,57.36 arc(197.95,57.37) 198.02,57.37 205.8,57.37 arc(206.77,57.18) 207.59,56.63 208.37,55.85 arc(208.99,55.43) 209.73,55.29 212.39,55.29 arc(212.53,55.35) 212.59,55.49 v2(212.59,55.52)
CXL_TX_N12: length 80.9
  L03_SIG1 w0.085: v2(134.87,55.6) 135.14,55.75 arc(135.18,55.81) 135.17,55.87 135.12,55.96 arc(135.06,56.16) 135.12,56.36 135.15,56.41 arc(135.4,56.67) 135.76,56.76 135.78,56.76 arc(135.91,56.79) 136.02,56.86 136.2,57.05 arc(136.34,57.14) 136.51,57.17 136.65,57.17 arc(136.85,57.12) 136.99,56.99 137,56.98 137.11,56.8 arc(137.22,56.68) 137.39,56.64 137.48,56.64 arc(137.74,56.57) 137.93,56.37 137.98,56.28 arc(138.09,56.17) 138.23,56.14 138.44,56.14 arc(138.58,56.17) 138.68,56.27 138.78,56.45 arc(138.96,56.63) 139.21,56.7 139.25,56.7 arc(139.25,56.7) 139.26,56.7 arc(139.34,56.72) 139.41,56.76 139.63,56.99 arc(139.79,57.1) 139.99,57.14 140.14,57.14 arc(140.3,57.18) 140.42,57.29 140.46,57.36 arc(140.66,57.56) 140.94,57.64 141.07,57.64 arc(141.18,57.67) 141.26,57.75 141.36,57.91 arc(141.53,58.09) 141.77,58.15 141.89,58.15 arc(142.07,58.12) 142.22,58.02 142.39,57.84 arc(142.48,57.78) 142.58,57.76 142.68,57.76 arc(143,57.68) 143.23,57.45 143.24,57.43 arc(143.36,57.31) 143.53,57.26 143.67,57.26 arc(143.88,57.2) 144.04,57.05 144.14,56.86 arc(144.26,56.74) 144.43,56.7 145.94,56.7 147.34,58.1 arc(147.71,58.35) 148.15,58.44 152.24,58.44 arc(152.98,58.58) 153.6,59 arc(154.03,59.28) 154.53,59.38 168.71,59.38 arc(168.81,59.4) 168.9,59.46 arc(169.03,59.54) 169.17,59.57 173.88,59.57 arc(174.04,59.61) 174.18,59.7 174.21,59.73 arc(175.01,60.06) 175.8,59.73 176.04,59.49 arc(176.12,59.43) 176.22,59.41 176.4,59.41 arc(176.48,59.43) 176.55,59.47 arc(176.64,59.54) 176.75,59.56 177.21,59.56 arc(177.31,59.54) 177.41,59.49 177.82,59.16 arc(178.46,58.82) 179.17,58.7 arc(179.18,58.7) 179.18,58.7 arc(179.23,58.7) 179.28,58.69 182.6,58.69 arc(182.88,58.64) 183.11,58.49 183.23,58.36 arc(183.98,57.86) 184.85,57.69 196.28,57.69 arc(196.53,57.71) 196.78,57.77 196.83,57.78 197.24,57.93 arc(197.31,57.96) 197.38,57.99 arc(197.64,58.08) 197.92,58.11 207.24,58.11 arc(207.93,57.98) 208.51,57.59 arc(209.06,57.22) 209.71,57.09 210.24,57.09 arc(210.24,57.09) 210.25,57.09 arc(210.3,57.09) 210.36,57.09 210.38,57.09 v2(210.61,57.32)
CXL_TX_N13: length 80.4
  L03_SIG1 w0.085: v2(137.47,57.1) 137.72,57 arc(137.82,56.99) 137.9,57.05 137.93,57.1 arc(137.94,57.12) 137.96,57.14 arc(138.06,57.23) 138.19,57.26 138.44,57.26 arc(138.52,57.27) 138.59,57.32 138.84,57.58 arc(138.98,57.67) 139.14,57.7 139.21,57.7 arc(139.34,57.73) 139.43,57.82 139.51,57.96 arc(139.73,58.18) 140.03,58.26 140.09,58.26 arc(140.23,58.3) 140.34,58.41 arc(140.6,58.67) 140.96,58.76 140.98,58.76 arc(141.07,58.78) 141.14,58.83 141.36,59.05 arc(141.51,59.15) 141.69,59.19 141.78,59.19 arc(142.04,59.11) 142.23,58.92 142.32,58.77 arc(142.42,58.67) 142.55,58.64 142.66,58.64 arc(142.93,58.56) 143.13,58.37 143.14,58.36 arc(143.3,58.2) 143.52,58.14 143.61,58.14 arc(143.8,58.1) 143.96,57.99 144.16,57.79 arc(144.26,57.72) 144.37,57.7 145.4,57.7 146.68,58.99 147.29,59.39 148.77,60.01 152.71,60.01 arc(152.99,60.06) 153.23,60.22 153.42,60.41 arc(153.58,60.52) 153.77,60.56 171.29,60.56 arc(172.19,60.74) 172.96,61.25 arc(173.49,61.6) 174.11,61.72 175.08,61.72 arc(175.38,61.67) 175.63,61.5 176.26,60.86 arc(176.74,60.54) 177.31,60.43 177.92,60.43 arc(178.47,60.32) 178.93,60.01 arc(179.17,59.85) 179.44,59.8 182.17,59.8 arc(182.77,59.68) 183.28,59.34 183.4,59.23 arc(184.14,58.73) 185.03,58.55 189.64,58.55 arc(190.61,58.69) 191.5,59.11 arc(191.53,59.13) 191.56,59.16 192.77,60.37 arc(193.32,60.79) 193.98,61.06 arc(194.04,61.07) 194.11,61.08 204.69,61.08 arc(204.77,61.07) 204.84,61.05 arc(205.23,60.87) 205.57,60.6 arc(205.77,60.47) 206.01,60.42 208.25,60.42 arc(208.85,60.3) 209.36,59.96 210.4,58.92 arc(210.44,58.9) 210.48,58.89 212.32,58.89 arc(212.36,58.9) 212.4,58.92 v2(212.59,59.12)
CXL_TX_N14: length 81.4
  L03_SIG1 w0.085: v2(134.87,57.6) 135.14,57.75 arc(135.18,57.81) 135.17,57.87 135.12,57.96 arc(135.07,58.15) 135.12,58.34 135.23,58.53 arc(135.28,58.6) 135.34,58.66 arc(135.49,58.74) 135.66,58.76 135.78,58.76 arc(135.91,58.79) 136.02,58.86 136.23,59.07 arc(136.37,59.17) 136.53,59.2 136.6,59.2 arc(136.84,59.14) 137.01,58.96 137.11,58.78 arc(137.22,58.68) 137.37,58.64 137.47,58.64 arc(137.74,58.56) 137.93,58.37 137.98,58.28 arc(138.09,58.17) 138.23,58.14 138.44,58.14 arc(138.58,58.17) 138.68,58.27 138.78,58.45 arc(138.96,58.63) 139.21,58.7 139.25,58.7 arc(139.33,58.72) 139.41,58.76 139.65,59.01 arc(139.79,59.1) 139.95,59.14 140.09,59.14 arc(140.3,59.19) 140.45,59.35 140.48,59.39 arc(140.66,59.57) 140.91,59.64 140.99,59.64 arc(141.17,59.68) 141.3,59.81 141.4,59.99 arc(141.56,60.15) 141.76,60.2 141.88,60.2 arc(141.97,60.22) 142.04,60.27 142.28,60.51 arc(142.42,60.6) 142.59,60.64 142.71,60.64 arc(142.83,60.67) 142.93,60.76 143.04,60.96 arc(143.22,61.14) 143.45,61.2 147.04,61.2 arc(147.08,61.2) 147.12,61.22 147.97,61.57 arc(147.99,61.58) 148.02,61.58 149.74,61.93 167.36,61.93 arc(168.24,62.1) 168.99,62.6 170.61,64.22 arc(171.35,64.71) 172.21,64.88 173.77,64.88 arc(174.8,64.68) 175.68,64.1 176.52,63.26 arc(176.55,63.23) 176.59,63.21 arc(176.65,63.19) 176.73,63.18 177.51,63.18 arc(177.79,63.12) 178.03,62.96 178.93,62.06 arc(179.24,61.85) 179.61,61.78 182.49,61.78 arc(183.05,61.86) 183.56,62.09 arc(183.86,62.24) 184.19,62.35 arc(184.22,62.35) 184.25,62.35 193.64,62.35 arc(193.72,62.35) 193.8,62.32 194,62.24 arc(194.08,62.22) 194.16,62.21 194.94,62.21 arc(195.02,62.22) 195.1,62.25 arc(195.27,62.33) 195.46,62.35 200.63,62.35 arc(200.72,62.37) 200.8,62.43 201.1,62.73 arc(201.62,63.07) 202.23,63.19 205.83,63.19 arc(205.83,63.19) 205.84,63.19 arc(206.49,63.34) 207.11,63.58 208.5,64.27 arc(208.62,64.31) 208.74,64.33 209.36,64.33 arc(209.41,64.32) 209.47,64.3 arc(209.51,64.29) 209.55,64.29 210.38,64.29 v2(210.61,64.52)
CXL_TX_N15: length 81
  L03_SIG1 w0.085: v2(137.47,59.1) 137.72,59 arc(137.82,58.99) 137.9,59.05 137.92,59.08 arc(137.93,59.1) 137.93,59.11 arc(138.05,59.21) 138.21,59.25 138.45,59.25 arc(138.49,59.26) 138.53,59.27 arc(138.57,59.3) 138.61,59.33 138.82,59.55 arc(138.99,59.66) 139.2,59.7 139.25,59.7 arc(139.34,59.73) 139.42,59.8 139.55,60.03 arc(139.72,60.2) 139.94,60.26 140.07,60.26 arc(140.23,60.3) 140.35,60.42 140.41,60.53 arc(140.58,60.7) 140.82,60.76 141.03,60.76 arc(141.11,60.78) 141.19,60.82 141.44,61.08 arc(141.58,61.17) 141.74,61.2 141.83,61.2 arc(141.94,61.23) 142.02,61.31 142.15,61.53 arc(142.32,61.7) 142.55,61.76 142.71,61.76 arc(142.8,61.78) 142.87,61.83 143.02,61.98 arc(143.21,62.1) 143.42,62.15 145.79,62.15 arc(145.81,62.15) 145.83,62.15 150.02,62.98 arc(150.05,62.99) 150.08,62.99 154.42,62.99 arc(154.61,62.96) 154.79,62.87 arc(154.84,62.84) 154.91,62.83 163.62,62.83 arc(163.83,62.87) 164.01,62.99 164.8,63.78 arc(165.12,64) 165.49,64.07 167.35,64.07 arc(168.36,64.27) 169.22,64.83 arc(170.15,65.43) 171.25,65.65 arc(172.22,65.76) 173.15,66.08 arc(173.63,66.27) 174.13,66.39 arc(174.19,66.4) 174.25,66.4 174.36,66.4 arc(175.09,66.25) 175.71,65.84 177.42,64.12 arc(177.65,63.95) 177.92,63.86 arc(177.96,63.85) 178,63.85 187.22,63.85 arc(188.25,64.03) 189.17,64.54 arc(189.2,64.56) 189.22,64.59 arc(189.53,64.78) 189.88,64.85 191.19,64.85 arc(191.24,64.85) 191.29,64.85 191.57,64.88 arc(191.65,64.89) 191.72,64.92 arc(191.78,64.94) 191.84,64.98 arc(191.98,65.07) 192.11,65.18 192.2,65.28 arc(192.44,65.46) 192.71,65.56 arc(192.73,65.57) 192.76,65.57 195.47,65.57 arc(195.87,65.65) 196.21,65.88 196.24,65.91 arc(196.49,66.07) 196.78,66.13 198.21,66.13 arc(198.83,66.25) 199.34,66.6 199.44,66.69 arc(199.64,66.83) 199.87,66.87 200.91,66.87 arc(201.48,66.76) 201.97,66.43 204.03,64.37 arc(204.18,64.27) 204.35,64.24 206.34,64.24 arc(206.4,64.25) 206.45,64.28 207.57,65.41 arc(208.22,65.84) 208.97,65.99 212.26,65.99 v2(212.59,66.32)
CXL_TX_P0: length 91.8
  L03_SIG1 w0.085: v2(211.64,17.14) 211.64,17.14 211.4,17.38 210.86,17.38 arc(210.73,17.41) 210.62,17.48 210.2,17.9 arc(210.02,18.17) 209.96,18.48 209.96,21.9 arc(209.29,23.53) 207.66,24.2 205.71,24.2 arc(204.47,23.96) 203.41,23.25 arc(203.03,22.99) 202.57,22.9 198.7,22.9 arc(197.8,23.08) 197.02,23.6 195.14,25.49 arc(194.71,25.77) 194.2,25.88 185.37,25.88 arc(185.08,25.93) 184.81,26.07 arc(184.76,26.11) 184.71,26.14 arc(183.84,26.41) 182.92,26.51 180.9,26.51 arc(180.25,26.6) 179.65,26.87 arc(179.45,26.98) 179.23,27.07 178.05,27.46 arc(177.96,27.5) 177.86,27.53 arc(177.82,27.54) 177.78,27.54 173.98,27.54 arc(172.1,27.91) 170.52,28.97 169.73,29.76 arc(169.34,30.12) 168.92,30.46 arc(166.78,31.58) 164.39,31.97 arc(161.86,32.47) 159.72,33.9 158.81,34.82 arc(157.76,35.74) 156.59,36.51 arc(155.65,37.1) 154.79,37.79 arc(154.26,38.32) 153.81,38.91 153.68,39.11 arc(153.67,39.13) 153.65,39.14 153.31,39.49 arc(152.52,40.14) 151.63,40.63 arc(151.59,40.65) 151.55,40.66 151.45,40.68 arc(151.14,40.72) 150.82,40.74 148.08,40.74 arc(148.02,40.74) 147.96,40.75 arc(146.74,41.17) 145.7,41.93 145.34,42.29 145.12,42.29 144.99,42.42 144.99,42.64 144.87,42.77 144.64,42.77 144.51,42.9 144.51,43.12 144.39,43.25 144.16,43.25 144.03,43.38 144.03,43.6 143.78,43.86 arc(143.76,43.87) 143.74,43.88 143.73,43.89 143.66,43.91 arc(143.62,43.93) 143.58,43.93 143.48,43.93 arc(143.19,44.01) 142.98,44.22 142.95,44.27 arc(142.83,44.39) 142.67,44.43 142.63,44.43 arc(142.33,44.51) 142.1,44.74 142.08,44.77 arc(141.97,44.89) 141.82,44.94 141.77,44.94 arc(141.55,44.89) 141.36,44.77 141.31,44.71 arc(141.14,44.6) 140.95,44.56 140.86,44.56 arc(140.7,44.52) 140.59,44.41 140.52,44.3 arc(140.32,44.12) 140.06,44.06 arc(139.83,44) 139.67,43.83 139.65,43.8 arc(139.47,43.6) 139.22,43.5 arc(139.2,43.49) 139.18,43.48 139.08,43.45 arc(138.96,43.38) 138.85,43.29 138.78,43.22 arc(138.6,43.1) 138.39,43.06 138.32,43.06 arc(138.12,43.1) 137.96,43.21 137.69,43.48 arc(137.61,43.53) 137.51,43.55 137.41,43.55 arc(137.26,43.58) 137.13,43.67 136.91,43.89 arc(136.82,43.96) 136.71,43.99 arc(136.65,44) 136.59,44.02 arc(136.52,44.04) 136.45,44.07 arc(136.36,44.12) 136.28,44.18 135.97,44.49 arc(135.91,44.53) 135.84,44.54 135.69,44.54 arc(135.55,44.52) 135.44,44.44 135.38,44.38 arc(135.35,44.35) 135.33,44.31 arc(135.3,44.24) 135.27,44.16 arc(135.27,44.12) 135.29,44.07 135.33,44 135.35,43.97 arc(135.4,43.93) 135.46,43.94 135.72,44.09 135.72,44.09 v2(135.73,44.09)
CXL_TX_P1: length 87.3
  L03_SIG1 w0.085: v2(138.33,44.6) 138.1,44.79 arc(138.05,44.95) 138.2,45.05 138.41,45.05 arc(138.6,45.09) 138.76,45.2 138.99,45.43 arc(139.06,45.48) 139.14,45.5 139.21,45.5 arc(139.44,45.56) 139.6,45.72 139.68,45.86 arc(139.83,46) 140.03,46.06 140.09,46.06 arc(140.34,46.12) 140.52,46.3 arc(140.7,46.49) 140.96,46.56 140.98,46.56 arc(141.15,46.59) 141.28,46.68 141.48,46.88 arc(141.59,46.95) 141.73,46.98 arc(141.86,46.96) 141.98,46.89 arc(142.01,46.86) 142.04,46.83 arc(142.17,46.71) 142.32,46.61 142.58,46.5 arc(142.65,46.47) 142.74,46.44 arc(142.84,46.4) 142.91,46.33 143.05,46.14 arc(143.26,45.99) 143.52,45.93 143.61,45.93 arc(143.72,45.91) 143.81,45.85 144.02,45.64 arc(144.18,45.53) 144.37,45.5 144.52,45.5 arc(144.64,45.47) 144.74,45.4 144.81,45.33 arc(144.84,45.29) 144.84,45.25 144.84,45.16 arc(144.85,45.12) 144.88,45.08 144.99,44.97 arc(145.02,44.95) 145.06,44.94 145.16,44.94 arc(145.2,44.93) 145.23,44.91 145.35,44.79 arc(145.37,44.76) 145.38,44.71 145.38,44.62 arc(145.39,44.58) 145.41,44.55 145.53,44.43 arc(145.57,44.41) 145.61,44.4 145.7,44.4 arc(145.74,44.39) 145.77,44.37 147.04,43.1 arc(148.45,42.13) 150.11,41.71 arc(152.59,41.03) 154.62,39.43 155.16,38.79 arc(155.51,38.44) 155.91,38.15 arc(157.09,37.51) 158.33,36.99 163.67,35.09 arc(165.56,34.46) 167.47,33.86 arc(167.8,33.7) 168.07,33.43 arc(168.49,32.9) 168.95,32.41 171,30.36 arc(172.02,29.68) 173.22,29.44 183.49,29.44 arc(184.14,29.37) 184.77,29.18 186.15,28.61 arc(186.53,28.43) 186.88,28.21 186.89,28.21 arc(187.11,28.07) 187.35,27.94 arc(187.41,27.91) 187.47,27.89 187.63,27.86 arc(187.67,27.85) 187.72,27.85 189.55,27.85 arc(190.03,27.75) 190.44,27.48 arc(190.86,27.2) 191.36,27.1 193.37,27.1 arc(194.77,26.82) 195.95,26.03 196.92,25.06 arc(197.56,24.54) 198.31,24.18 arc(198.38,24.16) 198.46,24.15 201.83,24.15 arc(202.51,24.25) 203.15,24.53 arc(203.79,24.81) 204.47,24.91 208.16,24.91 arc(209,24.74) 209.71,24.26 210.25,23.73 arc(210.78,22.93) 210.97,21.98 210.97,19.97 arc(211.2,19.41) 211.76,19.18 212.36,19.18 arc(212.36,19.18) 212.37,19.18 v2(212.59,18.95)
CXL_TX_P2: length 87.1
  L03_SIG1 w0.085: v2(211.48,24.39) 211.48,24.39 arc(211.42,24.55) 211.26,24.62 210.84,24.62 arc(210.56,24.67) 210.32,24.83 209.74,25.41 arc(209.5,25.57) 209.22,25.63 198.71,25.63 arc(197.76,25.82) 196.95,26.36 arc(195.08,27.61) 192.87,28.05 192.31,28.05 arc(191.55,28.2) 190.9,28.63 190.43,29.11 arc(189.28,29.87) 187.92,30.14 186.04,30.14 arc(185.34,30.28) 184.74,30.68 arc(184.15,31.08) 183.44,31.22 176.55,31.22 arc(176.15,31.27) 175.78,31.44 arc(175.17,31.65) 174.53,31.57 arc(173.95,31.36) 173.37,31.16 arc(173.35,31.15) 173.34,31.14 173.06,30.96 arc(172.98,30.92) 172.9,30.9 arc(172.3,30.87) 171.72,30.98 arc(171.65,31.01) 171.59,31.04 171.39,31.18 arc(171.33,31.22) 171.28,31.27 arc(170.86,31.79) 170.5,32.37 arc(169.88,33.28) 169.09,34.05 arc(168.2,34.69) 167.28,35.28 arc(164.22,36.69) 160.95,37.46 arc(158.16,38.31) 155.8,40.01 154.18,41.62 arc(153.43,42.12) 152.55,42.3 152.35,42.3 arc(151.23,42.52) 150.27,43.14 arc(150.24,43.17) 150.22,43.2 arc(149.9,43.44) 149.51,43.52 arc(148.87,43.7) 148.44,44.21 arc(148.27,44.42) 148.02,44.49 147.61,44.49 147.33,44.78 147.15,44.78 146.95,44.98 146.95,45.16 146.75,45.36 146.57,45.36 146.38,45.55 146.38,45.73 146.18,45.93 146,45.93 145.8,46.13 145.8,46.31 145.71,46.4 arc(145.6,46.47) 145.48,46.5 145.24,46.5 145.11,46.37 144.83,46.37 144.7,46.5 144.43,46.5 arc(144.08,46.59) 143.84,46.84 143.77,46.96 arc(143.69,47.03) 143.59,47.06 143.53,47.06 arc(143.25,47.13) 143.05,47.34 143.03,47.36 arc(142.88,47.5) 142.68,47.56 142.58,47.56 arc(142.4,47.59) 142.25,47.7 142.08,47.87 arc(141.99,47.93) 141.89,47.95 141.77,47.95 arc(141.63,47.91) 141.53,47.81 141.44,47.65 arc(141.28,47.49) 141.07,47.43 140.94,47.43 arc(140.76,47.39) 140.63,47.25 140.59,47.19 arc(140.4,47) 140.14,46.93 139.99,46.93 arc(139.87,46.91) 139.77,46.84 139.55,46.62 arc(139.41,46.53) 139.25,46.5 139.21,46.5 arc(139.07,46.46) 138.96,46.35 138.85,46.17 arc(138.68,46) 138.44,45.93 138.23,45.93 arc(137.99,46) 137.81,46.18 137.75,46.27 arc(137.63,46.39) 137.47,46.43 137.37,46.43 arc(137.12,46.5) 136.94,46.68 136.84,46.86 arc(136.74,46.96) 136.6,47 136.53,47 arc(136.45,46.98) 136.37,46.93 136.16,46.72 arc(135.99,46.6) 135.78,46.56 135.7,46.56 arc(135.5,46.51) 135.35,46.36 135.29,46.26 arc(135.27,46.16) 135.29,46.06 135.35,45.97 arc(135.4,45.93) 135.46,45.94 v2(135.73,46.1)
CXL_TX_P3: length 87
  L03_SIG1 w0.085: v2(212.59,26.15) 212.41,26.33 arc(212.37,26.36) 212.33,26.37 211.85,26.37 arc(211.48,26.37) 211.12,26.4 210.43,26.45 arc(210.24,26.49) 210.06,26.59 arc(210.02,26.63) 209.97,26.66 209.52,26.92 arc(209.15,27.07) 208.75,27.12 198.72,27.12 arc(196.99,27.44) 195.48,28.34 arc(194.59,28.86) 193.58,29.05 192.78,29.05 arc(192.7,29.05) 192.62,29.08 arc(192.3,29.24) 192.02,29.46 191.8,29.69 189.86,31.63 arc(188.75,32.37) 187.44,32.63 176.95,32.63 arc(176.04,32.81) 175.27,33.33 174.44,34.16 arc(173.84,34.56) 173.13,34.7 170.89,34.7 arc(170.11,34.86) 169.44,35.3 167.85,36.89 arc(166.92,38.28) 166.6,39.93 166.6,42.88 arc(166.24,43.73) 165.39,44.09 152.88,44.09 arc(151.8,44.3) 150.88,44.92 150.58,45.22 arc(150.23,45.45) 149.81,45.53 148.46,45.53 arc(148.19,45.59) 147.96,45.74 147.68,46.02 147.56,46.02 147.56,46.02 147.44,46.02 147.32,46.14 147.32,46.26 147.32,46.26 147.32,46.38 147.2,46.5 147.08,46.5 147.08,46.5 146.96,46.5 146.84,46.62 146.84,46.74 146.84,46.74 146.84,46.86 146.41,47.3 arc(146.19,47.44) 145.92,47.5 144.37,47.5 arc(144.18,47.53) 144.02,47.64 143.81,47.85 arc(143.72,47.91) 143.61,47.93 143.55,47.93 arc(143.25,48.01) 143.02,48.21 142.95,48.31 arc(142.78,48.46) 142.57,48.52 142.52,48.52 arc(142.27,48.59) 142.08,48.78 142.06,48.82 arc(141.92,48.95) 141.74,48.99 arc(141.69,48.99) 141.64,48.98 arc(141.56,48.95) 141.49,48.89 141.28,48.68 arc(141.15,48.59) 140.98,48.56 140.96,48.56 arc(140.7,48.49) 140.52,48.3 arc(140.34,48.12) 140.09,48.06 140.03,48.06 arc(139.83,48) 139.68,47.86 139.6,47.72 arc(139.44,47.56) 139.21,47.5 139.14,47.5 arc(139.06,47.48) 138.99,47.43 138.76,47.2 arc(138.68,47.13) 138.59,47.08 arc(138.51,47.06) 138.43,47.05 138.2,47.05 arc(138.14,47.04) 138.1,47 138.07,46.94 arc(138.06,46.85) 138.1,46.78 138.32,46.6 v2(138.33,46.6)
CXL_TX_P4: length 88.8
  L03_SIG1 w0.085: v2(135.73,48.1) 135.46,47.94 arc(135.4,47.93) 135.35,47.97 135.28,48.08 arc(135.27,48.15) 135.28,48.22 135.41,48.43 arc(135.44,48.47) 135.48,48.51 arc(135.56,48.55) 135.66,48.56 135.78,48.56 arc(135.99,48.6) 136.16,48.72 136.37,48.93 arc(136.45,48.98) 136.53,49 136.6,49 arc(136.74,48.96) 136.84,48.86 136.94,48.68 arc(137.11,48.51) 137.34,48.43 137.47,48.43 arc(137.63,48.39) 137.75,48.27 137.81,48.18 arc(137.99,48) 138.23,47.93 138.44,47.93 arc(138.68,48) 138.85,48.17 138.96,48.35 arc(139.07,48.46) 139.21,48.5 139.25,48.5 arc(139.41,48.53) 139.55,48.62 139.77,48.84 arc(139.87,48.91) 139.99,48.93 140.14,48.93 arc(140.4,49) 140.59,49.19 140.63,49.26 arc(140.76,49.39) 140.93,49.43 141.07,49.43 arc(141.28,49.49) 141.44,49.65 141.53,49.81 arc(141.63,49.91) 141.77,49.95 141.89,49.95 arc(141.99,49.93) 142.08,49.87 142.25,49.7 arc(142.4,49.59) 142.58,49.56 142.68,49.56 arc(142.9,49.5) 143.05,49.34 143.07,49.32 arc(143.26,49.13) 143.53,49.06 143.6,49.06 arc(143.71,49.03) 143.79,48.94 143.86,48.82 arc(144.1,48.58) 144.43,48.5 144.58,48.5 144.7,48.37 144.98,48.37 145.11,48.5 145.39,48.5 145.52,48.37 145.8,48.37 145.92,48.5 146.2,48.5 146.33,48.37 146.61,48.37 146.74,48.5 146.78,48.5 arc(147,48.45) 147.19,48.33 147.31,48.2 147.31,48.02 147.49,47.84 147.67,47.84 147.97,47.54 arc(148.23,47.37) 148.54,47.31 149.15,47.31 arc(150,47.13) 150.73,46.65 151.3,46.08 arc(152.02,45.6) 152.86,45.43 165.27,45.43 arc(165.29,45.43) 165.31,45.43 165.83,45.32 arc(165.87,45.31) 165.91,45.29 arc(166.21,45.14) 166.5,44.97 arc(166.54,44.94) 166.57,44.92 167.58,43.85 arc(167.64,43.78) 167.68,43.7 167.8,43.4 arc(167.82,43.36) 167.82,43.32 arc(167.84,43.12) 167.85,42.91 arc(167.97,40.79) 168.33,38.7 arc(168.62,37.91) 169.09,37.21 169.23,37.06 arc(170.57,36.16) 172.16,35.84 172.57,35.84 arc(173.86,35.58) 174.95,34.86 175.67,34.13 arc(175.73,34.08) 175.79,34.04 arc(176.47,33.79) 177.18,33.7 177.9,33.7 arc(178.05,33.73) 178.19,33.82 arc(178.32,33.91) 178.48,33.94 189.9,33.94 arc(190.47,33.83) 190.94,33.51 194.21,30.24 arc(194.39,30.12) 194.59,30.08 arc(195.07,29.99) 195.48,29.72 195.69,29.51 arc(197.17,28.52) 198.92,28.17 210.35,28.17 arc(210.39,28.16) 210.42,28.14 v2(210.61,27.95)
CXL_TX_P5: length 87.2
  L03_SIG1 w0.085: v2(212.59,29.75) 212.36,29.98 212.04,29.98 arc(210.01,30.39) 208.28,31.54 207.84,31.98 arc(206.43,32.92) 204.78,33.25 199.88,33.25 arc(199.83,33.24) 199.78,33.21 arc(199.49,33.01) 199.14,32.94 196.26,32.94 arc(195.71,33.05) 195.24,33.36 194.07,34.54 arc(193.33,35.03) 192.46,35.2 177.39,35.2 arc(175.72,35.54) 174.31,36.48 174.14,36.65 arc(173.97,36.91) 173.91,37.2 173.91,38.25 arc(173.94,38.48) 174.02,38.7 arc(174.11,38.91) 174.14,39.14 174.14,41.83 arc(174.1,42) 174.01,42.15 173.83,42.32 arc(173.72,42.5) 173.67,42.71 173.67,42.84 arc(173.08,44.27) 171.65,44.86 169.87,44.86 arc(168.45,45.14) 167.24,45.95 166.92,46.26 arc(166.01,46.87) 164.93,47.09 153.03,47.09 arc(152.42,47.21) 151.9,47.55 151.51,47.95 147.76,49.5 146.12,49.5 146,49.37 145.78,49.37 145.66,49.5 145.44,49.5 145.32,49.37 145.1,49.37 144.98,49.5 144.49,49.5 arc(144.19,49.56) 143.94,49.73 143.81,49.85 arc(143.72,49.91) 143.61,49.93 143.52,49.93 arc(143.19,50.02) 142.96,50.25 142.95,50.26 arc(142.83,50.39) 142.66,50.43 142.59,50.43 arc(142.32,50.51) 142.12,50.7 142.06,50.82 arc(141.94,50.94) 141.78,50.98 141.69,50.98 arc(141.59,50.96) 141.5,50.9 141.28,50.68 arc(141.15,50.59) 140.98,50.56 140.96,50.56 arc(140.7,50.49) 140.52,50.3 arc(140.34,50.12) 140.09,50.06 140.03,50.06 arc(139.83,50) 139.68,49.86 139.6,49.72 arc(139.44,49.56) 139.21,49.5 139.14,49.5 arc(139.06,49.48) 138.99,49.43 138.73,49.18 arc(138.59,49.08) 138.43,49.05 138.18,49.05 arc(138.14,49.04) 138.1,49.02 arc(138.05,48.96) 138.05,48.88 138.06,48.82 v2(138.33,48.6)
CXL_TX_P6: length 87.6
  L03_SIG1 w0.085: v2(210.61,35.15) 210.41,35.35 arc(210.38,35.37) 210.34,35.38 210.24,35.38 arc(209.91,35.32) 209.63,35.13 209.52,35.02 arc(209.28,34.86) 208.99,34.8 207.03,34.8 arc(206.76,34.86) 206.53,35.01 arc(206.3,35.16) 206.04,35.22 202.72,35.22 arc(202.59,35.19) 202.47,35.11 arc(201.6,34.53) 200.56,34.32 196.5,34.32 arc(196.14,34.39) 195.84,34.6 195.26,35.18 arc(193.82,36.13) 192.13,36.47 179.31,36.47 arc(178.29,36.67) 177.43,37.25 177.17,37.51 177.01,37.67 arc(176.52,38.4) 176.35,39.27 176.35,41.3 arc(176.34,41.39) 176.32,41.48 arc(176.22,41.68) 176.07,41.86 175.79,42.14 arc(175.52,42.54) 175.43,43.02 arc(175.24,43.95) 174.71,44.74 173.67,45.78 arc(173.28,46.04) 172.82,46.13 170.97,46.13 arc(169.84,46.36) 168.88,47 167.73,48.16 arc(166.5,48.98) 165.06,49.26 151.58,49.26 arc(150.47,49.48) 149.54,50.11 149.18,50.47 arc(149.15,50.49) 149.12,50.5 146.62,50.5 146.46,50.33 146.28,50.33 146.12,50.5 145.94,50.5 145.78,50.33 145.61,50.33 145.44,50.5 145.27,50.5 145.1,50.33 144.93,50.33 144.76,50.5 144.43,50.5 arc(144.09,50.59) 143.84,50.84 143.8,50.9 arc(143.69,51.02) 143.53,51.06 143.51,51.06 arc(143.23,51.14) 143.02,51.35 143.01,51.38 arc(142.89,51.51) 142.71,51.56 142.58,51.56 arc(142.4,51.6) 142.25,51.7 142.08,51.87 arc(141.99,51.93) 141.89,51.95 141.77,51.95 arc(141.63,51.91) 141.53,51.81 141.44,51.65 arc(141.28,51.49) 141.07,51.43 140.94,51.43 arc(140.76,51.39) 140.63,51.26 140.62,51.24 arc(140.4,51.01) 140.1,50.93 139.99,50.93 arc(139.87,50.91) 139.77,50.84 139.55,50.62 arc(139.41,50.53) 139.25,50.5 139.21,50.5 arc(139.07,50.46) 138.96,50.35 138.85,50.17 arc(138.68,50) 138.44,49.93 138.23,49.93 arc(137.99,50) 137.81,50.18 137.75,50.27 arc(137.63,50.39) 137.47,50.43 137.37,50.43 arc(137.12,50.5) 136.94,50.68 136.84,50.86 arc(136.74,50.96) 136.6,51 136.53,51 arc(136.45,50.98) 136.37,50.93 136.16,50.72 arc(135.99,50.6) 135.78,50.56 135.64,50.56 arc(135.49,50.52) 135.38,50.41 135.29,50.26 arc(135.27,50.16) 135.29,50.07 135.35,49.97 arc(135.4,49.93) 135.46,49.94 v2(135.73,50.1)
CXL_TX_P7: length 82.7
  L03_SIG1 w0.085: v2(212.59,36.95) 212.35,37.2 209.4,37.2 arc(209.23,37.16) 209.08,37.06 209,36.98 arc(208.58,36.7) 208.1,36.6 204.8,36.6 arc(203.22,37.1) 202.22,38.42 arc(201.93,39.01) 201.53,39.52 200.74,40.3 arc(200.32,40.58) 199.82,40.68 198.93,40.68 arc(197.74,40.92) 196.73,41.59 194.87,43.46 arc(194.18,43.91) 193.38,44.07 179.97,44.07 arc(179.52,44.25) 179.32,44.69 arc(179.31,44.73) 179.3,44.77 arc(179.11,45.14) 178.77,45.38 arc(178.72,45.4) 178.67,45.41 arc(177.37,45.82) 176.26,46.61 173.83,49.05 arc(173.51,49.26) 173.14,49.33 169.86,49.33 arc(169.02,49.5) 168.31,49.98 168.11,50.18 arc(167.56,50.55) 166.91,50.68 151.91,50.68 arc(151.21,50.79) 150.58,51.11 arc(150.55,51.13) 150.52,51.16 150.55,51.13 arc(150.56,51.13) 150.56,51.13 150.15,51.53 arc(149.95,51.67) 149.71,51.72 149.31,51.72 arc(149.24,51.7) 149.18,51.66 arc(149,51.54) 148.78,51.5 145.34,51.5 145.2,51.35 145,51.35 144.86,51.5 144.43,51.5 arc(144.2,51.54) 144,51.67 143.83,51.85 arc(143.73,51.91) 143.62,51.93 143.52,51.93 arc(143.19,52.02) 142.96,52.25 142.95,52.26 arc(142.83,52.39) 142.66,52.43 142.6,52.43 arc(142.32,52.51) 142.12,52.71 142.06,52.82 arc(141.94,52.94) 141.78,52.98 141.69,52.98 arc(141.59,52.96) 141.5,52.9 141.28,52.68 arc(141.15,52.59) 140.98,52.56 140.96,52.56 arc(140.7,52.49) 140.52,52.3 arc(140.34,52.12) 140.09,52.06 140.03,52.06 arc(139.83,52) 139.68,51.86 139.6,51.72 arc(139.44,51.56) 139.21,51.5 139.14,51.5 arc(139.06,51.48) 138.99,51.43 138.75,51.19 arc(138.7,51.14) 138.64,51.11 arc(138.55,51.07) 138.45,51.05 138.22,51.05 arc(138.15,51.04) 138.1,50.98 138.07,50.94 arc(138.06,50.85) 138.12,50.77 v2(138.33,50.6)
CXL_TX_P8: length 81.7
  L03_SIG1 w0.085: v2(210.61,45.86) 210.38,46.08 210.25,46.08 arc(209.69,46.31) 209.44,46.85 arc(209.44,46.89) 209.43,46.94 arc(209.14,47.49) 208.58,47.78 arc(208.54,47.78) 208.5,47.79 203.14,47.79 arc(202.94,47.81) 202.75,47.89 arc(202.56,47.96) 202.36,47.99 201.6,47.99 arc(200.9,47.9) 200.25,47.64 arc(199.68,47.39) 199.06,47.28 195.96,47.28 arc(195.47,47.21) 195.02,47 arc(194.46,46.74) 193.85,46.65 179.21,46.65 arc(177.42,47) 175.89,48.02 174.52,49.4 arc(173.58,50.02) 172.48,50.24 170.13,50.24 arc(169.76,50.31) 169.46,50.52 169.27,50.71 arc(168.27,51.37) 167.09,51.61 151.98,51.61 arc(151.5,51.7) 151.08,51.98 151.02,52.05 arc(150.52,52.38) 149.94,52.5 147.47,52.5 147.34,52.37 147.13,52.37 147,52.5 146.79,52.5 146.67,52.37 146.45,52.37 146.33,52.5 146.11,52.5 145.99,52.37 145.77,52.37 145.65,52.5 145.43,52.5 145.31,52.37 145.09,52.37 144.97,52.5 144.43,52.5 arc(144.1,52.58) 143.87,52.82 143.83,52.89 arc(143.7,53.01) 143.54,53.06 143.53,53.06 arc(143.26,53.13) 143.07,53.32 143.05,53.34 arc(142.9,53.5) 142.68,53.56 142.58,53.56 arc(142.4,53.6) 142.25,53.7 142.08,53.87 arc(141.99,53.93) 141.89,53.95 141.77,53.95 arc(141.63,53.91) 141.53,53.81 141.44,53.65 arc(141.28,53.49) 141.07,53.43 140.94,53.43 arc(140.76,53.39) 140.63,53.26 140.59,53.19 arc(140.4,53) 140.14,52.93 139.99,52.93 arc(139.87,52.91) 139.77,52.84 139.55,52.62 arc(139.41,52.53) 139.25,52.5 139.21,52.5 arc(139.07,52.46) 138.96,52.35 138.85,52.17 arc(138.68,52) 138.44,51.93 138.23,51.93 arc(137.99,52) 137.81,52.18 137.75,52.27 arc(137.63,52.39) 137.47,52.43 137.34,52.43 arc(137.11,52.51) 136.94,52.68 136.84,52.86 arc(136.74,52.96) 136.6,53 136.53,53 arc(136.45,52.98) 136.37,52.93 136.16,52.72 arc(135.99,52.6) 135.78,52.56 135.66,52.56 arc(135.56,52.55) 135.48,52.51 arc(135.43,52.47) 135.39,52.41 135.28,52.22 arc(135.26,52.16) 135.28,52.1 135.35,51.97 arc(135.4,51.93) 135.46,51.94 v2(135.73,52.1)
CXL_TX_P9: length 79.5
  L03_SIG1 w0.085: v2(212.59,47.66) 212.35,47.9 arc(212.31,47.92) 212.27,47.93 210.25,47.93 arc(209.91,48) 209.62,48.2 209.44,48.37 arc(208.74,48.84) 207.92,49 207.01,49 arc(206.88,48.97) 206.78,48.9 arc(206.29,48.58) 205.71,48.46 203.59,48.46 arc(203.37,48.51) 203.19,48.63 arc(202.93,48.8) 202.62,48.86 191.73,48.86 arc(191.68,48.86) 191.64,48.84 arc(191.45,48.74) 191.27,48.63 arc(190.2,48.09) 189.01,47.9 177.91,47.9 arc(177.23,48.03) 176.65,48.42 176.51,48.56 175.55,49.52 arc(173.89,50.63) 171.93,51.02 170.86,51.02 arc(170.45,51.1) 170.11,51.33 arc(168.79,52.21) 167.23,52.52 153.89,52.52 arc(153.44,52.61) 153.06,52.86 152.32,53.6 arc(151.73,54) 151.04,54.14 149.5,54.14 arc(149.45,54.13) 149.41,54.13 arc(149.21,54.07) 149.02,53.96 arc(148.99,53.94) 148.95,53.91 148.9,53.86 arc(148.47,53.59) 147.98,53.5 145.95,53.5 145.83,53.38 145.55,53.38 145.44,53.5 145.16,53.5 145.05,53.38 144.77,53.38 144.65,53.5 144.37,53.5 arc(144.18,53.53) 144.02,53.64 143.81,53.85 arc(143.72,53.91) 143.61,53.93 143.52,53.93 arc(143.19,54.02) 142.96,54.25 142.95,54.26 arc(142.83,54.39) 142.66,54.43 142.57,54.43 arc(142.32,54.5) 142.13,54.69 142.06,54.82 arc(141.94,54.94) 141.78,54.98 141.69,54.98 arc(141.59,54.96) 141.5,54.9 141.28,54.68 arc(141.15,54.59) 140.98,54.56 140.96,54.56 arc(140.7,54.49) 140.52,54.3 arc(140.34,54.12) 140.09,54.06 140.03,54.06 arc(139.83,54) 139.68,53.86 139.59,53.7 arc(139.43,53.54) 139.2,53.48 139.15,53.48 arc(139.04,53.46) 138.96,53.4 138.72,53.16 arc(138.6,53.08) 138.47,53.06 138.23,53.06 arc(138.15,53.04) 138.1,52.98 138.07,52.94 arc(138.06,52.85) 138.12,52.78 v2(138.33,52.6)
CXL_TX_P10: length 82.4
  L03_SIG1 w0.085: v2(135.73,54.1) 135.46,53.94 arc(135.4,53.93) 135.35,53.97 135.29,54.07 arc(135.27,54.15) 135.29,54.24 135.35,54.34 arc(135.51,54.5) 135.73,54.56 135.78,54.56 arc(135.99,54.6) 136.16,54.72 136.37,54.93 arc(136.45,54.98) 136.53,55 136.6,55 arc(136.74,54.96) 136.84,54.86 136.95,54.66 arc(137.12,54.49) 137.35,54.43 137.47,54.43 arc(137.64,54.39) 137.75,54.27 137.81,54.18 arc(137.99,54) 138.23,53.93 138.44,53.93 arc(138.68,54) 138.85,54.17 138.96,54.35 arc(139.07,54.46) 139.21,54.5 139.25,54.5 arc(139.41,54.53) 139.55,54.62 139.77,54.84 arc(139.87,54.91) 139.99,54.93 140.14,54.93 arc(140.4,55.01) 140.6,55.2 140.63,55.26 arc(140.76,55.39) 140.94,55.43 141.07,55.43 arc(141.28,55.49) 141.44,55.65 141.53,55.81 arc(141.63,55.91) 141.77,55.95 141.89,55.95 arc(141.99,55.93) 142.08,55.87 142.25,55.7 arc(142.4,55.6) 142.58,55.56 142.68,55.56 arc(142.9,55.5) 143.05,55.34 143.07,55.32 arc(143.26,55.13) 143.53,55.06 143.67,55.06 arc(143.72,55.04) 143.76,55 143.88,54.8 arc(143.92,54.73) 143.98,54.67 144,54.66 arc(144.21,54.55) 144.45,54.51 144.97,54.51 145.1,54.38 145.31,54.38 145.44,54.51 145.64,54.51 145.78,54.38 145.98,54.38 146.12,54.51 146.32,54.51 146.46,54.38 146.66,54.38 146.79,54.51 147,54.51 147.13,54.38 147.34,54.38 147.47,54.51 148.09,54.51 arc(148.42,54.55) 148.74,54.67 arc(148.89,54.75) 149.06,54.8 arc(149.1,54.81) 149.14,54.81 151.82,54.81 arc(151.86,54.8) 151.9,54.79 arc(152.38,54.56) 152.79,54.22 152.99,54.03 arc(153.51,53.68) 154.12,53.56 167.58,53.56 arc(169.05,53.27) 170.3,52.43 170.4,52.33 arc(170.96,51.96) 171.62,51.83 173.66,51.83 arc(174.13,51.73) 174.53,51.47 174.91,51.08 arc(175.17,50.91) 175.47,50.85 arc(175.7,50.87) 175.92,50.93 176.69,51.24 arc(176.82,51.28) 176.95,51.29 184.19,51.29 arc(184.92,51.44) 185.54,51.85 185.55,51.86 arc(185.94,52.12) 186.39,52.21 189.48,52.21 arc(193.46,53) 196.84,55.26 197.25,55.67 arc(197.5,55.88) 197.78,56.04 198.41,56.34 arc(198.66,56.42) 198.93,56.45 203.97,56.45 arc(204.01,56.45) 204.05,56.45 arc(205.09,56.17) 205.97,55.56 207.06,54.47 arc(208.37,53.59) 209.92,53.28 210.15,53.28 arc(210.36,53.24) 210.54,53.12 v2(210.61,53.06)
CXL_TX_P11: length 83
  L03_SIG1 w0.085: v2(138.33,54.6) 138.1,54.79 arc(138.04,54.89) 138.07,55 arc(138.19,55.09) 138.34,55.13 138.57,55.13 arc(138.68,55.15) 138.77,55.21 138.99,55.43 arc(139.06,55.48) 139.14,55.5 139.21,55.5 arc(139.44,55.56) 139.6,55.72 139.68,55.86 arc(139.83,56) 140.03,56.06 140.09,56.06 arc(140.34,56.12) 140.52,56.3 arc(140.7,56.49) 140.96,56.56 140.98,56.56 arc(141.15,56.59) 141.28,56.68 141.5,56.9 arc(141.59,56.96) 141.69,56.98 141.78,56.98 arc(141.94,56.94) 142.06,56.82 142.12,56.71 arc(142.32,56.51) 142.6,56.43 142.66,56.43 arc(142.83,56.39) 142.95,56.26 142.96,56.25 arc(143.19,56.02) 143.52,55.93 143.61,55.93 arc(143.72,55.91) 143.81,55.85 144.02,55.64 arc(144.18,55.53) 144.37,55.5 144.51,55.5 144.64,55.36 144.89,55.36 145.02,55.5 145.8,55.5 145.89,55.41 146.23,55.41 146.28,55.46 arc(146.31,55.49) 146.34,55.5 arc(146.35,55.5) 146.36,55.5 146.56,55.5 arc(146.81,55.55) 147.02,55.69 147.13,55.79 arc(147.52,56.06) 147.99,56.15 151.44,56.15 arc(153.09,56.48) 154.48,57.41 155.19,58.12 arc(155.48,58.31) 155.82,58.38 165.69,58.38 arc(166.37,58.1) 166.65,57.43 166.65,55.89 arc(167.02,54.98) 167.94,54.6 arc(169.02,54.38) 169.93,53.77 170.23,53.47 arc(171.19,52.83) 172.32,52.61 175.34,52.61 arc(175.49,52.59) 175.63,52.53 arc(175.68,52.51) 175.73,52.49 arc(175.81,52.45) 175.89,52.4 arc(175.95,52.36) 176.01,52.32 arc(176.05,52.29) 176.08,52.27 arc(176.31,52.13) 176.56,52.09 177.44,52.09 arc(177.52,52.09) 177.6,52.12 arc(177.69,52.14) 177.77,52.14 183.57,52.14 arc(183.63,52.15) 183.69,52.15 arc(184.34,52.32) 184.95,52.6 185.42,52.87 arc(186.06,53.14) 186.75,53.23 188.46,53.23 arc(192.68,54.05) 196.29,56.39 arc(196.47,56.55) 196.68,56.69 arc(197.29,56.98) 197.93,57.16 arc(197.97,57.17) 198.02,57.17 205.8,57.17 arc(206.69,56.99) 207.45,56.49 208.22,55.71 arc(208.92,55.25) 209.73,55.08 212.39,55.08 arc(212.53,55.03) 212.59,54.88 v2(212.59,54.86)
