# Allegro board FM85_AGILEX_PCIE_DK_CMC_ADI_REVC.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CXL_RX_N1: length 90.7
  TOP w0.116: J6.A6 v6(222.08,19.58)
  L16_SIG6 w0.085: v6(222.08,19.58) 221.96,19.47 arc(221.9,19.43) 221.83,19.42 216.13,19.42 arc(215.9,19.44) 215.67,19.49 215.45,19.57 arc(215.41,19.58) 215.37,19.6 212.71,20.86 arc(212.48,20.98) 212.25,21.12 arc(212.1,21.22) 211.97,21.33 arc(211.68,21.63) 211.41,21.95 211.41,21.95 arc(211.39,21.98) 211.37,22.02 211.15,22.55 arc(211.11,22.67) 211.07,22.79 arc(210.84,23.35) 210.46,23.84 209.98,24.32 arc(209.07,24.93) 207.99,25.14 204.39,25.14 arc(203.7,25) 203.1,24.61 arc(202.59,24.26) 201.98,24.14 199.76,24.14 arc(198.25,24.44) 196.97,25.3 195.92,26.35 arc(194.87,27.05) 193.63,27.3 189.32,27.3 arc(188.04,27.55) 186.96,28.27 arc(185.49,29.26) 183.75,29.6 173.72,29.6 arc(172.11,29.92) 170.76,30.83 168.44,33.15 arc(165.84,34.88) 162.78,35.49 162.55,35.49 arc(159.95,36.01) 157.75,37.48 153.16,42.07 arc(152.85,42.27) 152.49,42.34 147.48,42.34 arc(147.14,42.41) 146.85,42.61 145.59,43.87 145,44.46 arc(144.73,44.64) 144.42,44.7 144.33,44.7 arc(144.19,44.73) 144.09,44.83 143.97,45.04 arc(143.81,45.2) 143.59,45.26 143.41,45.26 arc(143.27,45.23) 143.16,45.15 arc(142.99,45.04) 142.78,45.05 v1(142.66,45.1)
CXL_RX_N2: length 92.3
  TOP w0.116: v6(222.08,24.98) J6.A15
  L16_SIG6 w0.085: v1(140.06,45.6) 140.34,45.75 arc(140.38,45.81) 140.37,45.87 140.31,45.96 arc(140.26,46.16) 140.31,46.36 140.39,46.5 arc(140.59,46.69) 140.85,46.76 140.98,46.76 arc(141.1,46.79) 141.21,46.86 141.36,47.01 arc(141.53,47.12) 141.72,47.16 141.82,47.16 arc(142.06,47.1) 142.23,46.92 142.31,46.78 arc(142.42,46.67) 142.57,46.63 142.67,46.63 arc(142.93,46.56) 143.13,46.37 143.18,46.28 arc(143.28,46.17) 143.43,46.13 143.66,46.13 arc(143.9,46.07) 144.08,45.89 144.12,45.83 arc(144.21,45.73) 144.34,45.7 146.24,45.7 146.46,45.6 147.83,44.24 arc(148.35,43.89) 148.97,43.77 152.45,43.77 arc(153,43.66) 153.46,43.35 157.62,39.19 arc(159.37,38.03) 161.43,37.62 161.6,37.62 arc(164.94,36.95) 167.77,35.06 170.74,32.09 arc(170.77,32.06) 170.81,32.05 171.02,31.99 arc(171.13,31.94) 171.21,31.84 171.47,31.38 arc(171.62,31.22) 171.83,31.17 173.43,31.17 arc(173.51,31.18) 173.57,31.22 173.76,31.42 arc(173.92,31.52) 174.1,31.55 175.92,31.55 arc(176.15,31.51) 176.34,31.38 arc(176.41,31.34) 176.48,31.32 183.31,31.32 arc(183.39,31.32) 183.48,31.32 185.57,31.32 arc(188.31,30.77) 190.63,29.22 190.88,28.97 arc(191.69,28.43) 192.65,28.24 192.91,28.24 arc(195.14,27.79) 197.04,26.53 arc(197.81,26.01) 198.73,25.83 209,25.83 arc(209.84,25.71) 210.62,25.36 arc(211.56,24.93) 212.59,24.79 221.8,24.79 arc(221.87,24.8) 221.93,24.84 v6(222.08,24.98)
CXL_RX_N3: length 91.1
  TOP w0.116: J6.A18 v6(222.08,26.78)
  L16_SIG6 w0.085: v1(142.66,47.1) 142.78,47.05 arc(142.99,47.04) 143.16,47.15 arc(143.27,47.23) 143.41,47.26 143.6,47.26 arc(143.81,47.21) 143.96,47.05 144.08,46.85 arc(144.19,46.74) 144.34,46.7 147.18,46.7 147.54,46.55 148.35,45.74 148.58,45.65 151.58,45.65 153.11,45.01 153.36,45.01 arc(153.73,44.94) 154.04,44.74 154.54,44.23 arc(155.17,43.81) 155.92,43.66 166.32,43.66 arc(166.66,43.52) 166.81,43.18 166.81,41.28 arc(167.38,38.41) 169,35.98 169.54,35.44 arc(170.16,35.03) 170.88,34.88 173.25,34.88 arc(173.95,34.74) 174.54,34.35 175.63,33.25 arc(175.84,33.08) 176.08,32.96 arc(176.33,32.88) 176.6,32.85 187.85,32.85 arc(187.91,32.85) 187.97,32.84 arc(189.07,32.45) 190.01,31.76 192.18,29.59 arc(192.63,29.28) 193.18,29.17 194.02,29.17 arc(194.88,29) 195.6,28.52 arc(196.96,27.61) 198.57,27.29 209.56,27.29 arc(209.62,27.29) 209.68,27.28 arc(209.74,27.27) 209.79,27.24 210.29,26.91 arc(210.83,26.67) 211.41,26.59 221.83,26.59 arc(221.87,26.59) 221.91,26.62 v6(222.08,26.78)
CXL_RX_N4: length 94.7
  TOP w0.116: J6.A21 v6(222.08,28.58)
  L16_SIG6 w0.085: v6(222.08,28.58) 221.9,28.4 arc(221.87,28.39) 221.84,28.38 198.03,28.38 arc(197.99,28.38) 197.95,28.39 arc(197.02,28.67) 196.24,29.23 195.34,30.14 arc(194.95,30.4) 194.49,30.49 arc(194.28,30.53) 194.1,30.65 191.14,33.62 arc(190.56,34) 189.89,34.13 177.93,34.13 arc(177.86,34.13) 177.78,34.11 177.37,33.96 arc(177.35,33.95) 177.32,33.95 177.07,33.91 arc(177.02,33.91) 176.98,33.91 arc(175.96,34.22) 175.09,34.84 174.75,35.17 arc(173.76,35.83) 172.6,36.06 171.78,36.06 arc(170.59,36.3) 169.59,36.97 arc(168.47,38.65) 168.07,40.63 168.07,42.78 arc(167.61,43.9) 166.49,44.36 156.48,44.36 arc(155.85,44.49) 155.32,44.85 154.57,45.59 arc(154.26,45.8) 153.88,45.88 152.79,45.88 151.17,46.54 150.02,46.54 149.57,46.73 149.14,47.16 148.93,47.25 148.66,47.25 148.42,47.34 148.13,47.63 147.98,47.7 144.34,47.7 arc(144.21,47.73) 144.12,47.83 144.08,47.89 arc(143.9,48.07) 143.66,48.13 143.43,48.13 arc(143.28,48.17) 143.18,48.28 143.13,48.37 arc(142.93,48.56) 142.67,48.64 142.57,48.64 arc(142.42,48.67) 142.31,48.78 142.23,48.92 arc(142.06,49.1) 141.82,49.16 141.72,49.16 arc(141.53,49.12) 141.36,49.01 141.21,48.86 arc(141.1,48.79) 140.98,48.76 140.85,48.76 arc(140.59,48.69) 140.39,48.5 140.31,48.36 arc(140.26,48.16) 140.31,47.96 140.37,47.87 arc(140.38,47.81) 140.34,47.75 v1(140.06,47.6)
CXL_RX_N5: length 92.1
  TOP w0.116: J6.A24 v6(222.08,30.38)
  L16_SIG6 w0.085: v1(142.66,49.1) 142.92,49 arc(143.02,49) 143.1,49.06 143.12,49.1 arc(143.24,49.22) 143.41,49.26 143.61,49.26 arc(143.64,49.26) 143.66,49.26 arc(143.77,49.25) 143.87,49.2 arc(143.93,49.14) 143.97,49.08 144.08,48.89 arc(144.22,48.75) 144.41,48.7 147.78,48.7 148.26,48.9 148.87,48.9 149.24,48.74 149.57,48.41 149.79,47.89 arc(149.81,47.85) 149.84,47.82 149.9,47.76 arc(149.93,47.73) 149.97,47.71 150.51,47.49 arc(150.55,47.47) 150.59,47.47 151.58,47.47 arc(151.66,47.46) 151.73,47.45 151.83,47.41 arc(151.9,47.38) 151.96,47.33 arc(152.15,47.21) 152.37,47.16 153.89,47.16 arc(154.37,47.07) 154.78,46.79 155.41,46.16 155.84,45.73 arc(156.5,45.29) 157.28,45.14 167.36,45.14 arc(167.62,45.11) 167.87,45.04 arc(168.04,44.99) 168.23,44.98 171.82,44.98 arc(173.26,44.38) 173.85,42.94 173.85,42.73 arc(173.88,42.6) 173.96,42.48 174.02,42.42 arc(174.09,42.32) 174.11,42.2 174.11,38.57 arc(174.09,38.46) 174.04,38.37 arc(173.99,38.28) 173.97,38.17 173.97,37.53 arc(174.05,37.14) 174.27,36.82 174.86,36.22 arc(175.77,35.62) 176.84,35.4 192.31,35.4 arc(193.42,35.18) 194.36,34.55 195.36,33.55 arc(195.8,33.26) 196.31,33.16 199.23,33.16 arc(199.43,33.2) 199.6,33.31 arc(199.74,33.41) 199.91,33.44 204.69,33.44 arc(206.44,33.09) 207.92,32.1 arc(208.07,31.96) 208.23,31.83 arc(208.27,31.8) 208.31,31.79 208.43,31.75 arc(208.47,31.74) 208.51,31.74 212.77,31.74 arc(213.16,31.66) 213.48,31.44 214.31,30.62 arc(214.79,30.3) 215.35,30.19 221.88,30.19 v6(222.08,30.38)
CXL_RX_N6: length 93
  TOP w0.116: J6.A33 v6(222.08,35.78)
  L16_SIG6 w0.085: v6(222.08,35.78) 221.91,35.62 arc(221.87,35.59) 221.83,35.59 215.13,35.59 arc(214.6,35.51) 214.12,35.3 arc(213.73,35.13) 213.32,35.07 207.98,35.07 arc(207.66,35.12) 207.36,35.24 arc(207.07,35.37) 206.75,35.41 202.83,35.41 arc(202.48,35.34) 202.18,35.14 arc(201.5,34.69) 200.7,34.53 197.24,34.53 arc(196.31,34.71) 195.51,35.24 arc(193.93,36.3) 192.06,36.68 179.15,36.68 arc(179.1,36.68) 179.06,36.68 arc(178.26,36.9) 177.59,37.38 176.93,38.03 arc(176.66,38.45) 176.56,38.93 176.56,41.97 arc(176.52,42.18) 176.4,42.35 175.61,43.14 arc(175.56,43.23) 175.54,43.33 arc(175.51,43.52) 175.46,43.7 arc(175.38,43.88) 175.26,44.05 175.08,44.26 174.23,45.1 arc(173.59,45.53) 172.83,45.68 169.97,45.68 arc(169.5,45.75) 169.07,45.94 169.01,45.98 arc(168.67,46.13) 168.3,46.18 158.15,46.18 arc(156.67,46.48) 155.42,47.31 arc(155,47.64) 154.51,47.86 arc(154.44,47.87) 154.37,47.88 152.81,47.88 arc(152.77,47.88) 152.73,47.89 149.99,49.03 arc(149.95,49.05) 149.92,49.07 149.61,49.39 arc(149.5,49.47) 149.38,49.54 148.99,49.7 144.32,49.7 arc(144.21,49.73) 144.13,49.81 144.08,49.89 arc(143.9,50.07) 143.66,50.14 143.43,50.14 arc(143.28,50.17) 143.18,50.28 143.13,50.37 arc(142.93,50.56) 142.67,50.64 142.57,50.64 arc(142.42,50.67) 142.31,50.78 142.23,50.92 arc(142.06,51.1) 141.82,51.16 141.72,51.16 arc(141.53,51.12) 141.36,51.01 141.21,50.86 arc(141.1,50.79) 140.98,50.76 140.85,50.76 arc(140.59,50.69) 140.39,50.5 140.31,50.36 arc(140.26,50.16) 140.31,49.96 140.37,49.87 arc(140.38,49.81) 140.34,49.75 v1(140.06,49.6)
CXL_RX_N7: length 88.2
  TOP w0.116: J6.A36 v6(222.08,37.58)
  L16_SIG6 w0.085: v6(222.08,37.58) 221.88,37.39 209.26,37.39 arc(209.09,37.35) 208.94,37.26 208.53,36.85 arc(208.22,36.63) 207.84,36.56 202.04,36.56 201.88,36.5 arc(201.5,36.38) 201.11,36.27 200.99,36.24 199.74,36.24 arc(199.7,36.25) 199.66,36.26 arc(198.88,36.73) 198.34,37.46 arc(198.27,37.65) 198.24,37.86 arc(197.95,39.06) 197.25,40.08 196.76,40.56 arc(195.43,41.46) 193.85,41.77 179.96,41.77 arc(179.57,41.85) 179.24,42.07 179.21,42.1 arc(179.2,42.11) 179.2,42.11 178.91,42.4 178.9,42.4 178.58,42.72 arc(178.43,42.95) 178.37,43.23 178.37,44.35 arc(178.29,44.77) 178.05,45.12 177.96,45.21 arc(177.56,45.48) 177.09,45.57 175.54,45.57 arc(175.04,45.67) 174.61,45.96 174.44,46.13 arc(174.04,46.4) 173.56,46.5 170.58,46.5 arc(170.11,46.56) 169.67,46.74 arc(169.23,46.91) 168.76,46.97 158.09,46.97 arc(157.08,47.17) 156.23,47.74 156.06,47.91 arc(155.25,48.45) 154.29,48.64 153.8,48.64 arc(153.6,48.66) 153.41,48.72 152.98,48.9 arc(152.9,48.92) 152.82,48.93 152.48,48.93 arc(152.44,48.94) 152.4,48.95 150.24,49.84 arc(150.2,49.86) 150.17,49.89 149.92,50.14 arc(149.78,50.25) 149.63,50.33 148.75,50.7 144.41,50.7 arc(144.2,50.75) 144.05,50.9 143.98,51.02 arc(143.81,51.2) 143.57,51.26 143.41,51.26 arc(143.24,51.22) 143.12,51.1 143.1,51.06 arc(143.02,51) 142.92,51 v1(142.66,51.1)
CXL_RX_N8: length 96.9
  TOP w0.116: J7.A3 v6(222.08,46.49)
  L16_SIG6 w0.085: v6(222.08,46.49) 221.99,46.4 arc(221.87,46.32) 221.74,46.29 arc(221.73,46.29) 221.73,46.29 214.88,46.29 arc(214.09,46.13) 213.42,45.68 arc(212.91,44.92) 212.73,44.03 212.73,42.17 arc(212.04,40.5) 210.36,39.8 209.65,39.8 arc(209.06,39.56) 208.82,38.97 arc(208.75,38.62) 208.54,38.31 208.03,37.8 arc(207.4,37.38) 206.66,37.23 203.42,37.23 arc(203.14,37.29) 202.9,37.45 202.37,37.98 arc(201.93,38.58) 201.7,39.3 arc(201.66,39.5) 201.6,39.7 201.46,40.12 arc(201.43,40.2) 201.38,40.27 arc(201.18,40.48) 200.96,40.68 arc(200.67,40.86) 200.33,40.96 arc(199.59,41.18) 198.96,41.63 197.99,42.61 arc(197.64,42.83) 197.24,42.91 196.76,42.91 arc(196.16,43.03) 195.64,43.38 195.11,43.91 arc(193.28,45.14) 191.11,45.57 179.07,45.57 arc(179.05,45.57) 179.03,45.57 178.67,45.64 arc(178.63,45.65) 178.6,45.67 178.25,46.02 arc(177.66,46.42) 176.96,46.56 arc(176.6,46.64) 176.3,46.84 173.91,49.23 arc(173.74,49.37) 173.54,49.49 arc(173.46,49.53) 173.37,49.54 170.31,49.54 arc(170.19,49.52) 170.09,49.46 169.93,49.32 arc(169.89,49.29) 169.85,49.29 155.63,49.29 155.61,49.31 155.18,49.31 arc(154.59,49.43) 154.09,49.77 152.61,51.24 arc(151.86,51.74) 150.97,51.92 148.91,51.92 148.38,51.7 144.4,51.7 arc(144.22,51.75) 144.09,51.88 144.08,51.89 arc(143.9,52.07) 143.66,52.14 143.43,52.14 arc(143.28,52.17) 143.18,52.28 143.13,52.37 arc(142.93,52.56) 142.67,52.64 142.57,52.64 arc(142.42,52.68) 142.31,52.78 142.23,52.92 arc(142.06,53.1) 141.82,53.16 141.72,53.16 arc(141.53,53.12) 141.36,53.01 141.21,52.86 arc(141.1,52.79) 140.98,52.76 140.85,52.76 arc(140.59,52.69) 140.39,52.5 140.31,52.36 arc(140.26,52.16) 140.31,51.96 140.37,51.87 arc(140.38,51.81) 140.34,51.75 v1(140.06,51.6)
CXL_RX_N9: length 83.8
  TOP w0.116: J7.A6 v6(222.08,48.29)
  L16_SIG6 w0.085: v6(222.08,48.29) 221.94,48.15 arc(221.83,48.08) 221.71,48.05 217.31,48.05 211.13,48.05 arc(210.74,48.01) 210.37,47.9 209.66,47.62 arc(209.41,47.54) 209.14,47.52 207.67,47.52 arc(207.42,47.57) 207.21,47.71 207.12,47.8 arc(206.88,47.96) 206.6,48.01 200.48,48.01 arc(200.11,47.94) 199.79,47.73 199.71,47.65 arc(199.35,47.41) 198.92,47.32 195.58,47.32 arc(195.09,47.25) 194.64,47.06 arc(194.29,46.9) 193.91,46.85 179.61,46.85 arc(179.56,46.85) 179.52,46.85 178.11,47.05 arc(178.07,47.06) 178.04,47.08 175.84,48.38 arc(175.8,48.41) 175.77,48.44 174.45,49.76 arc(174.03,50.09) 173.56,50.32 arc(173.49,50.34) 173.41,50.34 169.97,50.34 arc(169.89,50.33) 169.8,50.3 arc(169.58,50.18) 169.39,50.01 arc(169.33,49.97) 169.25,49.96 156.36,49.96 arc(155.24,50.18) 154.29,50.81 153.58,51.53 arc(152.28,52.39) 150.75,52.7 144.36,52.7 arc(144.2,52.74) 144.09,52.86 143.97,53.06 arc(143.89,53.15) 143.79,53.21 arc(143.73,53.23) 143.68,53.24 arc(143.61,53.26) 143.54,53.26 143.41,53.26 arc(143.24,53.22) 143.12,53.1 143.1,53.06 arc(143.02,53) 142.92,53 v1(142.66,53.1)
CXL_RX_N10: length 89.8
  TOP w0.116: J7.A15 v6(222.08,53.69)
  L16_SIG6 w0.085: v1(140.06,53.6) 140.34,53.75 arc(140.38,53.81) 140.37,53.87 140.31,53.96 arc(140.26,54.16) 140.31,54.36 140.39,54.5 arc(140.59,54.69) 140.85,54.76 140.98,54.76 arc(141.1,54.79) 141.21,54.86 141.36,55.01 arc(141.53,55.12) 141.72,55.16 141.82,55.16 arc(142.06,55.1) 142.23,54.92 142.31,54.78 arc(142.42,54.68) 142.57,54.64 142.67,54.64 arc(142.93,54.56) 143.13,54.37 143.18,54.28 arc(143.28,54.17) 143.43,54.14 143.66,54.14 arc(143.9,54.07) 144.08,53.89 144.11,53.84 arc(144.21,53.74) 144.35,53.7 148.07,53.7 arc(148.43,53.77) 148.74,53.98 arc(149.16,54.26) 149.65,54.36 150.59,54.36 arc(151.81,54.11) 152.84,53.43 153.41,52.86 arc(153.53,52.78) 153.67,52.74 153.77,52.74 arc(154.18,52.66) 154.53,52.43 155.5,51.46 arc(156.43,50.84) 157.51,50.62 167.92,50.62 arc(168.45,50.68) 168.94,50.86 arc(169.31,51.01) 169.69,51.1 arc(169.75,51.11) 169.8,51.11 173.47,51.11 arc(173.55,51.1) 173.62,51.08 arc(174.53,50.66) 175.31,50.04 176.68,48.68 176.72,48.64 177.48,48.19 177.78,48.11 arc(177.82,48.11) 177.86,48.11 185.3,48.11 arc(185.34,48.11) 185.38,48.12 arc(185.44,48.16) 185.5,48.21 arc(185.69,48.34) 185.92,48.38 190.17,48.38 arc(190.66,48.48) 191.07,48.75 arc(191.44,49) 191.88,49.09 202.78,49.09 arc(202.99,49.04) 203.17,48.92 arc(203.43,48.75) 203.74,48.68 207.03,48.68 arc(207.27,48.66) 207.5,48.57 arc(207.74,48.49) 207.98,48.46 209.74,48.46 arc(210.01,48.51) 210.23,48.66 211.39,49.82 arc(211.88,50.14) 212.45,50.26 215.29,50.26 arc(216.02,50.4) 216.63,50.82 218.78,52.97 arc(219.36,53.35) 220.04,53.49 221.84,53.49 arc(221.87,53.49) 221.9,53.51 v6(222.08,53.69)
CXL_RX_N11: length 85.1
  TOP w0.116: J7.A18 v6(222.08,55.49)
  L16_SIG6 w0.085: v1(142.66,55.1) 142.92,55 arc(143.02,55) 143.1,55.06 143.12,55.1 arc(143.24,55.22) 143.41,55.26 143.61,55.26 arc(143.87,55.19) 144.06,55 144.18,54.81 arc(144.26,54.73) 144.36,54.7 148.27,54.7 arc(148.41,54.73) 148.52,54.8 arc(148.77,54.97) 149.07,55.03 151.29,55.03 arc(152.22,54.84) 153.02,54.31 arc(153.62,53.91) 154.33,53.77 154.53,53.77 arc(154.92,53.69) 155.25,53.47 156.69,52.03 arc(156.97,51.85) 157.3,51.78 174.23,51.78 arc(174.47,51.73) 174.67,51.6 175.05,51.22 arc(175.22,51.11) 175.43,51.07 175.71,51.07 arc(176.07,51.14) 176.38,51.35 arc(176.54,51.45) 176.72,51.49 183.53,51.49 arc(184.23,51.63) 184.83,52.02 184.97,52.16 arc(185.23,52.34) 185.54,52.4 189.15,52.4 arc(193.41,53.25) 197.03,55.67 197.24,55.88 arc(198.1,56.46) 199.12,56.66 203.77,56.66 arc(205.07,56.4) 206.17,55.67 206.81,55.03 arc(207.32,54.68) 207.93,54.56 209.49,54.56 arc(209.66,54.59) 209.81,54.68 210.26,55.07 arc(210.32,55.11) 210.39,55.14 arc(210.65,55.23) 210.91,55.28 arc(210.97,55.29) 211.02,55.29 221.84,55.29 arc(221.87,55.29) 221.9,55.31 v6(222.08,55.49)
CXL_RX_N12: length 89.2
  TOP w0.116: J7.A21 v6(222.08,57.29)
  L16_SIG6 w0.085: v6(222.08,57.29) 221.9,57.11 arc(221.87,57.09) 221.84,57.09 213.15,57.09 arc(212.75,57.03) 212.37,56.86 212.15,56.71 arc(212.15,56.71) 212.15,56.71 212.14,56.71 arc(211.69,56.42) 211.21,56.17 211.2,56.16 arc(211.06,56.12) 210.91,56.1 210.17,56.1 210.16,56.1 209.42,56.1 209.34,56.12 208.05,56.68 207.98,56.73 207.76,56.95 arc(207.3,57.25) 206.76,57.36 197.95,57.36 arc(197.73,57.32) 197.54,57.19 197.4,57.05 arc(197.27,56.96) 197.11,56.93 196.91,56.93 arc(196.58,56.86) 196.31,56.68 195.49,55.86 arc(192.75,54.03) 189.52,53.39 186.9,53.39 arc(186.69,53.43) 186.5,53.56 186.49,53.57 arc(184.98,54.19) 183.47,53.57 182.92,53.02 arc(182.11,52.47) 181.15,52.28 176.39,52.28 arc(176.32,52.29) 176.26,52.32 176.03,52.47 arc(175.94,52.51) 175.84,52.53 159.31,52.53 arc(157.57,52.88) 156.08,53.86 154.95,55 arc(153.21,56.16) 151.17,56.57 148.16,56.57 arc(147.81,56.5) 147.52,56.3 arc(146.85,55.86) 146.07,55.7 144.34,55.7 arc(144.21,55.73) 144.12,55.83 144.08,55.89 arc(143.9,56.07) 143.66,56.14 143.43,56.14 arc(143.28,56.17) 143.18,56.28 143.13,56.37 arc(142.93,56.56) 142.67,56.64 142.57,56.64 arc(142.42,56.68) 142.31,56.78 142.23,56.92 arc(142.06,57.1) 141.82,57.16 141.72,57.16 arc(141.53,57.12) 141.36,57.01 141.21,56.86 arc(141.1,56.79) 140.98,56.76 140.85,56.76 arc(140.59,56.69) 140.39,56.5 140.31,56.36 arc(140.26,56.16) 140.31,55.96 140.37,55.87 arc(140.38,55.81) 140.34,55.75 v1(140.06,55.6)
CXL_RX_N13: length 87.7
  TOP w0.116: J7.A24 v6(222.08,59.09)
  L16_SIG6 w0.085: v1(142.66,57.1) 142.92,57 arc(143.02,57) 143.1,57.06 143.12,57.1 arc(143.24,57.22) 143.41,57.26 143.61,57.26 arc(143.87,57.19) 144.06,57 144.15,56.85 arc(144.26,56.74) 144.41,56.7 145.59,56.7 145.84,56.8 146.87,57.84 arc(147.52,58.27) 148.29,58.42 152.25,58.42 arc(152.95,58.56) 153.55,58.96 arc(154.01,59.27) 154.55,59.37 164.63,59.37 arc(166.29,58.65) 167.01,56.99 arc(167.01,56.99) 167.01,56.99 arc(168.08,54.42) 170.64,53.36 172.78,53.36 arc(173.15,53.43) 173.47,53.65 173.8,53.98 arc(174,54.11) 174.24,54.16 174.54,54.16 arc(174.58,54.16) 174.62,54.17 174.71,54.18 arc(174.93,54.25) 175.1,54.4 175.56,55.01 arc(175.59,55.04) 175.62,55.07 176.24,55.62 arc(176.27,55.65) 176.3,55.68 176.51,55.89 arc(176.63,55.98) 176.76,56.04 176.86,56.07 arc(176.89,56.08) 176.92,56.08 176.98,56.08 arc(177.1,56.07) 177.22,56.03 arc(177.33,55.99) 177.46,55.98 178.05,55.98 arc(178.19,56.01) 178.31,56.09 arc(178.43,56.17) 178.57,56.19 179.23,56.19 181.88,57.44 182.46,57.7 196.75,57.7 arc(196.86,57.71) 196.96,57.74 arc(197.05,57.79) 197.14,57.85 197.22,57.93 arc(197.4,58.06) 197.61,58.1 207.35,58.1 arc(207.85,58) 208.28,57.71 arc(209.02,57.4) 209.75,57.71 210.3,58.26 arc(211,58.72) 211.83,58.89 221.84,58.89 arc(221.87,58.89) 221.9,58.91 v6(222.08,59.09)
CXL_RX_N14: length 91.1
  TOP w0.116: J7.A33 v6(222.08,64.49)
  L16_SIG6 w0.085: v1(140.06,57.6) 140.34,57.75 arc(140.38,57.81) 140.37,57.87 140.31,57.96 arc(140.26,58.16) 140.31,58.36 140.39,58.5 arc(140.59,58.69) 140.85,58.76 140.98,58.76 arc(141.1,58.79) 141.21,58.86 141.36,59.01 arc(141.53,59.12) 141.72,59.16 141.82,59.16 arc(142.06,59.1) 142.23,58.93 142.31,58.78 arc(142.42,58.68) 142.57,58.64 142.67,58.64 arc(142.93,58.56) 143.13,58.37 143.18,58.28 arc(143.28,58.17) 143.43,58.14 143.66,58.14 arc(143.9,58.07) 144.08,57.89 144.12,57.83 arc(144.21,57.73) 144.34,57.7 145.31,57.7 145.51,57.79 145.8,58.07 146.48,59.71 146.5,59.74 arc(147.02,60.08) 147.64,60.21 151.7,60.21 arc(151.99,60.26) 152.23,60.42 arc(152.41,60.54) 152.62,60.59 170.66,60.59 arc(171.03,60.57) 171.39,60.53 arc(171.73,60.5) 172.07,60.48 173.91,60.48 arc(174.88,60.29) 175.7,59.74 175.85,59.6 arc(176.15,59.46) 176.47,59.55 arc(176.57,59.61) 176.67,59.64 arc(176.93,59.67) 177.18,59.63 arc(177.27,59.6) 177.34,59.54 177.46,59.43 arc(177.57,59.35) 177.71,59.32 178.28,59.32 arc(178.49,59.36) 178.68,59.48 arc(179,59.7) 179.38,59.78 182.45,59.78 arc(183.02,59.66) 183.5,59.34 183.54,59.31 arc(184.39,58.74) 185.4,58.54 187.81,58.54 arc(189.11,58.71) 190.31,59.2 arc(190.62,59.36) 190.93,59.5 194.78,61.1 arc(194.86,61.12) 194.95,61.13 196.45,61.13 arc(197.22,60.98) 197.87,60.54 198.57,59.84 arc(198.64,59.8) 198.72,59.78 205.69,59.78 arc(205.84,59.81) 205.97,59.89 arc(206.73,60.4) 207.62,60.58 212.55,60.58 arc(213.32,60.9) 213.64,61.67 213.64,62.63 arc(213.74,63.11) 214.01,63.52 214.55,64.06 215.1,64.29 221.84,64.29 arc(221.87,64.29) 221.9,64.31 v6(222.08,64.49)
CXL_RX_N15: length 85.5
  TOP w0.116: J7.A36 v6(222.08,66.29)
  L16_SIG6 w0.085: v1(142.66,59.1) 142.92,59 arc(143.02,58.99) 143.09,59.05 143.12,59.1 arc(143.24,59.22) 143.41,59.26 143.61,59.26 arc(143.73,59.29) 143.83,59.35 144.82,60.35 146.09,60.87 146.99,61.77 arc(147.38,62.03) 147.84,62.12 156.08,62.12 arc(156.39,62.06) 156.66,61.88 arc(156.87,61.74) 157.12,61.69 175.02,61.69 arc(175.56,61.58) 176.01,61.28 176.71,60.58 arc(176.87,60.48) 177.05,60.44 177.95,60.44 arc(178.09,60.47) 178.21,60.55 178.29,60.63 arc(178.47,60.75) 178.69,60.79 182.5,60.79 arc(182.83,60.86) 183.11,61.05 183.17,61.1 arc(183.32,61.33) 183.37,61.61 arc(183.61,62.17) 184.17,62.4 184.5,62.4 arc(184.66,62.38) 184.81,62.32 arc(185.06,62.22) 185.34,62.19 196.63,62.19 arc(196.71,62.2) 196.8,62.24 arc(196.98,62.33) 197.19,62.35 200.55,62.35 arc(200.89,62.29) 201.19,62.09 arc(202.27,61.64) 203.36,62.09 206.55,65.28 arc(207.45,65.88) 208.51,66.09 221.84,66.09 arc(221.87,66.09) 221.9,66.11 v6(222.08,66.29)
CXL_RX_P0: length 95.2
  TOP w0.116: J6.A2 v6(222.08,17.18)
  L16_SIG6 w0.085: v1(140.93,44.1) 140.66,43.94 arc(140.6,43.93) 140.54,43.97 140.51,44.04 arc(140.47,44.16) 140.51,44.28 140.56,44.39 arc(140.69,44.51) 140.86,44.56 141,44.56 arc(141.17,44.51) 141.3,44.39 141.41,44.18 arc(141.55,44.05) 141.74,44 141.85,44 arc(142.01,43.95) 142.13,43.84 142.16,43.78 arc(142.33,43.61) 142.57,43.55 142.65,43.55 arc(142.8,43.52) 142.92,43.44 143.19,43.17 arc(143.36,43.06) 143.56,43.02 143.98,43.02 144.19,42.93 144.4,42.72 144.4,42.54 144.58,42.36 144.76,42.36 145.25,41.88 arc(145.8,41.51) 146.45,41.38 146.88,41.38 147,41.26 147.22,41.26 147.34,41.38 147.56,41.38 147.68,41.26 147.9,41.26 148.02,41.38 148.24,41.38 148.36,41.26 148.58,41.26 148.7,41.38 151.44,41.38 arc(151.82,41.3) 152.15,41.08 159.14,34.09 arc(161.49,32.52) 164.26,31.97 165.09,31.97 arc(167.2,31.55) 168.99,30.35 170.2,29.14 arc(171.98,27.96) 174.07,27.54 178.56,27.54 arc(178.6,27.53) 178.64,27.52 arc(179,27.29) 179.32,27.02 arc(179.85,26.66) 180.48,26.54 183.58,26.54 arc(184.12,26.46) 184.63,26.25 arc(185.14,26.04) 185.68,25.97 193.51,25.97 arc(194.6,25.75) 195.52,25.14 196.79,23.87 arc(197.82,23.18) 199.03,22.94 201.85,22.94 arc(203.13,23.2) 204.22,23.92 204.33,24.04 arc(204.58,24.2) 204.87,24.26 207.41,24.26 arc(208.46,24.05) 209.35,23.46 209.38,23.43 arc(209.76,22.9) 209.97,22.28 arc(210.02,22.04) 210.1,21.81 210.29,21.36 arc(210.31,21.32) 210.33,21.29 211.14,20.07 arc(211.33,19.82) 211.54,19.6 arc(213.81,18.13) 216.41,17.39 arc(216.48,17.38) 216.55,17.38 221.78,17.38 arc(221.87,17.36) 221.95,17.31 v6(222.08,17.18)
CXL_RX_P1: length 90.7
  TOP w0.116: J6.A5 v6(222.08,18.98)
  L16_SIG6 w0.085: v6(222.08,18.98) 221.9,19.16 arc(221.84,19.2) 221.76,19.22 216.13,19.22 arc(215.86,19.24) 215.61,19.3 215.39,19.37 arc(215.33,19.39) 215.28,19.41 212.63,20.68 arc(212.38,20.8) 212.14,20.94 arc(211.98,21.06) 211.83,21.18 arc(211.52,21.49) 211.25,21.82 arc(211.21,21.88) 211.18,21.94 210.96,22.47 arc(210.91,22.6) 210.87,22.74 arc(210.66,23.25) 210.32,23.69 209.84,24.17 arc(208.99,24.74) 207.99,24.94 204.39,24.94 arc(203.77,24.82) 203.25,24.47 arc(202.67,24.08) 201.98,23.94 199.76,23.94 arc(198.17,24.26) 196.82,25.16 195.78,26.2 arc(194.79,26.86) 193.63,27.09 189.32,27.09 arc(187.97,27.36) 186.82,28.13 arc(185.41,29.07) 183.75,29.4 173.72,29.4 arc(172.04,29.73) 170.61,30.68 168.29,33.01 arc(165.76,34.7) 162.78,35.29 162.55,35.29 arc(159.87,35.82) 157.6,37.34 153.02,41.92 arc(152.78,42.08) 152.49,42.14 147.48,42.14 arc(147.06,42.22) 146.71,42.46 145.44,43.72 145.23,43.72 145.09,43.86 145.09,44.07 144.85,44.31 arc(144.65,44.45) 144.42,44.5 144.33,44.5 arc(144.09,44.56) 143.92,44.73 143.8,44.94 arc(143.71,45.03) 143.59,45.06 143.41,45.06 arc(143.36,45.05) 143.31,45.01 arc(143.3,45) 143.3,44.99 143.25,44.91 arc(143.24,44.86) 143.27,44.81 v1(143.53,44.6)
CXL_RX_P2: length 92.3
  TOP w0.116: v6(222.08,24.38) J6.A14
  L16_SIG6 w0.085: v6(222.08,24.38) 221.93,24.53 arc(221.87,24.57) 221.8,24.58 212.59,24.58 arc(211.51,24.74) 210.51,25.18 arc(209.79,25.51) 209,25.62 198.73,25.62 arc(197.73,25.82) 196.89,26.38 arc(195.06,27.61) 192.91,28.03 192.65,28.03 arc(191.61,28.24) 190.73,28.83 190.49,29.07 arc(188.23,30.58) 185.57,31.11 183.47,31.11 arc(183.39,31.12) 183.31,31.12 176.48,31.12 arc(176.33,31.15) 176.2,31.24 arc(176.07,31.32) 175.92,31.35 174.1,31.35 arc(174,31.33) 173.91,31.27 173.72,31.08 arc(173.59,30.99) 173.43,30.96 171.83,30.96 arc(171.52,31.05) 171.29,31.28 171.03,31.74 arc(171,31.78) 170.97,31.79 170.76,31.85 arc(170.67,31.89) 170.6,31.95 167.63,34.91 arc(164.86,36.76) 161.6,37.41 161.43,37.41 arc(159.29,37.84) 157.47,39.05 153.32,43.21 arc(152.92,43.47) 152.45,43.56 148.97,43.56 arc(148.27,43.7) 147.68,44.1 147.42,44.36 147.24,44.36 147.05,44.55 147.05,44.73 146.85,44.93 146.67,44.93 146.48,45.11 146.48,45.3 146.35,45.43 146.2,45.5 145.94,45.5 145.82,45.37 145.54,45.37 145.42,45.5 145.14,45.5 145.02,45.37 144.74,45.37 144.62,45.5 144.34,45.5 arc(144.11,45.56) 143.94,45.72 143.9,45.79 arc(143.8,45.89) 143.66,45.93 143.43,45.93 arc(143.18,46) 143,46.18 142.95,46.27 arc(142.83,46.39) 142.67,46.43 142.57,46.43 arc(142.32,46.5) 142.13,46.68 142.05,46.82 arc(141.96,46.92) 141.82,46.96 141.72,46.96 arc(141.61,46.93) 141.5,46.86 141.36,46.72 arc(141.18,46.6) 140.98,46.56 140.85,46.56 arc(140.69,46.52) 140.57,46.4 140.49,46.26 arc(140.46,46.16) 140.49,46.06 140.54,45.97 arc(140.59,45.93) 140.66,45.94 v1(140.93,46.1)
CXL_RX_P3: length 91.1
  TOP w0.116: J6.A17 v6(222.08,26.18)
  L16_SIG6 w0.085: v1(143.53,46.6) 143.27,46.81 arc(143.24,46.86) 143.25,46.91 143.3,46.99 arc(143.3,47) 143.31,47.01 arc(143.36,47.05) 143.41,47.06 143.6,47.06 arc(143.71,47.03) 143.79,46.95 143.91,46.75 arc(144.09,46.56) 144.34,46.5 144.68,46.5 144.79,46.39 145.02,46.39 145.12,46.5 145.36,46.5 145.46,46.39 145.7,46.39 145.8,46.5 147.14,46.5 147.43,46.38 148.23,45.57 148.54,45.44 151.54,45.44 153.07,44.81 153.36,44.81 arc(153.65,44.75) 153.89,44.59 154.39,44.09 arc(155.09,43.62) 155.92,43.46 166.32,43.46 arc(166.52,43.38) 166.6,43.18 166.6,41.28 arc(167.19,38.33) 168.86,35.84 169.4,35.29 arc(170.08,34.84) 170.88,34.68 173.25,34.68 arc(173.87,34.56) 174.39,34.21 175.49,33.11 arc(175.73,32.92) 176,32.77 arc(176.3,32.68) 176.6,32.65 187.85,32.65 arc(187.89,32.65) 187.93,32.64 arc(188.97,32.27) 189.86,31.62 192.03,29.45 arc(192.56,29.09) 193.18,28.97 194.02,28.97 arc(194.8,28.82) 195.46,28.37 arc(196.89,27.42) 198.57,27.09 209.56,27.09 arc(209.6,27.09) 209.65,27.08 arc(209.66,27.08) 209.68,27.07 210.18,26.74 arc(210.77,26.47) 211.41,26.38 221.83,26.38 arc(221.87,26.37) 221.91,26.35 v6(222.08,26.18)
CXL_RX_P4: length 94.7
  TOP w0.116: J6.A20 v6(222.08,27.98)
  L16_SIG6 w0.085: v6(222.08,27.98) 221.91,28.15 arc(221.88,28.17) 221.85,28.18 198.03,28.18 arc(197.98,28.18) 197.92,28.18 arc(196.94,28.49) 196.1,29.09 195.2,29.99 arc(194.87,30.21) 194.49,30.28 arc(194.2,30.34) 193.96,30.5 190.99,33.47 arc(190.49,33.81) 189.89,33.93 177.93,33.93 arc(177.89,33.93) 177.85,33.92 177.43,33.77 arc(177.39,33.75) 177.35,33.75 177.1,33.71 arc(177.03,33.71) 176.96,33.71 arc(175.87,34.03) 174.94,34.69 174.61,35.03 arc(173.69,35.64) 172.6,35.86 171.78,35.86 arc(170.51,36.11) 169.44,36.83 arc(168.28,38.57) 167.87,40.63 167.87,42.78 arc(167.46,43.76) 166.49,44.16 156.48,44.16 arc(155.77,44.3) 155.17,44.7 154.43,45.45 arc(154.18,45.61) 153.88,45.67 152.75,45.67 151.13,46.34 149.98,46.34 149.46,46.55 149.03,46.99 148.89,47.04 148.62,47.04 148.31,47.17 148.04,47.45 147.91,47.5 147.19,47.5 147.05,47.36 146.85,47.36 146.71,47.5 146.51,47.5 146.37,47.36 146.17,47.36 146.03,47.5 145.83,47.5 145.69,47.36 145.49,47.36 145.36,47.5 145.15,47.5 145.02,47.36 144.81,47.36 144.68,47.5 144.34,47.5 arc(144.11,47.56) 143.94,47.72 143.9,47.79 arc(143.8,47.89) 143.66,47.93 143.43,47.93 arc(143.18,48) 143,48.18 142.95,48.27 arc(142.83,48.39) 142.67,48.43 142.57,48.43 arc(142.32,48.5) 142.13,48.68 142.05,48.82 arc(141.96,48.92) 141.82,48.96 141.72,48.96 arc(141.61,48.93) 141.5,48.86 141.36,48.72 arc(141.18,48.6) 140.98,48.56 140.85,48.56 arc(140.69,48.52) 140.57,48.4 140.49,48.26 arc(140.46,48.16) 140.49,48.06 140.54,47.97 arc(140.59,47.93) 140.66,47.94 v1(140.93,48.1)
CXL_RX_P5: length 92.1
  TOP w0.116: J6.A23 v6(222.08,29.78)
  L16_SIG6 w0.085: v6(222.08,29.78) 221.88,29.98 215.35,29.98 arc(214.71,30.11) 214.17,30.47 213.34,31.3 arc(213.08,31.47) 212.77,31.53 208.51,31.53 arc(208.44,31.54) 208.37,31.56 208.25,31.59 arc(208.18,31.62) 208.11,31.67 arc(207.94,31.81) 207.78,31.96 arc(206.36,32.91) 204.69,33.24 199.91,33.24 arc(199.82,33.22) 199.74,33.17 arc(199.51,33.01) 199.23,32.95 196.31,32.95 arc(195.72,33.07) 195.22,33.41 194.21,34.41 arc(193.34,34.99) 192.31,35.2 176.84,35.2 arc(175.69,35.43) 174.72,36.08 174.12,36.68 arc(173.86,37.07) 173.77,37.53 173.77,38.17 arc(173.79,38.3) 173.84,38.43 arc(173.89,38.55) 173.91,38.69 173.91,42.2 arc(173.9,42.24) 173.88,42.28 173.81,42.34 arc(173.69,42.52) 173.65,42.73 173.65,42.94 arc(173.11,44.24) 171.82,44.77 168.23,44.77 arc(168.01,44.79) 167.79,44.85 arc(167.58,44.91) 167.36,44.93 157.28,44.93 arc(156.42,45.1) 155.7,45.59 155.27,46.02 154.64,46.65 arc(154.29,46.88) 153.89,46.96 152.37,46.96 arc(152.07,47.02) 151.81,47.19 arc(151.79,47.21) 151.77,47.22 151.67,47.25 arc(151.62,47.26) 151.58,47.27 150.59,47.27 arc(150.51,47.28) 150.43,47.3 149.89,47.52 arc(149.82,47.56) 149.75,47.62 149.69,47.68 arc(149.64,47.74) 149.6,47.81 149.42,48.26 arc(149.4,48.3) 149.37,48.33 149.13,48.57 148.83,48.69 148.3,48.69 147.82,48.5 145.95,48.5 145.83,48.38 145.55,48.38 145.44,48.5 145.16,48.5 145.04,48.38 144.77,48.38 144.65,48.5 144.41,48.5 arc(144.12,48.57) 143.91,48.79 143.8,48.98 arc(143.74,49.04) 143.66,49.06 143.41,49.06 arc(143.35,49.04) 143.3,48.99 143.25,48.91 arc(143.24,48.86) 143.27,48.81 v1(143.53,48.6)
CXL_RX_P6: length 93
  TOP w0.116: J6.A32 v6(222.08,35.18)
  L16_SIG6 w0.085: v1(140.93,50.1) 140.66,49.94 arc(140.59,49.93) 140.54,49.97 140.49,50.07 arc(140.46,50.16) 140.49,50.26 140.57,50.4 arc(140.69,50.52) 140.85,50.56 140.98,50.56 arc(141.18,50.6) 141.36,50.72 141.5,50.86 arc(141.61,50.93) 141.72,50.96 141.82,50.96 arc(141.96,50.92) 142.05,50.82 142.13,50.68 arc(142.32,50.5) 142.57,50.43 142.67,50.43 arc(142.83,50.39) 142.95,50.27 143,50.18 arc(143.18,50) 143.43,49.93 143.66,49.93 arc(143.8,49.89) 143.9,49.79 143.95,49.71 arc(144.11,49.55) 144.32,49.5 144.62,49.5 144.74,49.37 145.02,49.37 145.14,49.5 145.42,49.5 145.54,49.37 145.82,49.37 145.94,49.5 146.22,49.5 146.34,49.37 146.62,49.37 146.75,49.5 147.02,49.5 147.15,49.37 147.43,49.37 147.55,49.5 148.95,49.5 149.31,49.35 arc(149.39,49.3) 149.46,49.24 149.77,48.93 arc(149.84,48.88) 149.91,48.84 152.65,47.71 arc(152.73,47.68) 152.81,47.67 154.37,47.67 arc(154.41,47.67) 154.45,47.66 arc(154.89,47.47) 155.27,47.17 arc(156.59,46.29) 158.15,45.98 168.3,45.98 arc(168.61,45.94) 168.9,45.81 168.96,45.77 arc(169.45,45.55) 169.97,45.48 172.83,45.48 arc(173.51,45.35) 174.09,44.96 174.93,44.12 175.11,43.91 arc(175.2,43.78) 175.27,43.64 arc(175.31,43.48) 175.33,43.32 arc(175.37,43.15) 175.47,43 176.26,42.21 arc(176.33,42.1) 176.36,41.97 176.36,38.93 arc(176.47,38.37) 176.79,37.89 177.44,37.23 arc(178.18,36.72) 179.04,36.48 arc(179.09,36.47) 179.15,36.47 192.06,36.47 arc(193.85,36.12) 195.37,35.1 arc(196.23,34.53) 197.24,34.32 200.7,34.32 arc(201.58,34.5) 202.33,35 arc(202.56,35.15) 202.83,35.2 206.75,35.2 arc(207.01,35.17) 207.26,35.07 arc(207.6,34.92) 207.98,34.87 213.32,34.87 arc(213.79,34.93) 214.22,35.13 arc(214.66,35.32) 215.13,35.38 221.83,35.38 arc(221.87,35.37) 221.91,35.35 v6(222.08,35.18)
CXL_RX_P7: length 88.2
  TOP w0.116: J6.A35 v6(222.08,36.98)
  L16_SIG6 w0.085: v1(143.53,50.6) 143.27,50.81 arc(143.24,50.86) 143.25,50.92 143.3,50.99 arc(143.35,51.04) 143.41,51.06 143.57,51.06 arc(143.71,51.02) 143.81,50.92 143.88,50.8 arc(144.1,50.58) 144.41,50.5 144.65,50.5 144.77,50.38 145.04,50.38 145.16,50.5 145.44,50.5 145.55,50.38 145.83,50.38 145.95,50.5 148.71,50.5 149.55,50.15 arc(149.67,50.08) 149.77,50 150.02,49.75 arc(150.09,49.7) 150.16,49.66 152.32,48.76 arc(152.4,48.74) 152.48,48.73 152.82,48.73 arc(152.86,48.73) 152.9,48.71 153.33,48.53 arc(153.56,48.46) 153.8,48.44 154.29,48.44 arc(155.17,48.27) 155.91,47.77 156.09,47.6 arc(157,46.98) 158.09,46.77 168.76,46.77 arc(169.18,46.72) 169.57,46.56 arc(170.06,46.36) 170.58,46.29 173.56,46.29 arc(173.96,46.21) 174.3,45.99 174.47,45.82 arc(174.96,45.49) 175.54,45.37 177.09,45.37 arc(177.48,45.29) 177.81,45.07 177.91,44.98 arc(178.1,44.69) 178.17,44.35 178.17,43.23 arc(178.24,42.87) 178.44,42.57 178.46,42.55 179.06,41.96 arc(179.06,41.96) 179.06,41.96 179.1,41.92 arc(179.5,41.66) 179.96,41.56 193.85,41.56 arc(195.35,41.27) 196.62,40.42 197.1,39.93 arc(197.76,38.98) 198.04,37.84 arc(198.08,37.6) 198.16,37.37 arc(198.74,36.58) 199.59,36.07 arc(199.66,36.05) 199.74,36.04 201.01,36.04 201.16,36.08 arc(201.56,36.19) 201.95,36.31 202.07,36.36 207.84,36.36 arc(208.29,36.45) 208.68,36.7 209.09,37.11 arc(209.16,37.16) 209.26,37.18 221.88,37.18 v6(222.08,36.98)
CXL_RX_P8: length 96.9
  TOP w0.116: J7.A2 v6(222.08,45.89)
  L16_SIG6 w0.085: v1(140.93,52.1) 140.66,51.94 arc(140.59,51.93) 140.54,51.97 140.49,52.07 arc(140.46,52.16) 140.49,52.26 140.57,52.4 arc(140.69,52.52) 140.85,52.56 140.98,52.56 arc(141.18,52.6) 141.36,52.72 141.5,52.86 arc(141.61,52.93) 141.72,52.96 141.82,52.96 arc(141.96,52.92) 142.05,52.82 142.13,52.68 arc(142.32,52.5) 142.57,52.43 142.67,52.43 arc(142.83,52.39) 142.95,52.27 143,52.18 arc(143.18,52) 143.43,51.93 143.66,51.93 arc(143.8,51.89) 143.9,51.79 143.91,51.77 arc(144.12,51.57) 144.4,51.5 144.74,51.5 144.87,51.36 145.07,51.36 145.21,51.5 145.41,51.5 145.55,51.36 145.75,51.36 145.88,51.5 146.09,51.5 146.22,51.36 146.43,51.36 146.56,51.5 146.77,51.5 146.9,51.36 147.11,51.36 147.24,51.5 148.42,51.5 148.95,51.72 150.97,51.72 arc(151.78,51.56) 152.47,51.09 153.94,49.62 arc(154.51,49.24) 155.18,49.11 155.52,49.11 155.55,49.08 169.85,49.08 arc(169.96,49.1) 170.06,49.16 170.23,49.31 arc(170.26,49.33) 170.31,49.33 173.37,49.33 arc(173.41,49.33) 173.45,49.31 arc(173.62,49.21) 173.76,49.08 176.15,46.69 arc(176.52,46.45) 176.96,46.36 arc(177.58,46.23) 178.11,45.88 178.46,45.53 arc(178.54,45.47) 178.64,45.44 178.99,45.37 arc(179.03,45.36) 179.07,45.36 191.11,45.36 arc(193.2,44.95) 194.96,43.77 195.5,43.23 arc(196.08,42.85) 196.76,42.71 197.24,42.71 arc(197.57,42.65) 197.84,42.46 198.82,41.49 arc(199.5,41) 200.31,40.76 arc(200.58,40.68) 200.83,40.52 arc(201.03,40.33) 201.22,40.13 arc(201.25,40.1) 201.27,40.06 201.41,39.64 arc(201.46,39.46) 201.5,39.27 arc(201.75,38.49) 202.22,37.83 202.76,37.3 arc(203.06,37.1) 203.42,37.03 206.66,37.03 arc(207.48,37.19) 208.17,37.65 208.69,38.17 arc(208.93,38.54) 209.02,38.97 arc(209.2,39.42) 209.65,39.6 210.36,39.6 arc(212.18,40.35) 212.93,42.17 212.93,44.03 arc(213.1,44.84) 213.56,45.54 arc(214.17,45.94) 214.88,46.09 221.74,46.09 arc(221.86,46.06) 221.97,45.99 v6(222.08,45.89)
CXL_RX_P9: length 83.8
  TOP w0.116: J7.A5 v6(222.08,47.69)
  L16_SIG6 w0.085: v1(143.53,52.6) 143.27,52.81 arc(143.24,52.86) 143.25,52.92 143.3,52.99 arc(143.35,53.04) 143.41,53.06 143.54,53.06 arc(143.58,53.06) 143.63,53.05 arc(143.68,53.03) 143.73,53.02 arc(143.76,53) 143.79,52.96 143.91,52.76 arc(144.1,52.57) 144.36,52.5 144.7,52.5 144.8,52.4 145.04,52.4 145.14,52.5 145.38,52.5 145.48,52.4 145.72,52.4 145.82,52.5 146.06,52.5 146.16,52.4 146.4,52.4 146.5,52.5 150.75,52.5 arc(152.2,52.21) 153.43,51.38 154.15,50.67 arc(155.16,49.99) 156.36,49.75 169.25,49.75 arc(169.4,49.78) 169.53,49.87 arc(169.7,50.01) 169.89,50.12 arc(169.93,50.14) 169.97,50.14 173.41,50.14 arc(173.45,50.14) 173.49,50.13 arc(173.93,49.92) 174.3,49.62 175.68,48.24 177.95,46.89 arc(178,46.87) 178.07,46.85 179.49,46.65 arc(179.55,46.65) 179.61,46.64 192.07,46.64 arc(192.07,46.64) 192.07,46.64 193.91,46.64 arc(194.35,46.71) 194.75,46.88 arc(195.15,47.06) 195.58,47.12 198.92,47.12 arc(199.43,47.22) 199.85,47.51 199.93,47.58 arc(200.18,47.75) 200.48,47.81 206.6,47.81 arc(206.8,47.77) 206.98,47.65 207.07,47.56 arc(207.34,47.38) 207.67,47.32 209.16,47.32 arc(209.45,47.34) 209.72,47.42 210.44,47.72 arc(210.78,47.82) 211.13,47.85 217.31,47.85 221.71,47.85 arc(221.9,47.81) 222.06,47.7 v6(222.08,47.69)
CXL_RX_P10: length 89.8
  TOP w0.116: J7.A14 v6(222.08,53.09)
  L16_SIG6 w0.085: v1(140.93,54.1) 140.66,53.94 arc(140.59,53.93) 140.54,53.97 140.49,54.07 arc(140.46,54.16) 140.49,54.26 140.57,54.4 arc(140.69,54.52) 140.85,54.56 140.98,54.56 arc(141.18,54.6) 141.36,54.72 141.5,54.86 arc(141.61,54.93) 141.72,54.96 141.82,54.96 arc(141.96,54.92) 142.05,54.82 142.13,54.68 arc(142.32,54.5) 142.57,54.43 142.67,54.43 arc(142.83,54.39) 142.95,54.27 143,54.18 arc(143.18,54) 143.43,53.93 143.66,53.93 arc(143.8,53.89) 143.9,53.79 143.94,53.73 arc(144.11,53.56) 144.35,53.5 144.62,53.5 144.74,53.37 145.01,53.37 145.14,53.5 145.42,53.5 145.54,53.37 145.82,53.37 145.94,53.5 146.22,53.5 146.34,53.37 146.62,53.37 146.75,53.5 147.02,53.5 147.15,53.37 147.43,53.37 147.55,53.5 148.07,53.5 arc(148.51,53.58) 148.89,53.84 arc(149.24,54.07) 149.65,54.15 150.59,54.15 arc(151.73,53.93) 152.7,53.28 153.26,52.71 arc(153.45,52.59) 153.66,52.54 153.77,52.54 arc(154.11,52.47) 154.39,52.28 155.36,51.31 arc(156.35,50.65) 157.51,50.42 167.92,50.42 arc(168.49,50.49) 169.03,50.68 arc(169.37,50.81) 169.72,50.9 arc(169.76,50.9) 169.8,50.9 173.47,50.9 arc(173.52,50.9) 173.56,50.89 arc(174.42,50.49) 175.17,49.9 176.54,48.53 176.59,48.48 177.4,48 177.74,47.91 arc(177.8,47.9) 177.86,47.9 185.3,47.9 arc(185.38,47.91) 185.46,47.94 arc(185.56,47.99) 185.65,48.06 arc(185.77,48.15) 185.92,48.18 190.17,48.18 arc(190.74,48.29) 191.22,48.61 arc(191.52,48.81) 191.88,48.88 202.78,48.88 arc(202.91,48.86) 203.03,48.78 arc(203.36,48.56) 203.74,48.48 207.03,48.48 arc(207.22,48.46) 207.41,48.39 arc(207.69,48.29) 207.98,48.26 209.74,48.26 arc(210.09,48.33) 210.38,48.52 211.53,49.68 arc(211.95,49.96) 212.45,50.06 215.29,50.06 arc(216.09,50.22) 216.78,50.67 218.93,52.82 arc(219.44,53.16) 220.04,53.28 221.84,53.28 arc(221.87,53.28) 221.9,53.26 v6(222.08,53.09)
CXL_RX_P11: length 85.1
  TOP w0.116: J7.A17 v6(222.08,54.89)
  L16_SIG6 w0.085: v1(143.53,54.6) 143.27,54.81 arc(143.24,54.86) 143.25,54.92 143.3,54.99 arc(143.35,55.04) 143.41,55.06 143.61,55.06 arc(143.77,55.02) 143.89,54.9 144,54.71 arc(144.15,54.55) 144.36,54.5 144.65,54.5 144.77,54.38 145.04,54.38 145.16,54.5 145.44,54.5 145.55,54.38 145.83,54.38 145.95,54.5 148.27,54.5 arc(148.49,54.54) 148.67,54.66 arc(148.85,54.78) 149.07,54.83 151.29,54.83 arc(152.15,54.66) 152.87,54.17 arc(153.54,53.72) 154.33,53.56 154.53,53.56 arc(154.85,53.5) 155.11,53.32 156.54,51.89 arc(156.89,51.66) 157.3,51.58 174.23,51.58 arc(174.4,51.55) 174.53,51.45 174.91,51.08 arc(175.15,50.92) 175.43,50.86 175.71,50.86 arc(176.15,50.95) 176.52,51.2 arc(176.61,51.26) 176.72,51.28 183.53,51.28 arc(184.31,51.44) 184.97,51.88 185.11,52.02 arc(185.31,52.15) 185.54,52.2 189.15,52.2 arc(193.49,53.06) 197.17,55.52 197.39,55.74 arc(198.18,56.27) 199.12,56.46 203.77,56.46 arc(204.99,56.21) 206.02,55.52 206.66,54.88 arc(207.24,54.5) 207.93,54.36 209.49,54.36 arc(209.73,54.4) 209.95,54.53 210.39,54.91 arc(210.43,54.94) 210.47,54.96 arc(210.7,55.03) 210.94,55.08 arc(210.98,55.08) 211.02,55.08 221.84,55.08 arc(221.87,55.08) 221.9,55.06 v6(222.08,54.89)
CXL_RX_P12: length 89.2
  TOP w0.116: J7.A20 v6(222.08,56.69)
  L16_SIG6 w0.085: v1(140.93,56.1) 140.66,55.94 arc(140.59,55.93) 140.54,55.97 140.49,56.07 arc(140.46,56.16) 140.49,56.26 140.57,56.4 arc(140.69,56.52) 140.85,56.56 140.98,56.56 arc(141.18,56.6) 141.36,56.72 141.5,56.86 arc(141.61,56.93) 141.72,56.96 141.82,56.96 arc(141.96,56.92) 142.05,56.82 142.13,56.68 arc(142.32,56.5) 142.57,56.43 142.67,56.43 arc(142.83,56.39) 142.95,56.27 143,56.18 arc(143.18,56) 143.43,55.93 143.66,55.93 arc(143.8,55.89) 143.9,55.79 143.94,55.72 arc(144.11,55.56) 144.34,55.5 144.68,55.5 144.82,55.36 145.02,55.36 145.16,55.5 146.07,55.5 arc(146.93,55.67) 147.66,56.16 arc(147.89,56.31) 148.16,56.36 148.5,56.36 148.64,56.23 148.84,56.23 148.97,56.36 149.18,56.36 149.31,56.23 149.52,56.23 149.65,56.36 149.86,56.36 149.99,56.23 150.2,56.23 150.33,56.36 151.17,56.36 arc(153.14,55.97) 154.8,54.86 155.94,53.72 arc(157.49,52.69) 159.31,52.32 175.84,52.32 arc(175.88,52.32) 175.92,52.3 176.15,52.15 arc(176.26,52.1) 176.39,52.08 181.15,52.08 arc(182.18,52.29) 183.06,52.87 183.61,53.42 arc(184.98,53.99) 186.35,53.42 186.36,53.41 arc(186.61,53.25) 186.9,53.19 189.52,53.19 arc(192.83,53.85) 195.63,55.72 196.45,56.54 arc(196.66,56.68) 196.91,56.73 197.11,56.73 arc(197.35,56.77) 197.55,56.91 197.69,57.05 arc(197.81,57.13) 197.95,57.16 206.76,57.16 arc(207.23,57.07) 207.62,56.8 207.85,56.57 207.95,56.5 209.27,55.92 209.4,55.9 210.17,55.9 210.17,55.9 210.91,55.9 arc(211.1,55.92) 211.28,55.98 211.3,55.98 arc(211.79,56.24) 212.26,56.54 arc(212.26,56.54) 212.27,56.54 212.48,56.69 arc(212.8,56.83) 213.15,56.88 221.84,56.88 arc(221.87,56.88) 221.9,56.86 v6(222.08,56.69)
CXL_RX_P13: length 87.7
  TOP w0.116: J7.A23 v6(222.08,58.49)
  L16_SIG6 w0.085: v6(222.08,58.49) 221.9,58.66 arc(221.87,58.68) 221.84,58.68 211.83,58.68 arc(211.08,58.54) 210.44,58.11 209.9,57.57 arc(209.02,57.2) 208.14,57.57 arc(207.78,57.81) 207.35,57.89 197.61,57.89 arc(197.47,57.87) 197.36,57.79 197.28,57.71 arc(197.04,57.55) 196.75,57.49 182.5,57.49 181.96,57.25 179.27,55.99 178.57,55.99 arc(178.51,55.98) 178.46,55.94 arc(178.27,55.82) 178.05,55.77 177.46,55.77 arc(177.29,55.79) 177.13,55.85 arc(177.06,55.87) 176.98,55.88 176.92,55.88 176.82,55.85 arc(176.73,55.8) 176.65,55.74 176.45,55.54 arc(176.41,55.5) 176.38,55.47 175.77,54.93 arc(175.74,54.9) 175.71,54.87 175.26,54.28 arc(175.03,54.08) 174.74,53.98 174.65,53.96 arc(174.59,53.96) 174.54,53.96 174.24,53.96 arc(174.08,53.92) 173.94,53.83 173.61,53.5 arc(173.23,53.25) 172.78,53.16 170.64,53.16 arc(167.94,54.28) 166.81,56.99 arc(166.15,58.51) 164.63,59.17 154.55,59.17 arc(154.08,59.08) 153.69,58.82 arc(153.03,58.37) 152.25,58.22 148.29,58.22 arc(147.6,58.08) 147.02,57.69 146.59,57.27 146.59,57.05 146.46,56.92 146.24,56.92 145.95,56.63 145.63,56.5 145.16,56.5 145.04,56.38 144.77,56.38 144.65,56.5 144.41,56.5 arc(144.16,56.56) 143.98,56.75 143.89,56.9 arc(143.77,57.02) 143.61,57.06 143.41,57.06 arc(143.35,57.04) 143.3,56.99 143.25,56.92 arc(143.24,56.86) 143.27,56.81 v1(143.53,56.6)
CXL_RX_P14: length 91.1
  TOP w0.116: J7.A32 221.2,63.89 v6(222.08,63.89)
  L16_SIG6 w0.085: v1(140.93,58.1) 140.66,57.94 arc(140.59,57.93) 140.54,57.97 140.49,58.07 arc(140.46,58.16) 140.49,58.26 140.57,58.4 arc(140.69,58.52) 140.85,58.56 140.98,58.56 arc(141.18,58.6) 141.36,58.72 141.5,58.86 arc(141.61,58.93) 141.72,58.96 141.82,58.96 arc(141.96,58.92) 142.05,58.82 142.13,58.68 arc(142.32,58.5) 142.57,58.43 142.67,58.43 arc(142.83,58.39) 142.95,58.27 143,58.18 arc(143.18,58) 143.43,57.93 143.66,57.93 arc(143.8,57.9) 143.9,57.79 143.94,57.72 arc(144.11,57.56) 144.34,57.5 144.62,57.5 144.74,57.37 145.02,57.37 145.14,57.5 145.35,57.5 145.63,57.61 145.97,57.95 146.14,58.36 146.3,58.43 146.4,58.67 146.33,58.83 146.45,59.12 146.62,59.19 146.72,59.43 146.65,59.59 arc(147.1,59.9) 147.64,60 148.22,60 148.37,59.86 148.56,59.86 148.71,60 151.7,60 arc(152.06,60.07) 152.37,60.28 arc(152.49,60.36) 152.62,60.38 170.66,60.38 arc(171.01,60.37) 171.37,60.33 arc(171.72,60.29) 172.07,60.28 173.91,60.28 arc(174.8,60.1) 175.56,59.6 175.7,59.45 arc(176.14,59.25) 176.6,59.39 arc(176.66,59.42) 176.72,59.45 arc(176.92,59.47) 177.13,59.44 arc(177.17,59.42) 177.2,59.39 177.31,59.28 arc(177.5,59.16) 177.71,59.12 178.28,59.12 arc(178.57,59.17) 178.82,59.34 arc(179.08,59.51) 179.38,59.57 182.45,59.57 arc(182.94,59.48) 183.36,59.2 183.39,59.16 arc(184.31,58.55) 185.4,58.33 187.81,58.33 arc(189.16,58.51) 190.42,59.02 arc(190.71,59.18) 191.01,59.31 194.86,60.91 arc(194.9,60.92) 194.95,60.93 196.45,60.93 arc(197.14,60.79) 197.72,60.4 198.42,59.7 arc(198.56,59.61) 198.72,59.58 205.69,59.58 arc(205.92,59.62) 206.11,59.75 arc(206.81,60.22) 207.62,60.38 212.55,60.38 arc(213.47,60.76) 213.84,61.67 213.84,62.63 arc(213.92,63.03) 214.15,63.37 214.66,63.88 215.15,64.08 221.84,64.08 arc(221.87,64.08) 221.9,64.06 v6(222.08,63.89)
CXL_RX_P15: length 85.5
  TOP w0.116: J7.A35 v6(222.08,65.69)
  L16_SIG6 w0.085: v6(222.08,65.69) 221.9,65.86 arc(221.87,65.88) 221.84,65.88 208.51,65.88 arc(207.53,65.69) 206.69,65.13 203.51,61.95 arc(202.27,61.44) 201.04,61.95 arc(200.81,62.1) 200.55,62.15 197.19,62.15 arc(197.04,62.13) 196.91,62.07 arc(196.77,62.01) 196.63,61.99 185.34,61.99 arc(185.01,62.03) 184.71,62.14 arc(184.61,62.18) 184.5,62.2 184.17,62.2 arc(183.75,62.02) 183.58,61.61 arc(183.51,61.26) 183.31,60.96 183.25,60.9 arc(182.91,60.67) 182.5,60.59 178.69,60.59 arc(178.55,60.56) 178.43,60.48 178.36,60.41 arc(178.17,60.28) 177.95,60.24 177.05,60.24 arc(176.79,60.29) 176.57,60.44 175.87,61.14 arc(175.48,61.4) 175.02,61.49 157.12,61.49 arc(156.79,61.55) 156.51,61.74 arc(156.31,61.87) 156.08,61.92 147.84,61.92 arc(147.46,61.84) 147.14,61.63 146.91,61.4 146.91,61.23 146.73,61.05 146.56,61.05 146.21,60.7 144.93,60.17 144.63,59.87 144.63,59.7 144.42,59.48 144.24,59.48 143.97,59.21 arc(143.81,59.1) 143.61,59.06 143.41,59.06 arc(143.35,59.04) 143.3,58.99 143.27,58.94 arc(143.26,58.85) 143.31,58.78 v1(143.53,58.6)
CXL_SMB_ALERT_N: length 24.3
  TOP w0.149: J6.B9 216.05,21.29 214.79,21.29 v1(214.76,21.26)
  L07_SIG3 w0.089: v1(214.76,21.26) 212.94,21.26 209.26,17.58 209.25,17.58 209.02,17.34 204.54,17.34 204.46,17.26 203.94,17.26 203.86,17.34 203.16,17.34 202.73,16.91 200.52,16.91 199.22,18.21 199.22,19.23 197.19,21.26 v1(197.19,21.81)
  BOTTOM w0.149: U107.14 v1(197.19,21.81)
CXL_TX_C_N0: length 4.1
  TOP w0.116: C355.2 212.36,17.6 215.37,17.6 arc(215.41,17.6) 215.45,17.6 arc(215.46,17.62) 215.46,17.64 215.61,17.78 J6.B3
CXL_TX_C_N1: length 3.1
  TOP w0.116: J6.B6 215.61,19.58 215.43,19.4 213.34,19.4 C357.2
CXL_TX_C_N2: length 4.3
  TOP w0.116: C359.2 212.26,24.8 215.43,24.8 215.61,24.98 J6.B15
CXL_TX_C_N3: length 3.1
  TOP w0.116: C361.2 213.34,26.6 215.43,26.6 215.61,26.78 J6.B18
CXL_TX_C_N4: length 5.1
  TOP w0.116: C363.2 211.35,28.4 215.43,28.4 215.61,28.58 J6.B21
CXL_TX_C_N5: length 3.1
  TOP w0.116: J6.B24 215.61,30.38 215.43,30.2 213.34,30.2 C365.2
CXL_TX_C_N6: length 5.1
  TOP w0.116: J6.B33 215.61,35.78 215.43,35.6 211.35,35.6 C367.2
CXL_TX_C_N7: length 3.1
  TOP w0.116: J6.B36 215.61,37.58 215.43,37.4 213.34,37.4 C369.2
CXL_TX_C_N8: length 5.1
  TOP w0.116: J7.B3 215.61,46.49 215.43,46.31 211.35,46.31 C374.2
CXL_TX_C_N9: length 3.1
  TOP w0.116: J7.B6 215.61,48.29 215.43,48.11 213.34,48.11 C376.2
CXL_TX_C_N10: length 5.1
  TOP w0.116: C378.2 211.35,53.51 215.43,53.51 215.61,53.69 J7.B15
CXL_TX_C_N11: length 3.1
  TOP w0.116: C380.2 213.34,55.31 215.43,55.31 215.61,55.49 J7.B18
CXL_TX_C_N12: length 5.1
  TOP w0.116: C382.2 211.35,57.11 215.43,57.11 215.61,57.29 J7.B21
CXL_TX_C_N13: length 3.1
  TOP w0.116: C384.2 213.34,58.91 215.43,58.91 215.61,59.09 J7.B24
CXL_TX_C_N14: length 5.1
  TOP w0.116: C386.2 211.35,64.31 215.43,64.31 215.61,64.49 J7.B33
CXL_TX_C_N15: length 3.1
  TOP w0.116: J7.B36 216.03,66.29 215.61,66.29 215.43,66.11 213.34,66.11 C388.2
CXL_TX_C_P0: length 4.1
  TOP w0.116: C354.2 212.4,17.36 215.37,17.36 arc(215.43,17.35) 215.48,17.32 215.61,17.18 J6.B2
CXL_TX_C_P1: length 3.1
  TOP w0.116: C356.2 213.34,19.16 215.43,19.16 215.61,18.98 J6.B5
CXL_TX_C_P2: length 4.2
  TOP w0.116: J6.B14 215.61,24.38 215.43,24.56 212.19,24.56 C358.2
CXL_TX_C_P3: length 3.1
  TOP w0.116: C360.2 213.34,26.36 215.43,26.36 215.61,26.18 J6.B17
CXL_TX_C_P4: length 5.1
  TOP w0.116: C362.2 211.35,28.16 215.43,28.16 215.61,27.98 J6.B20
CXL_TX_C_P5: length 3.1
  TOP w0.116: J6.B23 215.61,29.78 215.43,29.96 213.34,29.96 C364.2
CXL_TX_C_P6: length 5.1
  TOP w0.116: J6.B32 215.61,35.18 215.43,35.36 211.35,35.36 C366.2
CXL_TX_C_P7: length 3.1
  TOP w0.116: C368.2 213.34,37.16 215.43,37.16 215.61,36.98 J6.B35
CXL_TX_C_P8: length 5.1
  TOP w0.116: J7.B2 215.61,45.89 215.43,46.07 211.35,46.07 C373.2
CXL_TX_C_P9: length 3.1
  TOP w0.116: C375.2 213.34,47.87 215.43,47.87 215.61,47.69 J7.B5
CXL_TX_C_P10: length 5.1
  TOP w0.116: C377.2 211.35,53.27 215.43,53.27 215.61,53.09 J7.B14
CXL_TX_C_P11: length 3.1
  TOP w0.116: C379.2 213.34,55.07 215.43,55.07 215.61,54.89 J7.B17
CXL_TX_C_P12: length 5.1
  TOP w0.116: C381.2 211.35,56.87 215.43,56.87 215.61,56.69 J7.B20
CXL_TX_C_P13: length 3.1
  TOP w0.116: C383.2 213.34,58.67 215.43,58.67 215.61,58.49 J7.B23
CXL_TX_C_P14: length 5.1
  TOP w0.116: J7.B32 215.61,63.89 215.43,64.07 211.35,64.07 C385.2
CXL_TX_C_P15: length 3.1
  TOP w0.116: J7.B35 215.61,65.69 215.43,65.87 213.34,65.87 C387.2
CXL_TX_N0: length 91.8
  L03_SIG1 w0.085: v2(134.86,43.59) 135.14,43.75 arc(135.18,43.81) 135.17,43.87 135.11,43.97 arc(135.07,44.08) 135.07,44.2 arc(135.1,44.31) 135.15,44.41 arc(135.19,44.47) 135.24,44.52 135.29,44.58 arc(135.48,44.7) 135.69,44.75 135.84,44.75 arc(135.99,44.72) 136.12,44.63 136.42,44.32 arc(136.47,44.28) 136.53,44.25 arc(136.58,44.23) 136.64,44.21 arc(136.69,44.2) 136.74,44.19 arc(136.91,44.14) 137.05,44.03 137.27,43.81 arc(137.34,43.77) 137.41,43.76 137.51,43.76 arc(137.69,43.72) 137.83,43.62 138.1,43.35 arc(138.2,43.29) 138.32,43.26 138.39,43.26 arc(138.52,43.29) 138.64,43.36 138.7,43.43 arc(138.84,43.55) 139,43.63 139.1,43.67 arc(139.14,43.69) 139.18,43.7 arc(139.35,43.77) 139.47,43.9 139.49,43.93 arc(139.73,44.17) 140.06,44.26 140.06,44.26 arc(140.22,44.3) 140.35,44.41 140.42,44.53 arc(140.61,44.7) 140.86,44.76 140.95,44.76 arc(141.06,44.79) 141.16,44.85 141.22,44.91 arc(141.47,45.08) 141.77,45.14 141.82,45.14 arc(142.08,45.06) 142.26,44.87 142.28,44.84 arc(142.43,44.69) 142.63,44.63 142.67,44.63 arc(142.93,44.56) 143.13,44.37 143.15,44.32 arc(143.29,44.19) 143.48,44.13 143.58,44.13 arc(143.66,44.13) 143.74,44.1 143.8,44.08 143.81,44.08 arc(143.87,44.05) 143.92,44.01 145.85,42.08 arc(146.84,41.35) 148,40.95 arc(148.04,40.94) 148.08,40.94 150.82,40.94 arc(151.16,40.93) 151.49,40.88 151.59,40.86 arc(151.65,40.84) 151.71,40.82 arc(152.64,40.31) 153.45,39.63 153.8,39.29 arc(153.82,39.25) 153.85,39.22 153.98,39.02 arc(154.42,38.45) 154.92,37.95 arc(155.77,37.27) 156.69,36.68 arc(157.88,35.9) 158.95,34.96 159.87,34.05 arc(161.94,32.66) 164.39,32.17 arc(166.84,31.78) 169.05,30.62 arc(169.47,30.28) 169.87,29.9 170.66,29.12 arc(172.18,28.1) 173.98,27.74 177.78,27.74 arc(177.85,27.74) 177.92,27.72 arc(178.02,27.69) 178.12,27.66 179.3,27.26 arc(179.53,27.16) 179.76,27.04 arc(180.31,26.79) 180.9,26.71 182.92,26.71 arc(183.88,26.61) 184.79,26.32 arc(184.87,26.28) 184.94,26.23 arc(185.14,26.12) 185.37,26.08 194.2,26.08 arc(194.78,25.96) 195.28,25.63 197.17,23.74 arc(197.87,23.27) 198.7,23.11 202.57,23.11 arc(202.95,23.18) 203.27,23.39 arc(204.39,24.14) 205.71,24.41 207.66,24.41 arc(209.43,23.67) 210.16,21.9 210.16,18.48 arc(210.21,18.24) 210.35,18.04 210.76,17.62 arc(210.81,17.6) 210.86,17.58 211.42,17.58 v2(211.64,17.8)
